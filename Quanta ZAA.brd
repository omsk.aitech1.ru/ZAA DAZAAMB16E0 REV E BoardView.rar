# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_PARITY: length 65.5
  IN1 w0.079: v2(111.12,104.53) 110.71,104.12 110.71,103.48 113.23,100.97 113.23,100.06 114.3,98.99 114.3,98.38
  IN1 w0.216: v1(119.31,49.04) 119.05,49.3 119.05,60.32 118.57,60.8 118.57,63.64 118.85,63.92 118.85,68.13 118.63,68.35 118.63,70.46 118.78,70.61 118.87,70.61 119.02,70.76 119.02,70.98 118.87,71.13 118.78,71.13 118.63,71.28 118.63,71.5 118.78,71.65 118.87,71.65 119.02,71.81 119.02,72.02 118.87,72.17 118.78,72.17 118.63,72.33 118.63,72.54 118.78,72.69 118.87,72.69 119.02,72.85 119.02,73.06 118.87,73.21 118.78,73.21 118.63,73.37 118.63,73.58 118.78,73.74 118.87,73.74 119.02,73.89 119.02,74.1 118.87,74.26 118.78,74.26 118.63,74.41 118.63,74.62 118.78,74.78 118.87,74.78 119.02,74.93 119.02,75.15 118.87,75.3 118.78,75.3 118.63,75.45 118.63,75.67 118.78,75.82 118.87,75.82 119.02,75.97 119.02,76.19 118.87,76.34 118.78,76.34 118.63,76.49 118.63,77.05 116.13,79.54 116.13,86.33 114.3,88.16 114.3,98.38
  BOTTOM w0.191: JDIM1.143 118.22,50.13 v1(119.31,49.04)
  BOTTOM w0.203: U35.AT52 v2(111.12,104.53)
M_A_RAS#: length 66.1
  IN1 w0.079: v2(112.99,103.88) 112.88,103.77 112.88,103.59 115.28,101.19 115.28,94.13 115.75,93.66 115.75,93.35
  IN1 w0.216: v1(122.47,46.63) 122.47,47.23 120.78,48.92 120.78,63.18 121.77,64.17 121.77,65.94 121.16,66.54 121.16,77.54 118.25,80.45 118.25,86.2 115.75,88.71 115.75,93.35
  BOTTOM w0.191: v1(122.47,46.63) JDIM1.152
  BOTTOM w0.203: U35.AU50 v2(112.99,103.88)
M_A_WE#: length 66.9
  IN1 w0.079: 116.97,93.47 116.97,93.68 117.04,93.75 117.17,93.75 117.58,94.16 117.58,98.97 117.15,99.4 117.15,100.84 114.43,103.56 114.43,104.1 v2(114.85,104.53)
  IN1 w0.216: 116.97,93.47 116.97,89.21 120.37,85.81 120.37,81.36 123.45,78.28 123.45,72.42 124.37,71.5 124.37,68.65 124.65,68.38 124.65,63.77 123.79,62.92 123.79,61.61 124.21,61.2 124.21,54.65 124.08,54.53 123.76,54.53 123.64,54.65 123.64,56.25 123.51,56.37 123.2,56.37 123.07,56.25 123.07,51.79 122.71,51.42 v1(122.71,50.05)
  BOTTOM w0.203: v1(122.71,50.05) 122.54,50.05 122.22,50.36 JDIM1.151 ; v2(114.85,104.53) U35.AT46
M_B_A0: length 55.8
  IN2 w0.216: v1(112.68,92.95) 112.68,90.59 111.59,89.51 111.59,76.59 114.88,73.3 114.88,69.73 114.44,69.29 114.44,66.26 114.52,66.18 114.52,64.3 114.74,64.07 114.74,58.95 115.03,58.66 115.03,55.95 115.16,55.82 115.57,55.82 115.69,55.95 115.69,56.4 115.82,56.53 116.71,56.53 117.61,57.43 v1(117.83,57.43)
  BOTTOM w0.079: v1(112.68,92.95) 113.13,92.95 v1(113.4,93.23) 114.46,94.29 114.46,97.4 114.86,97.81 114.86,99.47 115.31,99.91 115.31,101.47 U35.BA46
  BOTTOM w0.191: v1(117.83,57.43) 117.84,57.42 118.22,57.42 118.47,57.17 JDIM2.144
M_B_A1: length 56.5
  IN2 w0.079: v1(112.69,94.26) 113.14,94.26 113.33,94.46 113.33,97.07 113.39,97.13 113.54,97.13 113.59,97.08 113.59,94.28
  IN2 w0.216: 113.59,94.28 113.59,90.37 112.59,89.36 112.59,78.64 116.12,75.11 116.12,66.57 116.18,66.51 116.18,61.58 115.63,61.04 v1(115.25,61.04)
  BOTTOM w0.079: v1(112.69,94.26) 113.98,95.55 113.98,97.61 114.46,98.09 114.46,99.53 114.96,100.03 114.96,100.67 114.76,100.87 114.76,101.18 114.83,101.31 114.83,101.5 114.8,101.56 114.8,101.55 114.75,101.7 114.75,101.78 114.81,101.94 114.81,102.26 U35.AY46
  BOTTOM w0.191: v1(115.25,61.04) 116.71,61.04 116.82,61.15 116.82,61.46 116.71,61.56 115.86,61.56 115.72,61.7 JDIM2.133
M_B_A2: length 57.1
  IN2 w0.079: v1(112.68,94.91) 113.11,95.34 113.11,97.14 113.3,97.32 113.77,97.32 113.98,97.11 113.98,95.49
  IN2 w0.216: v1(115.5,58.31) 115.73,58.31 115.98,58.57 115.98,60.67 116.67,61.36 116.67,75.27 113.09,78.84 113.09,89.16 113.98,90.06 113.98,95.49
  BOTTOM w0.079: v1(112.68,94.91) 113.72,95.95 113.72,97.66 114.23,98.17 114.23,99.53 114.8,100.1 114.8,100.6 114.6,100.81 114.6,101.21 114.62,101.25 114.66,101.36 114.66,101.43 114.59,101.68 114.59,101.8 114.64,101.95 114.64,102.41 U35.AY47
  BOTTOM w0.191: JDIM2.132 115.47,56.33 115.02,56.79 115.02,58.08 115.25,58.31 v1(115.5,58.31)
M_B_A3: length 54.7
  IN2 w0.216: v1(115.25,62.31) 115.25,62.59 115.37,62.71 115.62,62.71 115.75,62.84 115.75,63.07 115.62,63.19 115.32,63.19 115.19,63.32 115.19,63.61 115.32,63.74 115.64,63.74 115.76,63.87 115.76,64.13 115.64,64.26 115.22,64.26 114.96,64.51 114.96,66.78 115.09,66.91 115.5,66.91 115.63,67.03 115.63,67.31 115.5,67.44 115.09,67.44 114.96,67.56 114.96,69.11 115.38,69.52 115.38,74.97 113.09,77.26 112.91,77.26 112.72,77.07 112.72,76.89 114.83,74.79 114.83,74.61 114.64,74.42 114.46,74.42 112.09,76.79 112.09,89.46 113.12,90.49 113.12,92.51 113.21,92.6 113.21,93.29 112.9,93.61 v1(112.68,93.61)
  BOTTOM w0.079: 113.7,94.62 114.1,94.62 114.23,94.74 114.23,97.56 114.64,97.96 114.64,99.47 115.13,99.97 115.13,100.99 U35.BB46
  BOTTOM w0.191: 113.7,94.62 113.61,94.52 113.61,94.32 113.72,94.2 113.72,93.99 113.58,93.85 113.37,93.85 113.26,93.97 113.05,93.97 112.69,93.61 v1(112.68,93.61) ; JDIM2.131 115.25,63.57 115.25,62.36 115.25,62.36 v1(115.25,62.31)
M_B_A4: length 55.5
  IN2 w0.079: 112.27,92.63 112.27,95.15 v1(112.68,95.56)
  IN2 w0.216: v1(113.97,58.07) 114.07,58.07 114.37,57.77 114.52,57.77 114.67,57.92 114.67,58.43 114.28,58.82 114.28,63.99 113.47,64.8 113.47,65.75 113.87,66.15 113.87,69.57 114.36,70.06 114.36,72.25 113.95,72.66 113.95,72.88 114.17,73.09 114.17,73.31 114.02,73.46 113.8,73.46 113.58,73.25 113.37,73.25 113.21,73.4 113.21,73.61 113.43,73.83 113.43,74.05 113.28,74.2 113.06,74.2 112.85,73.98 112.63,73.98 112.48,74.13 112.48,74.35 112.69,74.57 112.69,74.78 112.54,74.94 112.33,74.94 112.11,74.72 111.89,74.72 111.74,74.87 111.74,75.09 111.96,75.3 111.96,75.52 111.1,76.38 111.1,89.64 112.27,90.82 112.27,92.63
  BOTTOM w0.079: v1(112.68,95.56) 113.45,96.33 113.45,97.72 113.92,98.19 113.92,100.6 114.16,100.83 114.16,101.18 114.14,101.22 114.08,101.38 114.08,101.77 U35.BA47
  BOTTOM w0.191: JDIM2.128 114.47,56.98 114.61,57.12 114.61,58.36 114.48,58.49 114.1,58.49 113.97,58.36 v1(113.97,58.07)
M_B_A5: length 56.3
  IN2 w0.079: 110.81,92.62 110.81,92.85 111.31,93.35 111.31,96.79 v1(112.68,98.16)
  IN2 w0.216: 110.81,92.62 110.81,91.21 109.6,90 109.6,73.42 110.79,72.23 110.79,71.28 111.83,70.24 111.83,68.22 112.06,67.99 112.06,62.95 112.83,62.18 112.83,58.75 113.3,58.29 113.3,56.37 113.17,56.24 111.67,56.24 111.54,56.11 111.54,55.71 111.67,55.59 113.45,55.59 113.97,56.11 v1(113.97,56.8)
  BOTTOM w0.079: U35.AY48 113.71,102.17 113.43,101.88 113.43,99.8 113.31,99.69 113.31,98.79 v1(112.68,98.16)
  BOTTOM w0.191: v1(113.97,56.8) JDIM2.126
M_B_A6: length 54.8
  IN2 w0.079: 111.82,92.7 111.82,96 v1(112.68,96.86)
  IN2 w0.216: 111.82,92.7 111.82,91.02 110.59,89.79 110.59,75.31 112.83,73.07 112.83,71.8 112.95,71.68 113.18,71.68 113.31,71.8 113.31,71.9 113.43,72.02 113.74,72.02 113.87,71.9 113.87,70.27 113.04,69.44 113.04,69.21 113.18,69.07 113.27,69.07 113.39,68.94 113.39,68.68 113.27,68.55 113.14,68.55 112.98,68.4 112.98,68.18 113.14,68.03 113.39,68.03 113.54,67.88 113.54,67.66 113.39,67.51 113.14,67.51 113,67.37 113,67.07 113.13,66.94 113.34,66.94 113.47,66.81 113.47,66.45 113,65.98 113,64.2 113.13,64.07 113.57,64.07 113.7,63.94 113.7,63.68 113.57,63.56 113.13,63.56 113,63.43 113,63.28 113.81,62.47 113.81,60.1 113.65,59.94 113.42,59.94 113.26,60.1 113.26,60.96 v1(113.31,61)
  BOTTOM w0.079: U35.BA48 113.89,101.56 113.89,101.46 113.94,101.29 113.94,101.28 113.99,101.15 113.99,100.9 113.76,100.67 113.76,98.32 113.23,97.79 113.23,97.41 v1(112.68,96.86)
  BOTTOM w0.191: JDIM2.127 114.22,62.64 114.66,62.2 114.66,61.11 114.36,60.8 113.52,60.8 v1(113.31,61)
M_B_A7: length 58.3
  IN2 w0.079: 110.16,91.12 110.39,91.34 110.39,92.81 111.09,93.52 111.09,97.47 112.49,98.87 112.49,103.96 112.61,104.09 112.61,105.5 v2(112.99,105.88)
  IN2 w0.216: 110.16,91.12 109.1,90.06 109.1,73.22 110.3,72.03 110.3,69.01 110.42,68.88 110.69,68.88 110.82,69.01 110.82,70.03 110.95,70.16 111.21,70.16 111.34,70.03 111.34,68.27 111.21,68.15 110.95,68.15 110.82,68.02 110.82,67.73 110.95,67.6 111.46,67.6 111.59,67.47 111.59,66.81 111.34,66.56 111.34,66.29 111.59,66.04 111.59,62.76 112.36,61.99 112.36,58.18 v1(112.47,58.07)
  BOTTOM w0.127: U35.AP48 v2(112.99,105.88)
  BOTTOM w0.191: v1(112.47,58.07) 112.7,58.07 112.97,57.79 JDIM2.122
M_B_A8: length 53.6
  IN2 w0.079: 111.32,92.68 111.32,92.92 111.55,93.15 111.55,96.38 v1(112.68,97.51)
  IN2 w0.216: 111.32,92.68 111.32,91.13 110.09,89.9 110.09,73.63 111.29,72.44 111.29,71.48 111.44,71.33 111.69,71.33 111.79,71.43 111.79,72.67 110.82,73.64 110.82,73.85 110.98,74.01 111.19,74.01 112.33,72.87 112.33,70.77 112.46,70.64 112.72,70.64 112.85,70.77 112.85,70.95 112.98,71.07 113.24,71.07 113.37,70.95 113.37,70.47 112.92,70.02 112.46,70.02 112.33,69.9 112.33,68.48 112.53,68.28 112.53,63.06 v1(113.31,62.27)
  BOTTOM w0.079: v1(112.68,97.51) 113.48,98.31 113.48,99.62 113.59,99.73 113.59,100.84 113.71,100.96 U35.BB48
  BOTTOM w0.191: JDIM2.125 113.72,62.63 114.28,62.07 114.28,61.87 114.14,61.73 113.94,61.73 113.39,62.27 v1(113.31,62.27)
M_B_A9: length 54.7
  IN2 w0.079: v1(112.09,105.8) 111.67,105.38 111.67,101.69 111.39,101.41 111.39,99.72 109.82,98.16 109.82,92.16 109.38,91.71
  IN2 w0.216: 109.38,91.71 108.1,90.43 108.1,72.82 109.31,71.61 109.31,68.58 109.85,68.04 109.85,64.9 110.64,64.1 110.64,62.38 111.44,61.58 111.44,60.08 111.05,59.7 v1(110.95,59.7)
  BOTTOM w0.191: JDIM2.121 112.72,61.4 111.03,59.7 v1(110.95,59.7)
  BOTTOM w0.203: U35.AP50 v1(112.09,105.8)
M_B_A10: length 56.2
  IN2 w0.216: v1(121.49,56.82) 121.12,56.82 120.99,56.95 120.99,57.68 120.87,57.81 120.56,57.81 120.44,57.68 120.44,56.44 120.31,56.32 120,56.32 119.87,56.44 119.87,59.19 120.5,59.82 120.5,62.17 121.44,63.11 121.44,75.51 120.81,76.15 120.81,78.9 117.65,82.06 117.65,89.67 115.73,91.6 v1(115.73,94.32)
  BOTTOM w0.079: v1(115.73,94.32) 115.6,94.32 114.65,95.27 114.65,97.34 115.12,97.81 115.12,99.49 115.47,99.84 115.47,101.81 115.24,102.04 115.24,102.46 115.14,102.66 115.13,102.66 114.94,102.85 U35.AW46
  BOTTOM w0.191: v1(121.49,56.82) 121.44,56.82 120.97,56.36 JDIM2.146
M_B_A11: length 58.6
  IN2 w0.079: v2(112.99,106.5) 112.58,106.09 112.58,105.7 112.45,105.57 112.45,104.16 112.32,104.03 112.32,100.22 110.06,97.95 110.06,91.59 109.91,91.45
  IN2 w0.216: v1(112.47,56.8) 112.08,56.8 111.89,56.98 111.89,58.36 111.74,58.51 110.21,58.51 110.08,58.64 110.08,58.9 110.21,59.03 111.74,59.03 111.89,59.18 111.89,61.79 110.96,62.72 110.96,64.33 110.37,64.92 110.37,68.18 109.8,68.74 109.8,71.82 108.61,73.01 108.61,90.15 109.91,91.45
  BOTTOM w0.127: U35.AN48 v2(112.99,106.5)
  BOTTOM w0.191: JDIM2.120 v1(112.47,56.8)
M_B_A12: length 57.9
  IN2 w0.079: 108.91,91.95 108.91,97.74 111.09,99.92 111.09,101.48 111.51,101.89 111.51,106.26 111.7,106.45 v2(112.09,106.45)
  IN2 w0.216: 108.91,91.95 107.6,90.64 107.6,72.59 108.12,72.06 108.12,71.33 108.28,71.18 108.68,71.18 108.81,71.05 108.81,70.78 108.68,70.66 108.28,70.66 108.12,70.5 108.12,70.29 108.28,70.14 108.65,70.14 108.78,70.01 108.78,69.74 108.65,69.61 108.28,69.61 108.12,69.46 108.12,69.25 108.28,69.09 108.66,69.09 108.79,68.97 108.79,68.7 108.66,68.57 108.28,68.57 108.12,68.42 108.12,68.01 108.74,67.39 108.74,63.56 108.87,63.43 109.21,63.43 109.34,63.56 109.34,64.2 109.46,64.32 109.88,64.32 110.01,64.2 110.01,62.31 110.95,61.36 v1(110.95,61.02)
  BOTTOM w0.191: v1(110.95,61.02) 111.05,61.02 112.22,62.19 JDIM2.119
  BOTTOM w0.203: v2(112.09,106.45) U35.AN50
M_B_A13: length 53.3
  IN2 w0.079: v1(116.92,95.62) 117.64,94.9 117.64,92.99 117.92,92.71
  IN2 w0.216: v1(123.68,58.32) 122.9,59.1 122.9,60.58 123.72,61.4 123.72,62.03 125.15,63.47 125.15,69.59 125.35,69.79 125.35,79.89 121.57,83.68 121.57,89.05 117.92,92.71
  BOTTOM w0.079: v1(116.92,95.62) 116.51,96.03 116.51,97.67 116.17,98.02 116.17,99.14 116.47,99.43 116.47,99.65 117.12,100.31 117.12,100.67 116.96,100.84 116.96,100.96 116.96,100.97 116.96,101.22 117.01,101.36 117.01,101.47 116.95,101.63 116.95,101.84 U35.BA43
  BOTTOM w0.191: JDIM2.158 123.97,56.59 124.49,57.1 124.49,58.21 124.38,58.32 v1(123.68,58.32)
M_B_ACT#: length 56.2
  IN2 w0.079: v1(110.26,106.46) 109.82,106.02 109.82,105.69 108.97,104.84 108.97,103.36 109.06,103.27 109.06,102.93
  IN2 w0.216: 109.06,102.93 109.06,99.7 108.05,98.69 108.05,92.82 105.29,90.07 105.29,67.97 106.22,67.04 106.22,64.38 108.22,62.38 108.22,60.99 108.76,60.45 108.76,59.04 111,56.8 v1(111.08,56.8)
  BOTTOM w0.165: v1(110.26,106.46) U35.AN53
  BOTTOM w0.191: v1(111.08,56.8) 110.97,56.7 JDIM2.114
M_B_ALERT#: length 64.2
  TOP w0.191: v2(115.78,106.5) 115.32,106.95 115.32,107.45 R11044.1
  IN2 w0.079: 115.73,90.35 115.15,90.93 115.15,102.56 115.37,105.14 115.37,105.64 115.78,106.04 v2(115.78,106.5)
  IN2 w0.216: v1(111.4,53.97) 113.99,54.78 116.58,54.78 118.89,57.09 118.89,59.32 119.94,60.38 119.94,68.41 119.72,68.64 119.72,69.24 119.23,69.73 119.23,77.64 115.92,80.95 115.92,90.16 115.73,90.35
  BOTTOM w0.079: v2(115.78,106.5) 116.08,106.8 U35.AN43
  BOTTOM w0.191: JDIM2.116 111.47,54.05 v1(111.4,53.97)
M_B_BA#0: length 56
  IN2 w0.079: v1(115.73,96.92) 116.48,96.17 116.48,92.48 116.78,92.18
  IN2 w0.216: v1(121.49,58.09) 121.93,58.09 122.06,57.97 122.06,55.82 122.2,55.67 122.41,55.67 122.55,55.82 122.55,58.22 121.96,58.81 121.96,62.17 123.12,63.33 123.12,68.29 123.27,68.44 123.27,70.17 123.51,70.42 123.51,79.12 119.72,82.91 119.72,89.25 116.78,92.18
  BOTTOM w0.079: U35.BB44 115.96,100.98 115.96,99.63 115.67,99.34 115.67,96.97 v1(115.73,96.92)
  BOTTOM w0.191: JDIM2.150 121.97,57.8 121.69,58.09 v1(121.49,58.09)
M_B_BA#1: length 56
  IN2 w0.079: 116.59,91.95 116.29,92.24 116.29,95.05 v1(115.73,95.62)
  IN2 w0.216: v1(121.49,60.86) 121.32,61.03 121.32,62.01 122.79,63.49 122.79,63.79 122.67,63.9 122.24,63.9 122.13,64.02 122.13,64.18 122.24,64.3 122.67,64.3 122.79,64.41 122.79,76.07 122.46,76.4 122.46,76.73 122.79,77.06 122.79,77.36 122.59,77.57 122.36,77.57 122.15,77.77 122.15,78.12 122.33,78.3 122.59,78.3 122.79,78.51 122.79,78.82 118.99,82.61 118.99,89.54 116.59,91.95
  BOTTOM w0.079: U35.BA44 115.92,101.74 115.8,101.61 115.8,99.7 115.51,99.41 115.51,97.69 115.31,97.49 115.31,96.04 v1(115.73,95.62)
  BOTTOM w0.203: v1(121.49,60.86) 120.99,60.86 120.78,60.66 120.78,58.65 120.6,58.47 120.33,58.47 120.15,58.65 120.15,61.31 120.72,61.89 JDIM2.145
M_B_BG#0: length 57
  IN2 w0.079: 110.55,103.4 110.67,103.52 110.67,105.38 v2(111.12,105.83)
  IN2 w0.216: 110.55,103.4 110.21,103.06 110.21,101.74 110.52,101.43 110.52,100.07 108.67,98.22 108.67,92.3 106.74,90.37 106.74,68.57 108.26,67.05 108.26,63.49 109.9,61.85 109.9,59.99 109.62,59.71 v1(109.38,59.71)
  BOTTOM w0.203: v1(109.38,59.71) 109.43,59.71 109.68,59.45 109.68,59.05 109.89,58.85 110.09,58.85 110.29,59.05 110.29,61.37 111.22,62.3 JDIM2.115 ; U35.AP52 v2(111.12,105.83)
M_B_BG#1: length 57.4
  IN2 w0.079: 109.78,103.4 109.78,105.24 110.04,105.49 110.04,105.81 110.17,105.94 110.58,105.94 v2(111.12,106.48)
  IN2 w0.216: v1(109.38,60.98) 109.38,61.85 107.06,64.16 107.06,67.22 106.02,68.27 106.02,90.16 108.37,92.51 108.37,98.42 110.06,100.12 110.06,101.21 109.78,101.49 109.78,103.4
  BOTTOM w0.203: v1(109.38,60.98) 109.2,60.8 109.19,60.8 108.87,60.49 108.87,59.89 108.67,59.68 108.46,59.68 108.26,59.89 108.26,60.68 109.41,61.82 110.22,61.82 110.72,62.33 JDIM2.113 ; U35.AN52 v2(111.12,106.48)
M_B_CAS#: length 56.7
  IN2 w0.079: v1(116.92,94.97) 117.36,94.53 117.36,92.7 117.58,92.47
  IN2 w0.216: v1(123.68,57.05) 123.88,56.85 123.88,55.72 123.68,55.52 123.26,55.52 123.09,55.68 123.09,58.29 122.43,58.96 122.43,60.67 123.25,61.49 123.25,62.05 124.64,63.45 124.64,69.77 124.86,69.99 124.86,79.69 121.06,83.48 121.06,88.99 117.58,92.47
  BOTTOM w0.079: U35.AY43 116.54,102.42 116.54,102.32 116.45,102.16 116.45,101.97 116.51,101.79 116.51,101.71 116.43,101.43 116.43,101.37 116.51,101.19 116.51,100.87 116.3,100.66 116.3,99.5 116,99.21 116,97.95 116.32,97.63 116.32,95.23 116.58,94.97 v1(116.92,94.97)
  BOTTOM w0.191: v1(123.68,57.05) 123.47,56.85 JDIM2.156
M_B_CB0: length 6.2
  TOP w0.127: v1(106.36,57.38) 105.72,56.75 v1(105.72,55.26) 104.96,54.5 R10931.2
  BOTTOM w0.127: v1(106.36,57.38) 105.92,57.38 105.44,56.9 105.44,56.46 105.47,56.43 JDIM2.92
M_B_CB1: length 3.9
  TOP w0.127: R10936.2 104.59,60.72 v1(104.32,60.98)
  BOTTOM w0.127: v1(104.32,60.98) 105.22,61.88 JDIM2.91
M_B_CB2: length 3.5
  TOP w0.127: v1(107.65,62.25) 108.16,62.76 R10933.2
  BOTTOM w0.127: JDIM2.101 107.72,62.32 v1(107.65,62.25)
M_B_CB3: length 5.8
  TOP w0.127: v1(107.63,66.42) 108.29,67.08 R10939.2
  BOTTOM w0.127: v1(107.63,66.42) 108.03,66.42 108.72,65.72 JDIM2.105
M_B_CB4: length 2.8
  TOP w0.127: v1(104.37,56.75) v1(104.84,56.28) R10941.2
  BOTTOM w0.127: JDIM2.88 104.47,56.65 v1(104.37,56.75)
M_B_CB5: length 5.1
  TOP w0.127: v1(104.32,62.25) 105.04,61.53 105.04,59.33 104.92,59.2 R10922.2
  BOTTOM w0.127: JDIM2.87 104.22,62.35 v1(104.32,62.25)
M_B_CB6: length 5.9
  TOP w0.127: v1(107.65,56.8) 107.65,56.3 v1(107.35,56) 104.84,53.5 R10942.2
  BOTTOM w0.127: v1(107.65,56.8) 107.47,56.62 JDIM2.100
M_B_CB7: length 5.1
  TOP w0.127: R10925.2 v1(108.15,58.57) v1(107.65,58.07)
  BOTTOM w0.127: v1(107.65,58.07) 108.47,57.24 JDIM2.104
M_B_CKE0: length 55
  IN2 w0.079: 107.96,103.59 107.96,105.92 v2(108.5,106.46)
  IN2 w0.216: v1(107.65,60.17) 106.85,60.17 106.02,61.01 106.02,63.12 104.83,64.3 104.83,66.47 103.95,67.36 103.95,89.97 106.42,92.44 106.42,99.29 106.83,99.71 107.25,100.09 107.96,100.8 107.96,103.59
  BOTTOM w0.079: U35.AN56 v2(108.5,106.46)
  BOTTOM w0.191: v1(107.65,60.17) 107.65,60.63 109.72,62.71 JDIM2.109
M_B_CKE1: length 55.3
  IN2 w0.079: v1(109.38,105.82) 108.81,105.25 108.81,103.64 108.55,103.38 108.55,103.26
  IN2 w0.191: 107.87,100.16 108.55,100.84 108.55,103.26
  IN2 w0.216: 107.87,100.16 106.83,99.12 106.83,92.37 104.44,89.98 104.44,67.61 105.35,66.71 105.35,64.59 107.18,62.76 107.18,61.41 108.28,60.31 108.28,58.75 v1(109.38,57.69)
  BOTTOM w0.079: v1(109.38,105.82) 109.71,106.15 U35.AP55
  BOTTOM w0.191: JDIM2.110 109.97,57.09 v1(109.38,57.69)
M_B_CLK0: length 59.5
  IN2 w0.079: v2(114.81,106.48) 115.13,106.48 115.22,106.39 115.22,106.18 114.97,105.93 114.7,105.93 114.31,105.54 114.31,101.56 113.76,101.01 113.76,98.61 114.79,97.58 114.79,90.3 114.86,90.23 114.86,90.16
  IN2 w0.114: 114.86,90.16 115.16,89.87 115.16,89.47 114.65,88.96 114.65,79.49 115.19,78.95 115.53,78.95 115.92,79.34 116.08,79.34 116.36,79.06 116.36,78.9 115.97,78.51 115.97,78.17 116.08,78.05 116.42,77.71 116.76,77.71 117.15,78.1 117.32,78.1 117.59,77.82 117.59,77.66 117.2,77.27 117.2,76.93 118.22,75.92 118.22,68.75 118.63,68.34 118.65,68.32 118.65,63.65 117.94,62.94 117.94,60.83 118.18,60.58 118.53,60.58 118.77,60.82 118.77,61.5 118.85,61.58 118.97,61.58 v1(119.18,61.37)
  BOTTOM w0.114: v1(119.18,61.37) 119.18,61.77 119.05,61.91 117.19,61.91 116.92,62.18 116.92,62.29 116.9,62.4 116.77,62.5 116.72,62.55 JDIM2.137
  BOTTOM w0.127: U35.AP45 115.14,106.15 v2(114.81,106.48)
M_B_CLK0#: length 59.5
  IN2 w0.079: v1(115.78,107.17) 115.36,106.75 115.36,106.48 115.38,106.46 115.38,106.12 115.08,105.82 115.03,105.77 114.76,105.77 114.47,105.48 114.47,101.5 113.92,100.95 113.92,98.67 114.95,97.64 114.95,90.38 115.02,90.31
  IN2 w0.114: 115.02,90.31 115.37,89.96 115.37,89.38 114.86,88.87 114.86,79.58 115.28,79.16 115.44,79.16 115.83,79.56 116.17,79.56 116.57,79.15 116.57,78.81 116.18,78.42 116.18,78.26 116.23,78.21 116.51,77.93 116.67,77.93 117.06,78.32 117.41,78.32 117.81,77.91 117.81,77.57 117.42,77.18 117.42,77.02 118.43,76.01 118.43,68.87 118.86,68.44 118.86,63.54 118.16,62.84 118.16,60.92 118.28,60.81 118.44,60.81 118.54,60.91 118.54,61.59 119.18,62.23 v1(119.18,62.64)
  BOTTOM w0.079: U35.AN45 115.41,106.8 v1(115.78,107.17)
  BOTTOM w0.114: v1(119.18,62.64) 118.66,62.12 117.28,62.12 117.13,62.27 117.13,62.31 117.12,62.42 117.22,62.56 JDIM2.139
M_B_CLK1: length 59.2
  IN2 w0.079: v2(113.93,105.83) 113.54,105.43 113.54,103.35 113.83,103.05 113.88,103.01 113.88,102.93 113.89,102.92 113.89,101.77 113.42,101.3 113.42,98.52 113.43,98.5
  IN2 w0.114: 113.43,98.5 114.52,97.41 114.52,89.52 114.01,89 114.01,79.19 117.51,75.69 117.51,75.69 117.58,75.62 117.58,65.05 117.72,64.91 117.96,64.91 118.21,64.66 118.21,64.07 117.99,63.84 117.77,63.84 117.58,63.65 117.58,61.37 116.66,60.44 116.66,60.11 116.77,59.99 117.11,59.99 117.35,59.74 117.35,59.32 117.12,59.08 116.78,59.08 116.66,58.96 116.66,58.71 116.81,58.56 117.85,58.56 117.99,58.7 117.99,59.18 v1(117.83,59.34)
  BOTTOM w0.114: v1(117.83,59.34) 117.83,59 117.66,58.82 117.35,58.82 116.9,58.36 116.9,56.79 116.97,56.71 JDIM2.138
  BOTTOM w0.127: U35.AP46 v2(113.93,105.83)
M_B_CLK1#: length 59.2
  IN2 w0.079: 113.26,98.4 113.26,101.38 113.72,101.84 113.72,102.94 113.38,103.28 113.38,105.5 113.51,105.62 113.51,106.05 v2(113.93,106.48)
  IN2 w0.114: v1(117.83,58.07) 117.57,58.33 116.71,58.33 116.43,58.61 116.43,59.03 116.71,59.31 117.03,59.31 117.13,59.41 117.13,59.65 117.01,59.76 116.68,59.76 116.43,60.01 116.43,60.54 117.35,61.46 117.35,63.74 117.67,64.06 117.87,64.06 117.98,64.16 117.98,64.56 117.86,64.69 117.64,64.69 117.35,64.97 117.35,75.54 113.79,79.1 113.79,89.09 114.31,89.61 114.31,97.36 113.26,98.4
  BOTTOM w0.114: JDIM2.140 117.47,56.52 117.11,56.88 117.11,58.27 117.44,58.6 117.63,58.6 117.83,58.41 v1(117.83,58.07)
  BOTTOM w0.127: U35.AN46 v2(113.93,106.48)
M_B_CS#0: length 56.4
  IN2 w0.079: v1(116.75,98.87) 116.95,98.87 118.74,97.08 118.74,93.35 119.21,92.88 119.88,92.88 119.97,92.79
  IN2 w0.216: 119.97,92.79 123.83,88.93 123.83,84.8 128.19,80.44 128.19,76.78 129.23,75.74 129.23,70.55 127.49,68.8 127.49,63.32 126.33,62.16 126.33,59.86 125.74,59.28 123.98,59.28 v1(123.68,59.58)
  BOTTOM w0.079: v1(116.75,98.87) 116.82,98.94 116.82,99.51 117.49,100.18 117.49,100.82 117.39,100.92 U35.BB42
  BOTTOM w0.191: v1(123.68,59.58) 123.45,59.58 121.72,61.31 JDIM2.149
M_B_CS#1: length 58.5
  IN2 w0.079: 119.14,92.04 117.91,93.27 117.91,96.02 117.65,96.27 v2(116.92,96.27)
  IN2 w0.216: v1(124.82,61.93) 124.77,61.88 124.77,60.94 124.59,60.75 124.32,60.75 124.14,60.94 124.14,62.01 125.59,63.46 125.59,68.66 125.98,69.05 125.98,69.4 126.08,69.49 126.08,70.71 126.29,70.92 126.46,70.92 126.65,71.11 126.65,71.38 126.46,71.57 126.31,71.57 126.12,71.76 126.12,72.03 126.31,72.22 126.52,72.22 126.71,72.41 126.71,72.68 126.52,72.87 126.29,72.87 126.08,73.08 126.08,73.38 126.29,73.59 126.5,73.59 126.7,73.79 126.7,74.04 126.5,74.24 126.28,74.24 126.09,74.43 126.09,74.7 126.28,74.89 126.51,74.89 126.7,75.08 126.7,75.34 126.51,75.53 126.28,75.53 126.09,75.72 126.09,75.99 126.28,76.18 126.51,76.18 126.7,76.37 126.7,76.64 126.51,76.83 126.31,76.83 126.12,77.02 126.12,77.29 126.31,77.48 126.52,77.48 126.71,77.67 126.71,77.94 126.52,78.12 126.28,78.12 126.09,78.31 126.09,78.58 126.28,78.77 126.52,78.77 126.71,78.96 126.71,79.23 126.52,79.42 126.29,79.42 126.08,79.64 126.08,80.19 122.31,83.96 122.31,88.87 119.14,92.04
  BOTTOM w0.079: v2(116.92,96.27) 116.93,96.27 117.31,96.65 117.32,96.65 117.54,96.87 117.54,99.76 117.84,100.07 117.84,101.18 117.81,101.26 117.81,101.27 117.69,101.57 117.69,102.09 U35.AY42
  BOTTOM w0.191: JDIM2.157 123.72,62.16 124.44,61.44 125.01,61.44 125.05,61.49 125.35,61.49 125.48,61.62 125.48,61.8 125.35,61.93 v1(124.82,61.93)
M_B_DQ0: length 84.9
  IN2 w0.079: v1(104.41,110.71) 103.72,111.4 102.05,111.4 101.4,112.06 100.31,112.06 98.59,113.78 97.57,113.78 96.9,114.45 96.64,114.45
  IN2 w0.14: 96.64,114.45 88.33,114.45 80.55,106.67 80.55,66.44 80.66,66.32 80.86,66.32 80.98,66.21 80.98,66.04 80.86,65.93 80.66,65.93 80.55,65.81 80.55,65.65 80.66,65.54 80.96,65.54 81.08,65.42 81.08,65.26 80.96,65.14 80.66,65.14 80.55,65.03 80.55,64.86 80.66,64.75 80.97,64.75 81.08,64.63 81.08,64.47 80.97,64.35 80.66,64.35 80.55,64.24 80.55,64.08 80.66,63.96 80.91,63.96 81.03,63.85 81.03,63.68 80.91,63.57 80.66,63.57 80.55,63.45 80.55,63.11 83.48,60.18 83.48,59.07 v1(83.95,58.6)
  BOTTOM w0.079: v1(104.41,110.71) U35.AF65
  BOTTOM w0.127: v1(83.95,58.6) 83.47,58.13 JDIM2.4
M_B_DQ1: length 83.6
  IN2 w0.079: v1(105.06,110.71) 104.16,111.61 102.19,111.61 101.54,112.26 100.39,112.26 98.69,113.95 97.73,113.95 97,114.68
  IN2 w0.14: 97,114.68 96.9,114.78 88.14,114.78 80.19,106.83 80.19,62.79 82.99,59.99 82.99,58.29 v1(83.95,57.33)
  BOTTOM w0.079: v1(105.06,110.71) U35.AF64
  BOTTOM w0.127: JDIM2.8 84.47,56.81 v1(83.95,57.33)
M_B_DQ2: length 83.9
  IN2 w0.079: 90.1,112.85 90.3,113.05 96.86,113.05 97.08,112.83 98.14,112.83 101.28,109.7 101.96,109.7 102.78,108.88 v1(103.76,108.88)
  IN2 w0.14: 90.1,112.85 82.84,105.58 82.84,81.23 83.58,80.48 83.58,72.02 83.74,71.86 84.36,71.86 84.48,71.74 84.48,71.58 84.36,71.47 83.74,71.47 83.63,71.35 83.63,71.19 83.74,71.07 84.5,71.07 84.61,70.96 84.61,70.79 84.5,70.68 83.74,70.68 83.63,70.56 83.63,70.4 83.74,70.28 84.5,70.28 84.61,70.17 84.61,70.01 84.5,69.89 83.74,69.89 83.63,69.78 83.63,69.61 83.74,69.5 84.5,69.5 84.61,69.38 84.61,64.69 86,63.3 86,58.04 86.62,57.42 v1(86.92,57.42)
  BOTTOM w0.079: U35.AK65 v1(103.76,108.88)
  BOTTOM w0.127: v1(86.92,57.42) 87.47,56.87 JDIM2.20
M_B_DQ3: length 84.8
  IN2 w0.079: 90.43,112.67 90.57,112.81 96.76,112.81 96.94,112.62 98.07,112.62 101.19,109.5 101.87,109.5 102.92,108.45 104.65,108.45 v2(105.06,108.04)
  IN2 w0.14: v1(86.92,60.98) 86.7,60.98 86.33,61.35 86.33,63.48 84.96,64.85 84.96,72.5 84.84,72.61 84.08,72.61 83.97,72.73 83.97,72.89 84.08,73 84.84,73 84.96,73.12 84.96,73.28 84.84,73.4 84.08,73.4 83.97,73.51 83.97,73.68 84.08,73.79 84.84,73.79 84.96,73.91 84.96,74.07 84.84,74.19 84.08,74.19 83.97,74.3 83.97,74.46 84.08,74.58 84.84,74.58 84.96,74.69 84.96,74.86 84.84,74.97 84.08,74.97 83.97,75.09 83.97,75.25 84.08,75.37 84.72,75.37 84.83,75.48 84.83,75.65 84.72,75.76 84.08,75.76 83.97,75.88 83.97,76.04 84.08,76.15 84.65,76.15 84.77,76.27 84.77,76.43 84.65,76.55 84.08,76.55 83.97,76.66 83.97,80.58 83.19,81.36 83.19,105.43 90.43,112.67
  BOTTOM w0.079: U35.AK64 v2(105.06,108.04)
  BOTTOM w0.127: v1(86.92,60.98) 87.43,61.49 87.43,62.38 87.72,62.67 JDIM2.21
M_B_DQ4: length 84.4
  IN2 w0.079: v1(103.76,110.71) 103.32,111.15 100.94,111.15 98.5,113.6 97.48,113.6 96.94,114.14 96.63,114.14
  IN2 w0.14: 96.63,114.14 88.52,114.14 80.9,106.52 80.9,71.75 81.01,71.65 81.45,71.65 81.56,71.54 81.56,71.37 81.45,71.26 81.01,71.26 80.89,71.14 80.89,70.98 81.01,70.86 81.45,70.86 81.56,70.75 81.56,70.58 81.45,70.47 81.01,70.47 80.89,70.35 80.89,70.19 81.01,70.08 81.45,70.08 81.56,69.96 81.56,69.8 81.45,69.68 81.01,69.68 80.89,69.57 80.89,69.4 81.01,69.29 81.45,69.29 81.56,69.17 81.56,69.01 81.45,68.89 81.01,68.89 80.89,68.78 80.89,68.62 81.01,68.5 81.45,68.5 81.56,68.39 81.56,68.22 81.45,68.11 81.01,68.11 80.89,67.99 80.89,67.83 81.01,67.71 81.45,67.71 81.56,67.6 81.56,67.44 81.45,67.32 81.01,67.32 80.89,67.2 80.89,67.04 81.01,66.93 81.45,66.93 81.56,66.81 81.56,62.81 83.43,60.94 v1(83.54,60.94)
  BOTTOM w0.079: v1(103.76,110.71) U35.AF66
  BOTTOM w0.127: v1(83.54,60.94) 83.58,60.94 84.22,61.58 JDIM2.7
M_B_DQ5: length 83.6
  IN2 w0.079: v1(103.11,110.71) 102.98,110.85 100.97,110.85 98.4,113.42 97.34,113.42 96.94,113.82 96.69,113.82
  IN2 w0.102: v1(83.54,62.21) 82.86,62.89
  IN2 w0.14: 82.86,62.89 81.91,63.85 81.91,71.97 81.73,72.15 81.46,72.15 81.35,72.26 81.35,72.43 81.46,72.54 81.79,72.54 81.91,72.66 81.91,72.82 81.79,72.93 81.36,72.93 81.25,73.05 81.25,73.21 81.36,73.33 81.79,73.33 81.91,73.44 81.91,73.61 81.79,73.72 81.36,73.72 81.25,73.84 81.25,74 81.36,74.12 81.79,74.12 81.91,74.23 81.91,74.39 81.79,74.51 81.36,74.51 81.25,74.62 81.25,74.79 81.36,74.9 81.79,74.9 81.91,75.02 81.91,75.18 81.79,75.3 81.36,75.3 81.25,75.41 81.25,75.58 81.36,75.69 81.79,75.69 81.91,75.81 81.91,75.97 81.79,76.08 81.36,76.08 81.25,76.2 81.25,76.36 81.36,76.48 81.79,76.48 81.91,76.59 81.91,76.76 81.79,76.87 81.36,76.87 81.25,76.99 81.25,77.15 81.36,77.27 81.79,77.27 81.91,77.38 81.91,77.54 81.79,77.66 81.36,77.66 81.25,77.77 81.25,77.94 81.36,78.05 81.79,78.05 81.91,78.17 81.91,78.33 81.79,78.45 81.36,78.45 81.25,78.56 81.25,78.72 81.36,78.84 81.79,78.84 81.91,78.96 81.91,79.12 81.79,79.23 81.36,79.23 81.25,79.35 81.25,79.51 81.36,79.63 81.67,79.63 81.78,79.74 81.78,79.91 81.67,80.02 81.36,80.02 81.26,80.12 81.26,106.37 88.71,113.82 96.69,113.82
  BOTTOM w0.079: v1(103.11,110.71) U35.AF67
  BOTTOM w0.127: v1(83.54,62.21) 83.22,62.53 JDIM2.3
M_B_DQ6: length 82.4
  IN2 w0.079: v1(103.11,107.97) 103.11,107.97 101.8,109.29 101.11,109.29 97.96,112.44 96.88,112.44 96.73,112.59 90.87,112.59 90.7,112.41
  IN2 w0.14: 90.7,112.41 83.55,105.26 83.55,81.49 84.51,80.53 84.51,77.18 85.3,76.39 85.3,72.97 85.41,72.86 85.57,72.86 85.69,72.74 85.69,72.58 85.57,72.46 85.41,72.46 85.3,72.35 85.3,72.18 85.41,72.07 85.93,72.07 86.04,71.95 86.04,71.79 85.93,71.67 85.41,71.67 85.3,71.56 85.3,71.4 85.41,71.28 85.93,71.28 86.04,71.17 86.04,71 85.93,70.89 85.41,70.89 85.3,70.77 85.3,70.61 85.41,70.49 85.93,70.49 86.04,70.38 86.04,70.22 85.93,70.1 85.41,70.1 85.3,69.98 85.3,69.82 85.41,69.71 85.93,69.71 86.04,69.59 86.04,69.43 85.93,69.31 85.41,69.31 85.3,69.2 85.3,69.03 85.41,68.92 85.93,68.92 86.04,68.8 86.04,68.64 85.93,68.53 85.41,68.53 85.3,68.41 85.3,68.25 85.41,68.13 85.93,68.13 86.04,68.02 86.04,67.85 85.93,67.74 85.41,67.74 85.3,67.62 85.3,67.46 85.41,67.34 85.93,67.34 86.04,67.23 86.04,67.07 85.93,66.95 85.41,66.95 85.3,66.84 85.3,66.67 85.41,66.56 85.93,66.56 86.04,66.44 86.04,66.28 85.93,66.16 85.41,66.16 85.3,66.05 85.3,65.88 85.41,65.77 85.93,65.77 86.04,65.65 86.04,65.49 85.93,65.38 85.41,65.38 85.3,65.26 85.3,65.02 86.92,63.39 v1(86.92,62.25)
  BOTTOM w0.079: U35.AK67 v1(103.11,107.97)
  BOTTOM w0.127: JDIM2.17 86.72,62.45 v1(86.92,62.25)
M_B_DQ7: length 83.1
  IN2 w0.079: v1(103.76,107.97) 103.33,107.54 102.95,107.54 102.6,107.89 102.6,108.17 101.71,109.06 101.02,109.06 97.86,112.23 96.71,112.23 96.55,112.38 91.16,112.38 91.01,112.23
  IN2 w0.14: v1(86.92,58.69) 87.17,58.69 87.41,58.93 87.41,63.42 86.42,64.41 86.42,73.42 86.3,73.54 85.76,73.54 85.64,73.65 85.64,73.81 85.76,73.93 86.3,73.93 86.42,74.04 86.42,74.21 86.3,74.32 85.76,74.32 85.64,74.44 85.64,74.6 85.76,74.72 86.3,74.72 86.42,74.83 86.42,74.99 86.3,75.11 85.76,75.11 85.64,75.23 85.64,75.39 85.76,75.5 86.3,75.5 86.42,75.62 86.42,75.78 86.3,75.9 85.76,75.9 85.64,76.01 85.64,76.18 85.76,76.29 86.3,76.29 86.42,76.41 86.42,76.57 86.3,76.68 85.49,76.68 84.9,77.27 84.9,80.61 83.9,81.62 83.9,105.12 91.01,112.23
  BOTTOM w0.079: U35.AK66 v1(103.76,107.97)
  BOTTOM w0.127: JDIM2.16 86.47,58.24 v1(86.92,58.69)
M_B_DQ8: length 70.9
  IN2 w0.14: v1(88.72,62.28) 88.72,63.08 87.53,64.27 87.53,66.93 87.42,67.05 87.18,67.05 87.06,67.16 87.06,67.32 87.18,67.44 87.42,67.44 87.53,67.56 87.53,67.72 87.42,67.83 87.18,67.83 87.06,67.95 87.06,68.11 87.18,68.23 87.42,68.23 87.53,68.34 87.53,68.51 87.42,68.62 87.18,68.62 87.06,68.74 87.06,68.9 87.18,69.01 87.42,69.01 87.53,69.13 87.53,69.29 87.42,69.41 87.18,69.41 87.06,69.52 87.06,69.69 87.18,69.8 87.42,69.8 87.53,69.92 87.53,70.08 87.42,70.2 87.18,70.2 87.06,70.31 87.06,70.47 87.18,70.59 87.42,70.59 87.53,70.7 87.53,70.87 87.42,70.98 87.18,70.98 87.06,71.1 87.06,71.26 87.18,71.38 87.42,71.38 87.53,71.49 87.53,71.66 87.42,71.77 87.18,71.77 87.06,71.89 87.06,72.05 87.18,72.16 87.42,72.16 87.53,72.28 87.53,72.44 87.42,72.56 87.18,72.56 87.06,72.67 87.06,72.84 87.18,72.95 87.35,72.95 87.47,73.07 87.47,73.23 87.35,73.35 87.18,73.35 87.06,73.46 87.06,76.84 85.59,78.32 85.59,80.85 84.55,81.88 84.55,104.85 91.81,112.11 95.36,112.11 v1(95.81,111.65)
  BOTTOM w0.079: v1(95.81,111.65) 96.42,111.04 100.35,111.04 U35.AF70
  BOTTOM w0.127: v1(88.72,62.28) JDIM2.25
M_B_DQ9: length 72.5
  IN2 w0.14: v1(88.6,56.77) 88.6,56.48 88.72,56.36 89.32,56.36 89.45,56.48 89.45,59.9 89.87,60.32 89.87,63.56 88.56,64.87 88.56,79.33 85.68,82.21 85.68,104.05 89.92,108.29 89.92,108.73 92.06,110.87 96.3,110.87 v1(97.08,111.65)
  BOTTOM w0.079: U35.AF68 101.82,110.77 101.38,110.77 100.75,111.4 97.34,111.4 v1(97.08,111.65)
  BOTTOM w0.127: v1(88.6,56.77) 88.47,56.65 JDIM2.24
M_B_DQ10: length 69.4
  IN2 w0.079: 93.36,109.37 93.52,109.53 96.83,109.53 v1(97.44,110.14)
  IN2 w0.14: 93.36,109.37 92.11,108.12 92.11,107.34 87.6,102.83 87.6,91.03 88.42,90.21 88.42,82.35 90.72,80.06 90.72,74.39 90.83,74.27 91.13,74.27 91.24,74.17 91.24,73.98 91.13,73.88 90.83,73.88 90.72,73.76 90.72,73.6 90.83,73.48 91.71,73.48 91.83,73.37 91.83,73.21 91.71,73.09 90.83,73.09 90.72,72.98 90.72,72.81 90.83,72.7 91.71,72.7 91.83,72.58 91.83,72.42 91.71,72.3 90.83,72.3 90.72,72.19 90.72,72.03 90.83,71.91 91.71,71.91 91.83,71.79 91.83,71.63 91.71,71.52 90.83,71.52 90.72,71.4 90.72,71.24 90.83,71.12 91.71,71.12 91.83,71.01 91.83,70.84 91.71,70.73 90.83,70.73 90.72,70.61 90.72,70.45 90.83,70.33 91.71,70.33 91.83,70.22 91.83,62.5 v1(91.57,62.25)
  BOTTOM w0.079: U35.AH71 99.6,109.23 99.41,109.42 98.86,109.42 98.75,109.53 98.06,109.53 v1(97.44,110.14)
  BOTTOM w0.102: v1(91.57,62.25) 91.72,62.4 JDIM2.37
M_B_DQ11: length 72.2
  IN2 w0.079: 93.99,108.99 94.18,109.18 98.59,109.18 98.71,109.3 v1(98.71,110.12)
  IN2 w0.14: 93.99,108.99 93.13,108.12 93.13,106.57 88.28,101.73 88.28,91.32 89.12,90.48 89.12,82.63 91.48,80.27 91.48,79.51 91.61,79.38 91.93,79.38 92.06,79.26 92.06,79.08 91.93,78.96 91.52,78.96 91.4,78.84 91.4,78.68 91.52,78.56 92.42,78.56 92.54,78.45 92.54,78.29 92.42,78.17 91.52,78.17 91.4,78.05 91.4,77.89 91.52,77.78 92.42,77.78 92.54,77.66 92.54,57.28 92.41,57.15 91.72,57.15 91.59,57.28 v1(91.59,57.39)
  BOTTOM w0.079: U35.AH68 101.91,109.23 101.64,109.5 101.63,109.5 101.55,109.58 101.16,109.58 100.93,109.69 100.75,109.69 100.59,109.62 100.42,109.62 100.3,109.67 99.7,109.67 99.63,109.75 99.08,109.75 v1(98.71,110.12)
  BOTTOM w0.102: v1(91.59,57.39) 92.03,56.95 92.03,56.39 91.97,56.34 JDIM2.38
M_B_DQ12: length 70.2
  IN2 w0.14: v1(94.54,111.65) 91.88,111.65 84.89,104.67 84.89,82.03 85.96,80.96 85.96,78.52 87.28,77.19 87.4,77.08 87.67,77.08 87.79,76.96 87.79,76.8 87.67,76.68 87.52,76.68 87.41,76.57 87.41,76.4 87.52,76.29 87.76,76.29 87.88,76.17 87.88,76.01 87.76,75.89 87.52,75.89 87.41,75.78 87.41,75.62 87.52,75.5 87.76,75.5 87.88,75.39 87.88,75.22 87.76,75.11 87.52,75.11 87.41,74.99 87.41,74.83 87.52,74.71 87.76,74.71 87.88,74.6 87.88,74.44 87.76,74.32 87.52,74.32 87.41,74.2 87.41,74.04 87.52,73.93 87.76,73.93 87.88,73.81 87.88,64.49 89.16,63.21 89.16,61.19 88.96,60.99 v1(88.72,60.99)
  BOTTOM w0.079: v1(94.54,111.65) 95.32,110.88 99.87,110.88 U35.AF71
  BOTTOM w0.127: JDIM2.29 89.72,61.83 88.88,60.99 v1(88.72,60.99)
M_B_DQ13: length 71.8
  IN2 w0.14: v1(96.45,111.65) 95.94,111.14 91.86,111.14 89.35,108.64 89.35,108.24 85.32,104.22 85.32,82.08 88.22,79.18 88.22,64.64 89.49,63.37 89.49,60.47 88.94,59.93 88.94,59.68 88.83,59.57 88.72,59.57 88.61,59.45 88.61,59.29 88.72,59.18 88.83,59.18 88.94,59.06 88.94,58.39 v1(88.6,58.04)
  BOTTOM w0.079: v1(96.45,111.65) 96.9,111.2 100.64,111.2 101.38,110.46 U35.AF69
  BOTTOM w0.127: JDIM2.28 89.47,57.41 88.85,58.04 v1(88.6,58.04)
M_B_DQ14: length 71
  IN2 w0.079: v1(96.8,110.14) 96.8,109.88 96.68,109.75 93.23,109.75 93.09,109.61
  IN2 w0.14: 93.09,109.61 91.73,108.25 91.73,107.7 87.25,103.23 87.25,90.89 88.07,90.08 88.07,82.18 90.37,79.88 90.37,69.8 90.49,69.69 90.79,69.69 90.91,69.57 90.91,69.41 90.79,69.3 90.49,69.3 90.37,69.18 90.37,69.02 90.49,68.9 91.25,68.9 91.37,68.79 91.37,68.62 91.25,68.51 90.49,68.51 90.37,68.39 90.37,68.23 90.49,68.11 91.25,68.11 91.37,68 91.37,63.76 91.12,63.5 91.12,59.89 91.5,59.51 91.5,58.76 v1(91.59,58.66)
  BOTTOM w0.079: v1(96.8,110.14) 97.6,109.35 98.65,109.35 98.74,109.26 99.32,109.26 99.61,108.97 100.03,108.97 100.3,108.97 100.44,109.02 100.62,109.02 U35.AH70
  BOTTOM w0.102: v1(91.59,58.66) 91.86,58.66 92.97,57.55 JDIM2.42
M_B_DQ15: length 71.6
  IN2 w0.079: 93.74,109.24 93.83,109.33 97.26,109.33 v1(98.07,110.14)
  IN2 w0.14: v1(91.57,60.95) 91.57,60.85 91.7,60.73 92.06,60.73 92.18,60.85 92.18,74.83 92.07,74.94 91.17,74.94 91.06,75.06 91.06,75.22 91.17,75.34 92.07,75.34 92.18,75.45 92.18,75.62 92.07,75.73 91.17,75.73 91.06,75.85 91.06,76.01 91.17,76.12 92.07,76.12 92.18,76.24 92.18,76.4 92.07,76.52 91.17,76.52 91.06,76.63 91.06,76.8 91.17,76.91 92.07,76.91 92.18,77.03 92.18,77.19 92.07,77.31 91.17,77.31 91.06,77.42 91.06,80.2 88.77,82.5 88.77,90.35 87.94,91.18 87.94,102.17 92.61,106.84 92.61,108.11 93.74,109.24
  BOTTOM w0.079: U35.AH69 101.31,109.41 101.14,109.41 101.04,109.46 101.03,109.46 100.95,109.5 100.94,109.5 100.9,109.52 100.76,109.52 100.62,109.46 100.38,109.46 100.29,109.5 99.58,109.5 99.5,109.59 99,109.59 98.88,109.71 98.51,109.71 v1(98.07,110.14)
  BOTTOM w0.102: JDIM2.41 92.72,61.78 91.9,60.95 v1(91.57,60.95)
M_B_DQ16: length 60.6
  IN2 w0.114: 102.8,105.16 v2(102.97,105.16)
  IN2 w0.14: 102.8,105.16 102.46,105.16 102.24,104.95 101.65,104.95 98.19,101.49 93.96,101.49 89.66,97.19 89.66,92 90.49,91.17 90.49,84.26 92.54,82.2 92.54,82.04 92.43,81.93 92.27,81.93 90.76,83.43 90.6,83.43 90.49,83.31 90.49,83.15 93.91,79.73 93.91,65.86 94.54,65.22 94.54,64.46 94.06,63.97 v1(94.06,62.31)
  BOTTOM w0.127: v1(94.06,62.31) 93.72,62.64 JDIM2.45 ; v2(102.97,105.16) U35.AT66
M_B_DQ17: length 60
  IN2 w0.114: 102.8,104.53 v2(102.91,104.53)
  IN2 w0.14: v1(94.06,61.04) 94.67,61.66 94.67,64.01 94.91,64.25 94.91,65.37 94.31,65.97 94.31,79.81 92.86,81.27 92.86,81.44 92.98,81.56 93.15,81.56 93.7,81.01 93.88,81.01 94.03,81.16 94.03,81.34 90.84,84.53 90.84,91.37 90,92.21 90,96.81 94.27,101.07 98.28,101.07 101.73,104.53 102.8,104.53
  BOTTOM w0.127: v1(94.06,61.04) 94.72,61.71 JDIM2.49 ; U35.AU66 v2(102.91,104.53)
M_B_DQ18: length 63.2
  IN2 w0.079: 102.55,100.56 102.55,100.94 104.53,102.92 104.53,104.03 104.23,104.34 104.23,105.41 v2(103.84,105.8)
  IN2 w0.14: 102.55,100.56 102.55,99.47 101.87,98.79 101.87,93.91 96.53,88.58 96.53,85.34 96.65,85.23 97.33,85.23 97.44,85.11 97.44,84.95 97.33,84.83 96.65,84.83 96.53,84.72 96.53,84.55 96.65,84.44 97.33,84.44 97.44,84.32 97.44,84.16 97.33,84.04 96.65,84.04 96.53,83.93 96.53,83.77 96.65,83.65 97.33,83.65 97.44,83.54 97.44,83.37 97.33,83.26 97.06,83.26 96.94,83.14 96.94,82.98 97.06,82.86 97.33,82.86 97.44,82.75 97.44,82.58 97.33,82.47 97.12,82.47 97.01,82.35 97.01,82.19 97.12,82.08 97.33,82.08 97.44,81.96 97.44,81.8 97.33,81.68 97.12,81.68 97.01,81.57 97.01,81.4 97.12,81.29 97.33,81.29 97.44,81.17 97.44,81.01 97.33,80.89 97.12,80.89 97.01,80.78 97.01,80.62 97.12,80.5 97.33,80.5 97.44,80.39 97.44,80.22 97.33,80.11 97.12,80.11 97.01,79.99 97.01,79.83 97.12,79.71 97.33,79.71 97.44,79.6 97.44,79.43 97.33,79.32 97.12,79.32 97.01,79.2 97.01,79.04 97.12,78.93 97.33,78.93 97.44,78.81 97.44,78.65 97.33,78.53 97.12,78.53 97.01,78.42 97.01,78.25 97.12,78.14 97.33,78.14 97.44,78.02 97.44,65.62 97.55,65.52 97.55,63.25 97.76,63.04 97.76,58.88 v1(97.47,58.6)
  BOTTOM w0.127: JDIM2.58 96.97,58.1 v1(97.47,58.6) ; U35.AP65 v2(103.84,105.8)
M_B_DQ19: length 64.1
  IN2 w0.079: 102.8,100.58 102.8,100.91 104.74,102.85 104.74,104.05 104.38,104.41 104.38,105.9 v2(103.84,106.45)
  IN2 w0.14: 102.8,100.58 102.8,99.12 102.22,98.54 102.22,93.77 97.75,89.3 97.75,89.09 98.05,88.8 98.05,88.63 97.93,88.52 96.99,88.52 96.88,88.4 96.88,88.24 96.99,88.12 97.93,88.12 98.05,88.01 98.05,87.84 97.93,87.73 96.99,87.73 96.88,87.61 96.88,87.45 96.99,87.34 97.96,87.34 98.07,87.22 98.07,87.06 97.96,86.94 96.99,86.94 96.88,86.83 96.88,86.66 96.99,86.55 97.96,86.55 98.07,86.43 98.07,86.27 97.96,86.15 96.99,86.15 96.88,86.04 96.88,85.88 96.99,85.76 97.75,85.76 97.87,85.65 97.87,63.38 98.09,63.16 98.09,57.46 97.96,57.33 v1(97.47,57.33)
  BOTTOM w0.127: v2(103.84,106.45) U35.AN65 ; v1(97.47,57.33) 97.92,56.88 97.92,56.47 97.97,56.41 JDIM2.62
M_B_DQ20: length 63.2
  IN2 w0.114: 102.06,106.93 102.25,107.12 v2(102.91,107.12)
  IN2 w0.14: 102.06,106.93 101.26,106.13 101.26,105.75 99.82,104.31 95.66,104.31 88.93,97.58 88.93,91.59 89.78,90.74 89.78,82.88 93.2,79.47 93.2,57.25 93.65,56.8 v1(93.97,56.8)
  BOTTOM w0.127: v1(93.97,56.8) JDIM2.46 ; U35.AN66 103.41,106.83 v2(102.91,107.12)
M_B_DQ21: length 62.7
  IN2 w0.114: 102.68,106.31 102.84,106.47 v2(102.98,106.47)
  IN2 w0.14: 102.68,106.31 102.68,106.1 101.99,105.41 101.48,105.41 99.99,103.91 95.75,103.91 89.32,97.48 89.32,91.78 90.14,90.97 90.14,83.01 93.55,79.6 93.55,58.49 v1(93.97,58.07)
  BOTTOM w0.127: U35.AP66 102.97,106.48 v2(102.98,106.47) ; v1(93.97,58.07) 94.28,58.07 94.97,57.37 JDIM2.50
M_B_DQ22: length 61.9
  IN2 w0.079: 102.25,100.56 102.25,100.93 104.31,102.99 104.31,104.03 v2(103.84,104.5)
  IN2 w0.14: v1(96.8,61.05) 96.93,61.05 97.34,61.46 97.34,62.88 97.25,62.97 97.25,63.21 97.13,63.33 96.93,63.33 96.81,63.45 96.81,63.61 96.93,63.72 97.13,63.72 97.25,63.84 97.25,64 97.13,64.12 96.93,64.12 96.81,64.23 96.81,64.4 96.93,64.51 97.13,64.51 97.25,64.63 97.25,65.3 96.67,65.89 96.67,66.13 96.78,66.24 96.98,66.24 97.1,66.36 97.1,66.52 96.98,66.64 96.78,66.64 96.67,66.75 96.67,66.92 96.78,67.03 96.98,67.03 97.1,67.15 97.1,67.31 96.98,67.43 96.78,67.43 96.67,67.54 96.67,67.7 96.78,67.82 96.98,67.82 97.1,67.93 97.1,68.1 96.98,68.21 96.78,68.21 96.67,68.33 96.67,68.49 96.78,68.61 96.98,68.61 97.1,68.72 97.1,68.88 96.98,69 96.78,69 96.67,69.12 96.67,69.28 96.78,69.39 96.98,69.39 97.1,69.51 97.1,69.67 96.98,69.79 96.78,69.79 96.67,69.9 96.67,70.07 96.78,70.18 96.98,70.18 97.1,70.3 97.1,70.46 96.98,70.57 96.78,70.57 96.67,70.69 96.67,70.85 96.78,70.97 96.98,70.97 97.1,71.08 97.1,71.25 96.98,71.36 96.78,71.36 96.67,71.48 96.67,71.64 96.78,71.76 96.98,71.76 97.1,71.87 97.1,72.03 96.98,72.15 96.78,72.15 96.67,72.26 96.67,72.43 96.78,72.54 96.98,72.54 97.1,72.66 97.1,72.82 96.98,72.94 96.78,72.94 96.67,73.05 96.67,73.22 96.78,73.33 96.98,73.33 97.1,73.45 97.1,73.61 96.98,73.72 96.78,73.72 96.67,73.84 96.67,74 96.78,74.12 96.98,74.12 97.1,74.23 97.1,74.4 96.98,74.51 96.78,74.51 96.67,74.63 96.67,74.79 96.78,74.91 96.98,74.91 97.1,75.02 97.1,75.18 96.98,75.3 96.78,75.3 96.67,75.41 96.67,75.58 96.78,75.69 96.98,75.69 97.1,75.81 97.1,75.97 96.98,76.09 96.78,76.09 96.67,76.2 96.67,76.36 96.78,76.48 96.98,76.48 97.1,76.6 97.1,76.76 96.98,76.87 96.78,76.87 96.67,76.99 96.67,77.15 96.78,77.27 96.98,77.27 97.1,77.38 97.1,77.55 96.98,77.66 96.78,77.66 96.67,77.78 96.67,82.78 96.19,83.25 96.19,88.78 101.53,94.11 101.53,99 102.25,99.72 102.25,100.56
  BOTTOM w0.127: U35.AT65 v2(103.84,104.5) ; JDIM2.63 98.22,62.08 97.2,61.05 v1(96.8,61.05)
M_B_DQ23: length 61
  IN2 w0.079: v2(103.92,103.85) 103.92,102.89 101.97,100.94 101.97,100.58
  IN2 w0.14: v1(96.8,62.32) 96.8,62.83 96.32,63.31 96.32,66.79 96.21,66.91 95.96,66.91 95.85,67.02 95.85,67.19 95.96,67.3 96.21,67.3 96.32,67.42 96.32,67.58 96.21,67.7 95.96,67.7 95.85,67.81 95.85,67.97 95.96,68.09 96.21,68.09 96.32,68.2 96.32,68.37 96.21,68.48 95.96,68.48 95.85,68.6 95.85,68.76 95.96,68.88 96.21,68.88 96.32,68.99 96.32,69.16 96.21,69.27 95.96,69.27 95.85,69.39 95.85,69.55 95.96,69.66 96.21,69.66 96.32,69.78 96.32,69.94 96.21,70.06 95.96,70.06 95.85,70.17 95.85,70.34 95.96,70.45 96.21,70.45 96.32,70.57 96.32,70.73 96.21,70.85 95.96,70.85 95.85,70.96 95.85,71.12 95.96,71.24 96.21,71.24 96.32,71.35 96.32,71.52 96.21,71.63 95.96,71.63 95.85,71.75 95.85,71.91 95.96,72.03 96.21,72.03 96.32,72.14 96.32,72.3 96.21,72.42 95.96,72.42 95.85,72.54 95.85,72.7 95.96,72.81 96.21,72.81 96.32,72.93 96.32,73.09 96.21,73.21 95.96,73.21 95.85,73.32 95.85,73.49 95.96,73.6 96.21,73.6 96.32,73.72 96.32,73.88 96.21,74 95.96,74 95.85,74.11 95.85,74.27 95.96,74.39 96.21,74.39 96.32,74.5 96.32,74.67 96.21,74.78 95.96,74.78 95.85,74.9 95.85,75.06 95.96,75.18 96.21,75.18 96.32,75.29 96.32,75.45 96.21,75.57 95.96,75.57 95.85,75.69 95.85,75.85 95.96,75.96 96.21,75.96 96.32,76.08 96.32,76.24 96.21,76.36 95.96,76.36 95.85,76.47 95.85,76.64 95.96,76.75 96.21,76.75 96.32,76.87 96.32,77.03 96.21,77.14 95.96,77.14 95.85,77.26 95.85,77.42 95.96,77.54 96.21,77.54 96.32,77.65 96.32,77.82 96.21,77.93 95.96,77.93 95.85,78.05 95.85,78.21 95.96,78.33 96.21,78.33 96.32,78.44 96.32,78.6 96.21,78.72 95.96,78.72 95.85,78.83 95.85,79 95.96,79.11 96.21,79.11 96.32,79.23 96.32,79.39 96.21,79.51 95.96,79.51 95.85,79.62 95.85,79.79 95.96,79.9 96.21,79.9 96.32,80.02 96.32,80.18 96.21,80.29 95.96,80.29 95.85,80.41 95.85,80.57 95.96,80.69 96.21,80.69 96.32,80.8 96.32,80.97 96.21,81.08 95.96,81.08 95.85,81.2 95.85,81.36 95.96,81.48 96.21,81.48 96.32,81.59 96.32,81.75 96.21,81.87 95.96,81.87 95.85,81.98 95.85,82.15 95.96,82.26 96.21,82.26 96.32,82.38 96.32,82.54 96.21,82.66 95.96,82.66 95.85,82.77 95.85,89.02 101.15,94.32 101.15,99.11 101.97,99.94 101.97,100.58
  BOTTOM w0.127: v1(96.8,62.32) 96.91,62.32 97.22,62.64 JDIM2.59 ; U35.AU65 v2(103.92,103.85)
M_B_DQ24: length 54.4
  IN2 w0.079: 103.64,100.46 103.64,100.83 105.26,102.45 105.26,104 105.69,104.44 v2(105.69,104.56)
  IN2 w0.14: v1(100.41,60.85) 100.32,60.76 99.94,60.76 99.57,61.13 99.57,61.6 99.69,61.71 99.89,61.71 100,61.83 100,61.99 99.89,62.11 99.69,62.11 99.57,62.22 99.57,67.83 99.93,68.18 99.93,71.58 99.81,71.7 99.67,71.7 99.56,71.81 99.56,71.97 99.67,72.09 99.81,72.09 99.93,72.2 99.93,72.37 99.81,72.48 99.67,72.48 99.56,72.6 99.56,72.76 99.67,72.88 99.81,72.88 99.93,72.99 99.93,73.16 99.81,73.27 99.67,73.27 99.56,73.39 99.56,73.55 99.67,73.66 99.81,73.66 99.93,73.78 99.93,73.94 99.81,74.06 99.67,74.06 99.56,74.17 99.56,74.34 99.67,74.45 99.81,74.45 99.93,74.57 99.93,74.73 99.81,74.85 99.67,74.85 99.56,74.96 99.56,75.12 99.67,75.24 99.81,75.24 99.93,75.35 99.93,75.52 99.81,75.63 99.67,75.63 99.59,75.71 99.59,89.51 103.64,93.56 103.64,100.46
  BOTTOM w0.127: v1(100.41,60.85) 99.88,60.85 99.22,61.51 JDIM2.67 ; U35.AT61 v2(105.69,104.56)
M_B_DQ25: length 53.9
  IN2 w0.079: v2(105.69,103.89) 105.69,103.28 105.42,103.01 105.42,102.31 103.86,100.74 103.86,100.4
  IN2 w0.14: v1(100.41,62.12) 99.93,62.61 99.93,67.66 100.32,68.05 100.32,76.06 100.21,76.17 100.05,76.17 99.93,76.29 99.93,76.45 100.05,76.57 100.21,76.57 100.32,76.68 100.32,76.85 100.21,76.96 100.05,76.96 99.93,77.08 99.93,77.24 100.05,77.35 100.21,77.35 100.32,77.47 100.32,77.63 100.21,77.75 100.05,77.75 99.93,77.86 99.93,78.03 100.05,78.14 100.21,78.14 100.32,78.26 100.32,78.42 100.21,78.54 100.05,78.54 99.93,78.65 99.93,78.81 100.05,78.93 100.21,78.93 100.32,79.04 100.32,79.21 100.21,79.32 100.05,79.32 99.93,79.44 99.93,79.6 100.05,79.72 100.21,79.72 100.32,79.83 100.32,80 100.21,80.11 100.05,80.11 99.93,80.23 99.93,80.39 100.05,80.5 100.21,80.5 100.32,80.62 100.32,80.78 100.21,80.9 100.05,80.9 99.93,81.01 99.93,81.18 100.05,81.29 100.21,81.29 100.32,81.41 100.32,81.57 100.21,81.69 100.05,81.69 99.93,81.8 99.93,81.96 100.05,82.08 100.21,82.08 100.32,82.19 100.32,82.36 100.21,82.47 100.05,82.47 99.93,82.59 99.93,82.75 100.05,82.87 100.21,82.87 100.32,82.98 100.32,83.14 100.21,83.26 100.05,83.26 99.93,83.38 99.93,83.54 100.05,83.65 100.21,83.65 100.32,83.77 100.32,83.93 100.21,84.05 100.05,84.05 99.93,84.16 99.93,84.33 100.05,84.44 100.21,84.44 100.32,84.56 100.32,84.72 100.21,84.83 100.05,84.83 99.93,84.95 99.93,85.11 100.05,85.23 100.21,85.23 100.32,85.34 100.32,85.51 100.21,85.62 100.05,85.62 99.93,85.74 99.93,85.9 100.05,86.02 100.21,86.02 100.32,86.13 100.32,86.29 100.21,86.41 100.05,86.41 99.93,86.52 99.93,86.69 100.05,86.8 100.18,86.8 100.29,86.92 100.29,87.08 100.18,87.2 100.05,87.2 99.93,87.31 99.93,89.49 103.86,93.41 103.86,100.4
  BOTTOM w0.127: JDIM2.71 100.22,62.31 v1(100.41,62.12) ; U35.AU61 v2(105.69,103.89)
M_B_DQ26: length 56.8
  IN2 w0.079: 107.26,103.77 107.26,104.05 107.01,104.3 107.01,105.84 106.86,105.99 106.7,105.99 106.62,105.91 v2(106.62,105.83)
  IN2 w0.114: 105.71,100.56 107.26,102.1 107.26,103.77
  IN2 w0.14: v1(102.93,62.25) 103.05,62.38 103.24,62.38 103.37,62.25 103.37,60.25 103.49,60.13 103.67,60.13 103.8,60.25 103.8,62.65 103.68,62.76 103.41,62.76 103.3,62.88 103.3,63.04 103.41,63.16 104.34,63.16 104.46,63.27 104.46,63.44 104.34,63.55 103.56,63.55 103.43,63.68 103.43,65.2 102.92,65.71 102.92,66.14 102.72,66.34 102.72,89.96 105.71,92.95 105.71,100.56
  BOTTOM w0.127: JDIM2.83 103.22,62.71 103.42,62.51 103.42,62.12 103.29,61.98 103.18,61.98 102.93,62.23 v1(102.93,62.25) ; U35.AP60 107.14,106.08 107.14,105.93 106.99,105.82 106.63,105.82 v2(106.62,105.83)
M_B_DQ27: length 57.2
  IN2 w0.079: 107.54,103.74 107.54,104.02 107.16,104.39 107.16,105.93 v2(106.62,106.48)
  IN2 w0.114: 106.05,100.49 107.54,101.99 107.54,103.74
  IN2 w0.14: 106.05,100.49 106.05,92.78 103.26,89.99 103.26,66.81 103.82,66.26 103.82,64.74 104.78,63.78 104.78,60.74 104.28,60.24 104.28,60.08 104.49,59.88 104.49,59.71 104.37,59.6 104.21,59.6 104,59.8 103.84,59.8 103.72,59.69 103.72,59.52 103.99,59.26 103.99,59.1 103.87,58.98 103.71,58.98 103.45,59.25 103.28,59.25 102.97,58.94 v1(102.97,58.65)
  BOTTOM w0.127: v2(106.62,106.48) U35.AN60 ; JDIM2.80 102.47,56.36 102.33,56.5 102.33,58.01 v1(102.97,58.65)
M_B_DQ28: length 56.4
  IN2 w0.079: 103.17,100.54 103.17,100.97 104.93,102.73 104.93,104.18 105.15,104.4 105.15,106.08 105.58,106.5 v2(105.68,106.5)
  IN2 w0.14: 103.17,100.54 103.17,93.96 98.86,89.66 98.86,59.98 98.75,59.87 98.5,59.87 98.39,59.75 98.39,59.59 98.5,59.47 98.75,59.47 98.86,59.36 98.86,59.2 98.75,59.08 98.5,59.08 98.39,58.97 98.39,58.8 98.5,58.69 98.75,58.69 98.86,58.57 98.86,58.21 v1(98.8,58.15)
  BOTTOM w0.127: JDIM2.70 99.97,56.34 99.42,56.9 99.42,57.52 v1(98.8,58.15) ; U35.AN61 v2(105.68,106.5)
M_B_DQ29: length 55.8
  IN2 w0.079: 103.41,100.5 103.41,100.91 105.1,102.6 105.1,104.09 105.31,104.31 105.31,105.73 105.44,105.86 v1(105.69,105.86)
  IN2 w0.14: 103.41,100.5 103.41,93.78 99.22,89.58 99.22,71.29 99.33,71.17 99.42,71.17 99.53,71.06 99.53,70.89 99.42,70.78 99.33,70.78 99.22,70.66 99.22,70.5 99.33,70.38 99.45,70.38 99.56,70.27 99.56,70.11 99.45,69.99 99.33,69.99 99.22,69.87 99.22,69.71 99.33,69.6 99.45,69.6 99.56,69.48 99.56,69.32 99.45,69.2 99.33,69.2 99.22,69.09 99.22,68.92 99.33,68.81 99.45,68.81 99.56,68.69 99.56,68.53 99.45,68.42 99.33,68.42 99.22,68.3 99.22,58.62 99.25,58.58 99.25,57.33 v1(98.8,56.88)
  BOTTOM w0.127: U35.AP61 v1(105.69,105.86) ; v1(98.8,56.88) 98.97,56.7 JDIM2.66
M_B_DQ30: length 56.3
  IN2 w0.079: v2(106.62,104.52) 106.62,104.43 107,104.05 107,103.41
  IN2 w0.114: 105.39,100.8 107,102.42 107,103.41
  IN2 w0.14: v1(102.93,60.98) 102.93,60.88 102.8,60.75 102.56,60.75 102.5,60.81 102.5,61.4 102.38,61.52 102.23,61.52 102.11,61.64 102.11,61.8 102.23,61.91 102.38,61.91 102.5,62.03 102.5,62.21 102.37,62.34 102.22,62.34 102.1,62.46 102.1,62.62 102.22,62.73 102.86,62.73 102.98,62.85 102.98,63.01 102.86,63.13 102.22,63.13 102.1,63.24 102.1,63.41 102.22,63.52 102.94,63.52 103.05,63.64 103.05,63.8 102.94,63.92 102.22,63.92 102.1,64.03 102.1,64.19 102.22,64.31 102.54,64.31 102.66,64.43 102.66,64.59 102.54,64.7 102.22,64.7 102.1,64.82 102.1,64.98 102.22,65.1 102.48,65.1 102.61,65.22 102.61,65.39 102.48,65.52 102.22,65.52 102.11,65.63 102.11,65.79 102.22,65.91 102.31,65.91 102.37,65.97 102.37,90.04 105.39,93.06 105.39,100.8
  BOTTOM w0.127: JDIM2.79 102.22,62.7 102.08,62.55 102.08,61.1 102.32,60.86 102.8,60.86 v1(102.93,60.98) ; v2(106.62,104.52) 106.62,104.48 106.66,104.44 106.84,104.44 107.07,104.67 107.07,104.85 U35.AT60
