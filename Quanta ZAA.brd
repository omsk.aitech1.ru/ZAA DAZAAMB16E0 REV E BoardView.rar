# Allegro board Quanta ZAA.brd (continued)
## Nets (continued)
GND: BT1.2 C7.2 C9.1 C16.1 C19.2 C27.1 C29.1 C30.2 C33.1 C34.2 C35.1 C41.2 C73.2 C114.2 C136.1 C144.1 C148.2 C150.1 C151.2 C155.2 C157.2 C158.2 C161.2 C164.1 C165.2 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C176.1 C178.1 C179.1 C181.1 C182.1 C184.1 C185.2 C186.2 C187.1 C188.1 C189.1 C190.1 C191.1 C192.1 C193.1 C194.1 C195.1 C196.1 C197.1 C198.1 C199.1 C200.1 C201.1 C202.1 C203.1 C204.1 C205.1 C206.1 C207.1 C209.1 C210.1 C212.1 C214.1 C215.1 C216.1 C217.1 C218.2 C219.1 C221.2 C222.1 C223.2 C224.1 C225.1 C226.1 C227.1 C228.1 C229.2 C230.2 C232.2 C233.1 C235.1 C236.1 C237.1 C238.2 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C245.1 C246.1 C247.2 C248.1 C249.1 C250.2 C251.1 C252.1 C254.2 C255.1 C256.2 C257.2 C258.2 C259.2 C260.1 C261.1 C262.1 C263.2 C264.1 C265.2 C266.1 C267.1 C268.2 C269.1 C270.2 C272.1 C273.1 C274.1 C275.1 C276.1 C277.1 C278.1 C279.2 C280.2 C281.2 C282.1 C283.2 C284.2 C285.1 C286.2 C288.2 C289.1 C290.2 C291.2 C292.2 C297.1 C298.1 C299.1 C300.1 C301.2 C302.1 C303.1 C304.1 C305.2 C307.1 C308.1 C310.1 C311.1 C312.1 C313.1 C314.2 C316.2 C317.2 C318.2 C319.1 C320.1 C321.1 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C330.2 C332.1 C333.1 C334.1 C336.1 C337.1 C338.1 C339.1 C340.2 C344.1 C345.1 C346.1 C347.2 C348.1 C349.2 C350.1 C351.1 C352.1 C353.2 C354.2 C355.2 C356.2 C357.2 C360.2 C362.1 C363.1 C364.1 C365.2 C366.2 C367.1 C368.1 C370.2 C371.2 C373.2 C374.2 C376.2 C377.1 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C386.2 C412.2 C413.2 C424.2 C425.1 C428.2 C431.2 C435.2 C436.2 C437.2 C438.2 C450.1 C451.1 C452.1 C453.2 C454.2 C456.2 C457.2 C458.2 C460.2 C462.1 C469.1 C475.1 C477.2 C481.2 C482.2 C483.2 C484.2 C485.2 C487.2 C488.2 C489.2 C490.1 C491.2 C492.2 C493.1 C494.2 C496.1 C497.1 C500.2 C501.2 C502.1 C505.2 C508.2 C509.2 C510.2 C511.2 C514.2 C515.1 C517.1 C518.1 C525.2 C527.2 C530.2 C537.2 C538.2 C541.1 C545.2 C546.2 C548.2 C551.2 C555.2 C556.2 C577.1 C578.1 C580.1 C581.2 C628.2 C641.2 C642.2 C643.2 C645.1 C647.2 C650.1 C651.2 C657.2 C658.1 C659.1 C663.2 C664.2 C665.1 C666.1 C667.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.1 C678.2 C679.2 C680.2 C681.1 C682.2 C683.1 C684.1 C685.1 C686.2 C687.2 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C707.1 C708.2 C709.2 C710.1 C711.1 C712.2 C713.1 C714.2 C716.2 C718.2 C719.1 C720.1 C721.2 C723.1 C724.2 C726.2 C728.1 C730.2 C731.2 C732.2 C733.2 C735.2 C737.2 C739.2 C740.2 C742.1 C746.2 C747.2 C748.1 C750.2 C752.2 C753.2 C754.1 C755.2 C756.1 C757.2 C758.2 C759.1 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C770.2 C771.2 C772.2 C774.2 C775.2 C776.2 C777.2 C778.2 C780.2 C781.2 C783.2 C785.1 C786.2 C787.1 C788.1 C790.2 C793.1 C794.1 C796.2 C797.2 C798.1 C799.2 C800.2 C801.2 C802.2 C803.1 C804.1 C805.2 C806.2 C807.1 C808.1 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C817.1 C818.1 C819.1 C821.1 C822.2 C823.1 C824.1 C963.2 C965.2 C1162.2 C1163.2 C1164.2 C1165.2 C1166.2 C1167.2 C1168.2 C1169.2 C1211.2 C1212.2 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1258.1 C1259.2 C1260.2 C1261.2 C1262.2 C1263.2 C1264.2 C1265.2 C1266.2 C1267.2 C1270.2 C1271.2 C1272.2 C1273.2 C1275.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1317.1 C1318.2 C1319.2 C1320.2 C1321.2 C1323.2 C1324.2 C1325.2 C1327.2 C1328.2 C1330.2 C1331.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1377.2 C1386.2 C1388.2 C1391.2 C1394.1 C1396.2 C1398.1 C1399.2 C1401.1 C1402.1 C1403.1 C1408.2 C1409.2 C1413.2 C1414.2 C1415.2 C1416.2 C1418.2 C1419.2 C1420.2 C1421.1 C1422.1 C1423.2 C1432.2 C1435.2 C1436.2 C1438.1 C1439.1 C1440.2 C1447.2 C1448.1 C1450.2 C1457.1 C1458.2 C1497.2 C1498.1 C1499.2 C1504.2 C1513.1 C1537.2 C1538.1 C1543.1 C1544.2 C1549.1 C1551.2 C1764.2 C3000.1 C3001.1 C3002.1 C3007.1 C3008.1 C4000.1 C4001.1 C4002.1 C4003.1 C4004.2 C4005.2 C4006.2 C4007.2 C4008.1 C4009.1 C4010.1 C4011.1 C4012.1 C4014.1 C4019.2 C4024.1 C4025.1 C4026.1 C4027.2 C4028.1 C4029.1 C4030.1 C4031.1 C4032.1 C4033.2 C4034.1 C4035.1 C4036.2 C4037.1 C4038.1 C4039.2 C4040.2 C4041.2 C4100.1 C4101.1 C4102.1 C4103.1 C4104.1 C4105.1 C4106.1 C4107.1 C4108.1 C4109.1 C4110.1 C4111.1 C4112.1 C4113.1 C4115.1 C4117.1 C4119.1 C4200.2 C4201.2 C4202.2 C4203.2 C4204.2 C4205.1 C4206.1 C4207.1 C4208.2 C4209.2 C4210.1 C4211.1 C4400.1 C4401.1 C4402.1 C4403.1 C4404.2 C4405.2 C4406.2 C4407.2 C4408.2 C4409.2 C4410.2 C4411.2 C4412.2 C4413.2 C4414.2 C4415.2 C4416.2 C4417.2 C4418.2 C4419.2 C4420.2 C4421.2 C4422.2 C4423.1 C4424.1 C4425.1 C4426.1 C4427.1 C4428.1 C4429.1 C4430.2 C4431.2 C4432.2 C4433.2 C4434.2 C4435.2 C4596.2 C4597.1 C4598.1 C4599.1 C4600.1 C4603.2 C4604.2 C4605.1 C4606.1 C4607.2 C4608.2 C4609.2 C4611.2 C4612.2 C4613.2 C4614.2 C4615.2 C4616.2 C4617.2 C4618.1 C4647.2 C4648.1 C4649.2 C4650.1 C4711.1 C4712.1 C4713.1 C4714.2 C4715.1 C4723.2 C4726.2 C4727.2 C4728.2 C4733.2 C4734.2 C4735.2 C4736.2 C4737.2 C4748.1 C4749.1 C4750.1 C4751.1 C4752.1 C4753.2 C4754.1 C4764.1 C4765.1 C4766.1 C4767.1 C4768.1 C4769.1 C4772.2 C4773.2 C4774.2 C4775.2 C4782.1 C4783.1 C4784.1 C4785.2 C4786.2 C4787.2 C4788.2 C4793.2 C4794.2 C4795.2 C4796.2 C4797.2 C4798.2 C4799.2 C4800.2 C4801.2 C4802.2 C4803.2 C4804.2 C4805.2 C4806.2 C4807.2 C4808.2 C4809.2 C4810.2 C4811.2 C4812.2 C4813.2 C4814.2 C4815.2 C4816.2 C4817.2 C4818.1 C4819.2 C4820.1 C4821.1 C4822.1 CN2.8 CN2.10 CN2.12 CN2.14 CN4.3 CN4.6 CN4.12 CN4.13 CN4.14 CN4.15 CN5.3 CN5.9 CN5.12 CN5.15 CN5.18 CN5.21 CN5.24 CN5.28 CN5.41 CN5.42 CN5.43 CN5.44 CN6.1 CN6.5 CN6.6 CN7.5 CN7.6 CN7.7 CN7.8 CN7.10 CN7.16 CN7.17 CN8.3 CN8.4 CN8.5 CN9.1 CN9.4 CN9.12 CN9.13 CN9.14 CN9.15 CN10.1 CN10.7 CN10.18 CN10.33 CN10.39 CN10.45 CN10.51 CN10.57 CN10.63 CN10.69 CN10.75 CN11.9 CN11.10 CN11.11 CN11.12 CN12.2 CN12.5 CN12.8 CN12.11 CN12.17 CN12.20 CN12.21 CN12.22 CN12.23 CN13.4 CN13.7 CN13.10 CN13.11 CN13.12 CN13.13 CN14.1 CN14.4 CN14.7 CN14.11 CN14.12 CN14.13 CN14.17 CN14.19 CN14.23 CN14.24 CN16.4 CN16.7 CN16.10 CN16.11 CN16.12 CN16.13 CN17.5 CN17.9 CN17.10 CN18.5 CN18.6 CN20.28 CN20.29 CN20.30 CN23.1 CN23.3 CN23.9 CN23.15 CN23.21 CN23.27 CN23.33 CN23.39 CN23.45 CN23.51 CN23.57 CN23.71 CN23.73 CN23.75 CN23.76 CN23.77 CN95.4 CN95.9 CN95.10 CN2019.28 CN2019.29 CN2019.30 CN2020.6 CN2020.9 CN2020.10 CN2020.13 CN2020.27 CN2020.28 CN2021.1 CN2021.2 CN2021.3 CN2021.4 CN2021.A1 CN2021.A12 CN2021.B1 CN2021.B12 D2.2 D3.2 D4.2 D5.2 D6.2 D23.1 D24.2 D25.2 D26.2 D27.2 D28.1 D34.2 D4002.2 D4013.2 D4014.2 EC35.2 EC36.2 EC37.2 EC38.2 EC39.2 EC40.2 EC41.2 EC42.2 EC43.2 EC44.2 EC45.2 EC46.2 EC47.2 EC48.2 EC49.2 EC50.2 EC51.1 EC52.1 EC53.1 EC54.1 HOLE1.1 HOLE1.2 HOLE1.3 HOLE1.4 HOLE1.5 HOLE1.6 HOLE1.7 HOLE1.8 HOLE1.9 HOLE2.1 HOLE2.2 HOLE2.3 HOLE2.4 HOLE2.5 HOLE2.6 HOLE2.7 HOLE2.8 HOLE2.9 HOLE3.1 HOLE3.2 HOLE3.3 HOLE3.4 HOLE3.5 HOLE3.6 HOLE3.7 HOLE3.8 HOLE3.9 HOLE4.1 HOLE4.2 HOLE4.3 HOLE4.4 HOLE4.5 HOLE4.6 HOLE4.7 HOLE4.8 HOLE4.9 HOLE6.1 HOLE6.2 HOLE6.3 HOLE6.4 HOLE6.5 HOLE6.6 HOLE6.7 HOLE6.8 HOLE6.9 HOLE7.1 HOLE7.2 HOLE7.3 HOLE7.4 HOLE7.5 HOLE7.6 HOLE7.7 HOLE7.8 HOLE7.9 HOLE8.1 HOLE9.1 HOLE10.1 HOLE11.1 HOLE12.1 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 HOLE19.1 HOLE23.1 HOLE23.2 HOLE23.3 HOLE23.4 HOLE23.5 HOLE23.6 HOLE23.7 HOLE23.8 HOLE23.9 HOLE24.1 HOLE24.2 HOLE24.3 HOLE24.4 HOLE24.5 HOLE24.6 HOLE24.7 HOLE24.8 HOLE24.9 J1.2 JDIM1.1 JDIM1.2 JDIM1.5 JDIM1.6 JDIM1.9 JDIM1.10 JDIM1.14 JDIM1.15 JDIM1.18 JDIM1.19 JDIM1.22 JDIM1.23 JDIM1.26 JDIM1.27 JDIM1.30 JDIM1.31 JDIM1.35 JDIM1.36 JDIM1.39 JDIM1.40 JDIM1.43 JDIM1.44 JDIM1.47 JDIM1.48 JDIM1.51 JDIM1.52 JDIM1.56 JDIM1.57 JDIM1.60 JDIM1.61 JDIM1.64 JDIM1.65 JDIM1.68 JDIM1.69 JDIM1.72 JDIM1.73 JDIM1.77 JDIM1.78 JDIM1.81 JDIM1.82 JDIM1.85 JDIM1.86 JDIM1.89 JDIM1.90 JDIM1.93 JDIM1.94 JDIM1.98 JDIM1.99 JDIM1.102 JDIM1.103 JDIM1.106 JDIM1.107 JDIM1.167 JDIM1.168 JDIM1.171 JDIM1.172 JDIM1.175 JDIM1.176 JDIM1.180 JDIM1.181 JDIM1.184 JDIM1.185 JDIM1.188 JDIM1.189 JDIM1.192 JDIM1.193 JDIM1.196 JDIM1.197 JDIM1.201 JDIM1.202 JDIM1.205 JDIM1.206 JDIM1.209 JDIM1.210 JDIM1.213 JDIM1.214 JDIM1.217 JDIM1.218 JDIM1.222 JDIM1.223 JDIM1.226 JDIM1.227 JDIM1.230 JDIM1.231 JDIM1.234 JDIM1.235 JDIM1.238 JDIM1.239 JDIM1.243 JDIM1.244 JDIM1.247 JDIM1.248 JDIM1.251 JDIM1.252 JDIM1.261 JDIM1.262 JDIM2.1 JDIM2.2 JDIM2.5 JDIM2.6 JDIM2.9 JDIM2.10 JDIM2.14 JDIM2.15 JDIM2.18 JDIM2.19 JDIM2.22 JDIM2.23 JDIM2.26 JDIM2.27 JDIM2.30 JDIM2.31 JDIM2.35 JDIM2.36 JDIM2.39 JDIM2.40 JDIM2.43 JDIM2.44 JDIM2.47 JDIM2.48 JDIM2.51 JDIM2.52 JDIM2.56 JDIM2.57 JDIM2.60 JDIM2.61 JDIM2.64 JDIM2.65 JDIM2.68 JDIM2.69 JDIM2.72 JDIM2.73 JDIM2.77 JDIM2.78 JDIM2.81 JDIM2.82 JDIM2.85 JDIM2.86 JDIM2.89 JDIM2.90 JDIM2.93 JDIM2.94 JDIM2.98 JDIM2.99 JDIM2.102 JDIM2.103 JDIM2.106 JDIM2.107 JDIM2.167 JDIM2.168 JDIM2.171 JDIM2.172 JDIM2.175 JDIM2.176 JDIM2.180 JDIM2.181 JDIM2.184 JDIM2.185 JDIM2.188 JDIM2.189 JDIM2.192 JDIM2.193 JDIM2.196 JDIM2.197 JDIM2.201 JDIM2.202 JDIM2.205 JDIM2.206 JDIM2.209 JDIM2.210 JDIM2.213 JDIM2.214 JDIM2.217 JDIM2.218 JDIM2.222 JDIM2.223 JDIM2.226 JDIM2.227 JDIM2.230 JDIM2.231 JDIM2.234 JDIM2.235 JDIM2.238 JDIM2.239 JDIM2.243 JDIM2.244 JDIM2.247 JDIM2.248 JDIM2.251 JDIM2.252 JDIM2.261 JDIM2.262 MR1.3 PAD1.1 PAD2.1 PAD3.1 PAD5.1 PAD6.1 PAD7.1 PAD9.1 PAD10.1 PAD11.1 PAD12.1 PAD13.1 PAD14.1 PAD15.1 PC2.2 PC3.1 PC4.2 PC6.1 PC7.1 PC8.2 PC9.2 PC10.1 PC11.2 PC13.1 PC14.2 PC15.2 PC21.1 PC22.2 PC23.2 PC24.1 PC25.1 PC28.2 PC29.1 PC32.2 PC33.2 PC35.2 PC36.2 PC37.1 PC41.2 PC43.2 PC45.1 PC46.1 PC47.1 PC48.2 PC49.1 PC50.2 PC51.2 PC52.1 PC53.2 PC54.1 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC61.1 PC65.2 PC70.1 PC71.2 PC74.1 PC75.1 PC76.2 PC77.1 PC78.1 PC79.1 PC80.2 PC81.1 PC83.2 PC84.2 PC85.2 PC86.2 PC87.2 PC88.2 PC90.2 PC91.2 PC97.2 PC98.2 PC99.2 PC100.1 PC101.1 PC102.1 PC103.1 PC104.1 PC105.2 PC106.2 PC107.2 PC108.2 PC109.1 PC111.2 PC112.2 PC113.1 PC114.2 PC115.1 PC116.1 PC117.1 PC118.2 PC120.2 PC121.1 PC122.2 PC123.1 PC124.1 PC125.1 PC126.2 PC127.2 PC128.1 PC129.2 PC130.1 PC132.1 PC135.2 PC137.2 PC138.2 PC139.2 PC140.1 PC141.2 PC146.1 PC147.1 PC148.1 PC149.1 PC150.2 PC151.1 PC152.1 PC153.2 PC154.2 PC155.1 PC156.2 PC157.1 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC173.2 PC174.2 PC175.2 PC176.2 PC177.2 PC178.1 PC179.1 PC180.2 PC181.2 PC183.2 PC184.2 PC185.2 PC186.2 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC193.2 PC194.2 PC195.2 PC196.2 PC197.2 PC198.2 PC200.2 PC201.2 PC203.2 PC204.2 PC205.2 PC206.1 PC207.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.1 PC228.2 PC229.2 PC232.2 PC233.2 PC234.2 PC236.2 PC237.1 PC238.2 PC239.2 PC240.1 PC241.1 PC242.2 PC243.2 PC244.2 PC245.2 PC246.2 PC247.1 PC248.2 PC249.2 PC250.2 PC251.1 PC252.1 PC254.2 PC268.2 PC269.2 PC270.2 PC271.2 PC273.2 PC275.2 PC276.1 PC277.2 PC278.2 PC279.2 PC280.2 PC281.2 PC282.2 PC283.2 PC284.2 PC285.1 PC286.1 PC287.2 PC288.2 PC290.2 PC291.2 PC292.2 PC300.1 PC302.2 PC303.1 PC304.1 PC328.2 PC6098.2 PC6100.1 PC6212.2 PC6214.2 PC6216.2 PC6218.2 PC6219.1 PC6220.2 PC6221.2 PC6222.2 PC6224.2 PC6225.1 PC6226.1 PC6227.2 PC6228.2 PC6229.2 PC6230.1 PC6231.1 PC6232.2 PC6233.2 PD1.2 PD2.2 PD3.2 PJ1.1 PJ1.2 PJ1.9 PJ1.10 PJ3.1 PJ3.2 PQ3.1 PQ4.1 PQ5.1 PQ6.1 PQ7.1 PQ8.1 PQ9.1 PQ10.1 PQ11.1 PQ13.1 PQ14.1 PQ15.1 PQ16.1 PQ17.1 PQ18.1 PQ21.1 PQ21.2 PQ21.3 PQ25.1 PQ25.2 PQ25.3 PQ27.1 PQ27.2 PQ27.3 PQ34.1 PQ34.2 PQ34.3 PQ40.1 PQ42.1 PQ42.2 PQ42.3 PQ44.1 PQ44.2 PQ44.3 PQ6053.1 PQ6053.2 PQ6053.3 PQ6056.5 PQ6056.6 PQ6056.7 PQ6057.1 PQ6058.1 PQ6066.1 PR3.1 PR4.2 PR10.1 PR11.1 PR13.1 PR15.1 PR39.2 PR49.2 PR54.2 PR75.2 PR82.1 PR85.1 PR102.2 PR112.1 PR117.1 PR118.2 PR119.2 PR133.2 PR135.1 PR140.2 PR145.2 PR147.2 PR150.2 PR157.2 PR158.2 PR180.2 PR198.2 PR202.2 PR203.2 PR206.2 PR207.2 PR224.2 PR225.2 PR250.1 PR265.2 PR266.2 PR268.2 PR276.1 PR281.2 PR289.1 PR294.1 PR302.1 PR309.2 PR342.1 PR6125.1 PR6297.2 PU1.41 PU2.8 PU2.9 PU4.4 PU4.5 PU4.6 PU5.22 PU5.29 PU5.30 PU5.31 PU5.32 PU5.33 PU5.34 PU5.35 PU5.36 PU5.37 PU5.38 PU6.8 PU6.9 PU7.9 PU7.21 PU8.9 PU8.21 PU9.9 PU9.21 PU10.11 PU10.15 PU11.11 PU11.15 PU13.9 PU13.21 PU14.2 PU15.12 PU15.13 PU15.14 PU15.15 PU15.19 PU16.2 PU18.11 PU19.21 PU20.11 PU20.15 PU21.1 PU21.14 PU21.21 PU22.12 PU22.13 PU22.14 PU22.15 PU22.19 PU6010.21 PU6010.22 PU6010.23 PU6010.24 PU6010.25 PU6010.26 Q3.1 Q3.4 Q4.1 Q15.1 Q17.1 Q19.1 Q21.2 Q26.2 Q27.1 Q30.1 Q36.1 Q37.1 Q37.4 Q40.1 Q56.1 Q56.4 Q59.1 Q76.1 Q115.1 Q129.1 Q4001.1 Q4200.1 Q4201.1 Q4202.1 Q4203.1 Q6059.1 Q6060.1 R38.1 R65.1 R98.2 R109.2 R127.1 R130.1 R145.1 R156.1 R158.1 R161.2 R162.1 R174.1 R176.2 R178.2 R199.1 R213.2 R214.2 R219.2 R222.2 R256.2 R301.1 R337.1 R350.1 R354.1 R364.2 R369.2 R375.2 R376.1 R377.2 R380.1 R389.2 R393.2 R394.2 R399.2 R400.2 R401.1 R447.2 R450.2 R463.2 R532.2 R534.1 R537.1 R548.2 R553.1 R554.2 R555.2 R558.1 R563.1 R564.1 R569.2 R587.2 R592.1 R595.1 R598.1 R605.1 R606.1 R610.1 R612.1 R614.1 R616.1 R621.1 R624.2 R635.1 R642.2 R646.1 R648.2 R678.1 R681.1 R685.1 R692.2 R706.1 R707.1 R720.2 R729.1 R735.2 R736.2 R739.2 R750.2 R759.2 R760.2 R764.1 R766.1 R778.2 R782.2 R783.2 R784.2 R785.2 R786.2 R856.2 R858.2 R860.1 R861.1 R957.1 R968.1 R1318.2 R1319.2 R1323.1 R1333.1 R1335.1 R1337.1 R1367.1 R1415.1 R1416.1 R1438.1 R1466.2 R1472.2 R1508.1 R1510.1 R2872.2 R4005.1 R4009.1 R4011.2 R4012.2 R4202.1 R4206.1 R4208.1 R4209.1 R4211.1 R4212.1 R4308.1 R4309.1 R4310.1 R4311.1 R4312.1 R4313.1 R4314.1 R4315.1 R4325.2 R4326.1 R4332.1 R4334.1 R4337.2 R4338.2 R4339.2 R4340.2 R4343.2 R4345.1 R10873.1 R10877.2 R10882.2 R10886.2 R10895.2 R10927.2 R10930.2 R10937.2 R10938.2 R10943.2 R11043.2 R11044.2 R11064.1 R11114.1 R11188.2 R11200.2 R11209.2 R11210.2 R11258.2 R11262.2 R11264.1 R11273.2 R11276.2 R11277.2 R11287.2 SW1.1 SW1.2 SW1.5 SW1.6 SW2.3 SW2.4 SW2.5 SW2.6 U1.2 U1.5 U3.A1 U3.A3 U3.A12 U3.A14 U3.B5 U3.B10 U3.C1 U3.C3 U3.C4 U3.C11 U3.C12 U3.C14 U3.D10 U3.E1 U3.E3 U3.E12 U3.E14 U3.F5 U3.F10 U3.G5 U3.G10 U3.H1 U3.H2 U3.H13 U3.H14 U3.J1 U3.K1 U3.K2 U3.K13 U3.K14 U3.L5 U3.L10 U3.M5 U3.M10 U3.N1 U3.N3 U3.N12 U3.N14 U3.P10 U3.R1 U3.R3 U3.R4 U3.R11 U3.R12 U3.R14 U3.T5 U3.T10 U3.U1 U3.U3 U3.U12 U3.U14 U4.A1 U4.A3 U4.A12 U4.A14 U4.B5 U4.B10 U4.C1 U4.C3 U4.C4 U4.C11 U4.C12 U4.C14 U4.D10 U4.E1 U4.E3 U4.E12 U4.E14 U4.F5 U4.F10 U4.G5 U4.G10 U4.H1 U4.H2 U4.H13 U4.H14 U4.K1 U4.K2 U4.K13 U4.K14 U4.L5 U4.L10 U4.M5 U4.M10 U4.N1 U4.N3 U4.N12 U4.N14 U4.P10 U4.R1 U4.R3 U4.R4 U4.R11 U4.R12 U4.R14 U4.T5 U4.T10 U4.U1 U4.U3 U4.U12 U4.U14 U5.A1 U5.A3 U5.A12 U5.A14 U5.B5 U5.B10 U5.C1 U5.C3 U5.C4 U5.C11 U5.C12 U5.C14 U5.D10 U5.E1 U5.E3 U5.E12 U5.E14 U5.F5 U5.F10 U5.G5 U5.G10 U5.H1 U5.H2 U5.H13 U5.H14 U5.J1 U5.K1 U5.K2 U5.K13 U5.K14 U5.L5 U5.L10 U5.M5 U5.M10 U5.N1 U5.N3 U5.N12 U5.N14 U5.P10 U5.R1 U5.R3 U5.R4 U5.R11 U5.R12 U5.R14 U5.T5 U5.T10 U5.U1 U5.U3 U5.U12 U5.U14 U6.3 U7.A1 U7.A3 U7.A12 U7.A14 U7.B5 U7.B10 U7.C1 U7.C3 U7.C4 U7.C11 U7.C12 U7.C14 U7.D10 U7.E1 U7.E3 U7.E12 U7.E14 U7.F5 U7.F10 U7.G5 U7.G10 U7.H1 U7.H2 U7.H13 U7.H14 U7.K1 U7.K2 U7.K13 U7.K14 U7.L5 U7.L10 U7.M5 U7.M10 U7.N1 U7.N3 U7.N12 U7.N14 U7.P10 U7.R1 U7.R3 U7.R4 U7.R11 U7.R12 U7.R14 U7.T5 U7.T10 U7.U1 U7.U3 U7.U12 U7.U14 U8.3 U9.3 U9.6 U9.19 U9.33 U9.34 U9.35 U9.36 U9.37 U9.38 U9.39 U9.40 U9.41 U12.5 U12.6 U12.7 U12.8 U13.24 U13.33 U14.3 U15.49 U16.5 U16.6 U16.7 U16.8 U17.2 U17.5 U17.6 U17.7 U17.8 U18.17 U18.33 U18.34 U18.35 U18.36 U18.37 U19.5 U19.10 U19.12 U19.13 U19.15 U19.16 U20.2 U21.3 U21.8 U21.9 U21.11 U22.14 U22.17 U22.18 U22.19 U22.20 U22.21 U22.22 U23.49 U24.3 U24.8 U24.9 U24.11 U25.2 U28.12 U28.21 U28.22 U28.23 U28.24 U28.25 U28.26 U28.27 U33.3 U35.A5 U35.A67 U35.A70 U35.AA2 U35.AA4 U35.AA65 U35.AA68 U35.AB8 U35.AB15 U35.AB16 U35.AB18 U35.AB21 U35.AD8 U35.AD13 U35.AD16 U35.AD19 U35.AD20 U35.AD21 U35.AD62 U35.AE64 U35.AE65 U35.AE66 U35.AE67 U35.AE68 U35.AE69 U35.AF1 U35.AF2 U35.AF4 U35.AF10 U35.AF15 U35.AF17 U35.AF63 U35.AG16 U35.AG17 U35.AG18 U35.AG19 U35.AG20 U35.AG21 U35.AG71 U35.AH6 U35.AH13 U35.AH63 U35.AH64 U35.AH67 U35.AJ4 U35.AJ15 U35.AJ18 U35.AJ20 U35.AK8 U35.AK11 U35.AK16 U35.AK18 U35.AK21 U35.AK22 U35.AK27 U35.AK63 U35.AK68 U35.AK69 U35.AL2 U35.AL4 U35.AL28 U35.AL32 U35.AL35 U35.AL38 U35.AL45 U35.AL48 U35.AL52 U35.AL55 U35.AL58 U35.AL64 U35.AL65 U35.AL66 U35.AM8 U35.AM13 U35.AM21 U35.AM25 U35.AM27 U35.AM43 U35.AM45 U35.AM46 U35.AM55 U35.AM60 U35.AM61 U35.AM68 U35.AM71 U35.AN20 U35.AN23 U35.AN28 U35.AN30 U35.AN32 U35.AN33 U35.AN35 U35.AN37 U35.AN38 U35.AN40 U35.AN42 U35.AN58 U35.AN63 U35.AP10 U35.AP18 U35.AP20 U35.AP23 U35.AP28 U35.AP32 U35.AP35 U35.AP38 U35.AP42 U35.AP58 U35.AP63 U35.AP68 U35.AP70 U35.AR5 U35.AR8 U35.AR11 U35.AR15 U35.AR16 U35.AR20 U35.AR23 U35.AR28 U35.AR35 U35.AR42 U35.AR43 U35.AR45 U35.AR46 U35.AR48 U35.AR50 U35.AR52 U35.AR53 U35.AR55 U35.AR58 U35.AR63 U35.AT2 U35.AT4 U35.AT20 U35.AT23 U35.AT28 U35.AT35 U35.AT42 U35.AT56 U35.AT58 U35.AT63 U35.AT68 U35.AT71 U35.AU10 U35.AU15 U35.AU20 U35.AU32 U35.AU38 U35.AV1 U35.AV68 U35.AV69 U35.AV70 U35.AV71 U35.AW6 U35.AW8 U35.AW10 U35.AW12 U35.AW14 U35.AW16 U35.AW18 U35.AW21 U35.AW23 U35.AW26 U35.AW28 U35.AW30 U35.AW32 U35.AW34 U35.AW36 U35.AW38 U35.AW41 U35.AW43 U35.AW45 U35.AW47 U35.AW49 U35.AW51 U35.AW53 U35.AW55 U35.AW57 U35.AW60 U35.AW62 U35.AW64 U35.AW66 U35.AY66 U35.B10 U35.B14 U35.B18 U35.B22 U35.B30 U35.B34 U35.B39 U35.B44 U35.B48 U35.B53 U35.B58 U35.B62 U35.B66 U35.B71 U35.BA1 U35.BA2 U35.BA6 U35.BA10 U35.BA14 U35.BA18 U35.BA23 U35.BA28 U35.BA32 U35.BA36 U35.BA41 U35.BA45 U35.BA49 U35.BA53 U35.BA57 U35.BA62 U35.BA66 U35.BA71 U35.BB6 U35.BB18 U35.BB26 U35.BB30 U35.BB34 U35.BB38 U35.BB43 U35.BB55 U35.BB60 U35.BB64 U35.BB67 U35.BB70 U35.C1 U35.C5 U35.C25 U35.D6 U35.D10 U35.D11 U35.D14 U35.D18 U35.D22 U35.D25 U35.D26 U35.D30 U35.D34 U35.D39 U35.D44 U35.D45 U35.D47 U35.D48 U35.D53 U35.D58 U35.D62 U35.D66 U35.D69 U35.E6 U35.E11 U35.E15 U35.E18 U35.E21 U35.E46 U35.E50 U35.E53 U35.E56 U35.E65 U35.E71 U35.F1 U35.F2 U35.F4 U35.F8 U35.F13 U35.F22 U35.F23 U35.F27 U35.F28 U35.F32 U35.F33 U35.F35 U35.F37 U35.F38 U35.F40 U35.F42 U35.F68 U35.G5 U35.G6 U35.G10 U35.G22 U35.G43 U35.G45 U35.G48 U35.G52 U35.G55 U35.G58 U35.G60 U35.G63 U35.G66 U35.H15 U35.H18 U35.H71 U35.J8 U35.J11 U35.J13 U35.J25 U35.J28 U35.J32 U35.J35 U35.J38 U35.J42 U35.K16 U35.K18 U35.K22 U35.K61 U35.K63 U35.K64 U35.K65 U35.K66 U35.K67 U35.K68 U35.K70 U35.K71 U35.L2 U35.L4 U35.L8 U35.L11 U35.L16 U35.L17 U35.L18 U35.L20 U35.N6 U35.N10 U35.N13 U35.N19 U35.N21 U35.N65 U35.N68 U35.P17 U35.P19 U35.P20 U35.P21 U35.R6 U35.R13 U35.T2 U35.T4 U35.T15 U35.T17 U35.T18 U35.T21 U35.U10 U35.U63 U35.U64 U35.U66 U35.U67 U35.U69 U35.U70 U35.V16 U35.V17 U35.V18 U35.W6 U35.W9 U35.W13 U35.Y17 U35.Y19 U35.Y20 U35.Y21 U36.3 U37.1 U37.3 U38.3 U40.1 U40.3 U41.4 U42.25 U43.3 U44.9 U44.16 U44.23 U44.32 U44.33 U47.3 U48.3 U49.3 U50.3 U1006.3 U3002.A2 U3002.A33 U3002.AA13 U3002.AA15 U3002.AA17 U3002.AA18 U3002.AA20 U3002.AA22 U3002.AB2 U3002.AB5 U3002.AB7 U3002.AB12 U3002.AB14 U3002.AB16 U3002.AB19 U3002.AB21 U3002.AB23 U3002.AB28 U3002.AB30 U3002.AB32 U3002.AC13 U3002.AC15 U3002.AC17 U3002.AC18 U3002.AC20 U3002.AC22 U3002.AE2 U3002.AE5 U3002.AE7 U3002.AE28 U3002.AE30 U3002.AE32 U3002.AE33 U3002.AG11 U3002.AH2 U3002.AH5 U3002.AH7 U3002.AH10 U3002.AH11 U3002.AH13 U3002.AH16 U3002.AH19 U3002.AH22 U3002.AH24 U3002.AH28 U3002.AH29 U3002.AH30 U3002.AH32 U3002.AH33 U3002.AJ7 U3002.AK7 U3002.AK10 U3002.AL2 U3002.AL5 U3002.AL12 U3002.AL14 U3002.AL15 U3002.AL17 U3002.AL18 U3002.AL20 U3002.AL21 U3002.AL23 U3002.AL24 U3002.AL26 U3002.AL28 U3002.AL30 U3002.AL32 U3002.AL33 U3002.AM13 U3002.AM16 U3002.AM19 U3002.AM22 U3002.AM25 U3002.AN1 U3002.AN4 U3002.AN7 U3002.AN10 U3002.AN13 U3002.AN16 U3002.AN19 U3002.AN22 U3002.AN25 U3002.AN30 U3002.AN34 U3002.AP2 U3002.AP33 U3002.B1 U3002.B4 U3002.B7 U3002.B10 U3002.B22 U3002.B25 U3002.B28 U3002.B31 U3002.B34 U3002.C7 U3002.C10 U3002.C13 U3002.C16 U3002.C19 U3002.C22 U3002.C25 U3002.C28 U3002.D2 U3002.D31 U3002.D33 U3002.E5 U3002.E7 U3002.E10 U3002.E22 U3002.E25 U3002.F7 U3002.F28 U3002.G2 U3002.G3 U3002.G5 U3002.G7 U3002.G10 U3002.G13 U3002.G16 U3002.G19 U3002.G22 U3002.G25 U3002.G28 U3002.G30 U3002.G32 U3002.G33 U3002.K2 U3002.K5 U3002.K7 U3002.K28 U3002.K30 U3002.K32 U3002.K33 U3002.M13 U3002.M15 U3002.M17 U3002.M18 U3002.M20 U3002.M22 U3002.N2 U3002.N5 U3002.N7 U3002.N12 U3002.N14 U3002.N16 U3002.N19 U3002.N21 U3002.N23 U3002.N28 U3002.N30 U3002.N32 U3002.N33 U3002.P13 U3002.P15 U3002.P17 U3002.P18 U3002.P20 U3002.P22 U3002.R12 U3002.R14 U3002.R16 U3002.R19 U3002.R21 U3002.R23 U3002.T2 U3002.T5 U3002.T7 U3002.T13 U3002.T15 U3002.T17 U3002.T18 U3002.T20 U3002.T22 U3002.T28 U3002.T32 U3002.U12 U3002.U14 U3002.U16 U3002.U19 U3002.U21 U3002.U23 U3002.V12 U3002.V14 U3002.V16 U3002.V19 U3002.V21 U3002.V23 U3002.W13 U3002.W15 U3002.W17 U3002.W18 U3002.W20 U3002.W22 U3002.W28 U3002.W32 U3002.Y12 U3002.Y14 U3002.Y16 U3002.Y19 U3002.Y21 U3002.Y23 U4001.3 U4002.3 U4509.3 U4511.2 U4512.5 U4512.6 U4512.7 U4512.8 U4513.3 Y1.2 Y1.4 Y4.2 Y4.4 Y4200.2 Y4200.4
PVDD: L13.1 Q28.1 R338.1
V0P85A_VID0: TP31.1 U35.AN11
VCCGT_PHASE1: PC142.2 PL2.1 PR57.1 PU13.5 PU13.13
VCCGT_PHASE2: PC143.2 PL3.1 PR58.1 PU7.5 PU7.13
VCCGT_SENSE: PR191.1 R155.2 U35.J70
VCCGT_VBST1: PR223.2 PU13.3
VCCGT_VBST2: PR230.2 PU7.3
VCCGT_VCC1: PC146.2 PR61.1 PU13.23 PU13.24
VCCGT_VCC2: PC147.2 PR62.1 PU7.23 PU7.24
VCCK_V12: C4748.2 C4751.2 C4754.2 U13.4 U13.25
VCCOPC_VID0: PR287.2 R707.2 R708.1
VCCOPC_VID0_C: PR287.1 PU14.4
VCCOPC_VID1: PR286.2 R705.1 R706.2
VCCOPC_VID1_C: PR286.1 PU14.3
VCCRTC_2: BT1.1 R308.1
VCCSA_SW: PC145.2 PL5.1 PR59.1 PU9.5 PU9.13
VCCSA_VBST: PR232.2 PU9.3
VCCSA_VCC: PC151.2 PR56.1 PU9.23 PU9.24
VCCST_PWRGD: C136.2 R89.1 U35.B65
VCCST_PWRGD_EN: R102.1 R103.1 R777.2 U47.1
VCCST_PWRGD_EN_L: C823.2 C824.2 R777.1 U6.2 U47.4
VCCST_PWRGD_R: R85.1 R89.2 U6.4
VDD10: C355.1 C757.1 C758.1 C760.1 C761.1 C762.1 R246.2 R11257.1 U15.3 U15.8 U15.33 U15.46
VDD_DAC_33: C4750.2 L4208.2 U13.20
VDDREG: C4599.2 C4600.2 R11266.1 U15.35
VIN: C7.1 C9.2 PC51.1 PC52.2 PC53.1 PC54.2 PC86.1 PC99.1 PC100.2 PC117.2 PC118.1 PC138.1 PC140.2 PC141.1 PC154.1 PC155.2 PC156.1 PC157.2 PC179.2 PC181.1 PC184.1 PC209.1 PC211.1 PC213.1 PC220.1 PC224.1 PC228.1 PC229.1 PC237.2 PC238.1 PC251.2 PC254.1 PC269.1 PC271.1 PC276.2 PC277.1 PC283.1 PC285.2 PC286.2 PC291.1 PC292.1 PC6212.1 PC6214.1 PC6216.1 PC6218.1 PC6220.1 PC6229.1 PC6232.1 PC6233.1 PD4.2 PQ1.5 PQ20.5 PQ24.5 PQ30.5 PQ33.5 PQ41.5 PQ43.5 PQ6054.5 PQ6056.2 PR97.1 PR116.1 PR141.1 PR142.1 PR148.1 PR151.1 PR159.1 PR161.1 PR209.1 PR212.2 PR213.2 PR260.1 PR261.2 PR6130.1 PR6304.1 PU8.6 PU8.22 PU9.6 PU9.22 PU14.1 PU15.8 PU15.9 PU15.22 PU15.24 PU22.8 PU22.9 PU22.22 PU22.24 R14.1 R15.1 R345.1 R686.2
VSSGT_SENSE: PR181.1 R161.1 U35.J69
1P35V_BOOT: PR251.2 PU21.18
1P35V_CS: PR250.2 PU21.13
1P35V_FB: PR258.1 PR266.1 PU21.6
1P35V_LGATE: PQ25.4 PU21.15
1P35V_PGOOD: PR267.1 PU21.10
1P35V_PHASE: PC202.2 PL11.1 PQ24.1 PQ24.2 PQ24.3 PQ25.5 PR90.1 PU21.16
1P35V_S3: PC196.1 PR257.1 PR6302.1 PR6303.2 PU21.7
1P35V_S5: PC203.1 PR263.1 PR6303.1 PU21.8
1P35V_TON: PR261.1 PU21.9
1P35V_UGATE: PQ24.4 PU21.17
1P35V_VDD: PC217.1 PR274.2 PU21.12
1P35V_VDDQ: PR254.1 PR258.2 PU21.5
1P35V_VID: PR264.1 PR265.1 PU21.11
2ND_MBCLK: Q4302.3 R171.1 R733.1 U45.115
2ND_MBDATA: Q4302.6 R175.1 R734.1 U45.116
554EN_0.95V: PC300.2 PR321.1 PU18.5
554FB_0.95V: PC301.1 PR309.1 PR310.2 PU18.6
554FB_0.95V_S: PC301.2 PR310.1 PR311.1
554LX_0.95V: PL14.1 PR319.1 PU18.1 PU18.2 PU18.3
554NC_0.95V: PC247.2 PU18.7
554PG_0.95V: PR317.2 PU18.4
554SVIN_0.95V: PC252.2 PR312.2 PU18.8
681_AGND: PC230.1 PR294.2 PU14.11 R632.1 R636.1
1658R-BOOT1: PR96.2 PU19.1
1658R-BOOT2: PR95.2 PU19.15
1658R-COMP: PC199.1 PC221.1 PU19.12 TP4362.1
1658R-EN: PR276.2 PR345.2 PU19.3
1658R-FB: PC110.1 PR277.2 PU19.11 TP4363.1
1658R-FBRTN: PR279.2 PU19.10
1658R-LGATE1: PQ27.4 PQ42.4 PU19.19
1658R-LGATE2: PQ34.4 PQ44.4 PU19.17
1658R-OCS/CB: PR268.1 PR270.2 PR275.2 PU19.9
1658R-PG: PR252.1 PR259.1 PU19.13
1658R-PHASE1: PC253.2 PL9.1 PQ27.5 PQ33.1 PQ33.2 PQ33.3 PQ41.1 PQ41.2 PQ41.3 PQ42.5 PR89.1 PU19.20
1658R-PHASE2: PC182.2 PL10.1 PQ30.1 PQ30.2 PQ30.3 PQ34.5 PQ43.1 PQ43.2 PQ43.3 PQ44.5 PR91.1 PU19.16
1658R-PSI: PR255.2 PU19.4
1658R-PVCC: PC195.1 PR143.2 PU19.18
1658R-REFADJ: PR106.1 PU19.6
1658R-REFIN: PC178.2 PR114.1 PR115.2 PU19.7
1658R-UGATE1: PQ33.4 PQ41.4 PU19.2
1658R-UGATE2: PQ30.4 PQ43.4 PU19.14
1658R-VID: PR256.2 PU19.5
1658R-VREF: PC206.2 PR113.1 PR270.1 PU19.8
24780_ACDET: PR3.2 PR168.2 PU5.6
24780_ACDRV: PR165.2 PU5.4
24780_ACN: PC2.1 PC5.2 PR209.2 PU5.1
24780_ACP: PC5.1 PC115.2 PR210.2 PU5.2
24780_BATDRV: PR185.2 PU5.18
24780_BATSRC: PR186.2 PU5.17
24780_BM#: PR16.1 PU5.16
24780_BST: PR173.2 PU5.25
24780_CMPIN: PR11.2 PU5.13
24780_CMPOUT: PQ40.2 PR179.1 PU5.14
24780_CMSRC: PR166.2 PU5.3
24780_DH: PQ20.4 PU5.26
24780_DL: PQ21.4 PU5.23
24780_ILIM: PC123.2 PR14.1 PR15.2 PU5.21
24780_LX: PC119.1 PL1.2 PQ20.1 PQ20.2 PQ20.3 PQ21.5 PR2.1 PU5.27
24780_SRN: PC131.1 PC132.2 PR175.1 PR184.2
24780_SRP: PC130.2 PC131.2 PR176.1 PR183.2
24780_VCC: PC116.2 PR5.1 PU5.28
25810_AUO#: R11197.2 U28.17
25810_CC1: CN2021.A5 U28.11 U4513.5
25810_CC2: CN2021.B5 U28.13 U4513.6
25810_DBG#: R11194.2 U28.16
25810_FAULT#: R11206.2 R11281.2 U28.1
25810_LD_DET#: R11208.2 U28.20
25810_POL#: R11203.2 U28.18
25810_REF: R11204.1 U28.10
25810_REF_RTN: R11204.2 U28.9
25810_UFP#: Q15.2 R11193.2 R11252.2 U28.19
25810_UFP#_G1: Q15.3 Q17.2 R11201.1
25810_UFP#_G2: Q17.3 Q6062.4 R11195.1
51225_CS1: PR6124.1 PU6010.1
51225_CS2: PR6122.2 PU6010.5
51225_DH1: PQ6056.1 PU6010.16
51225_DH2: PQ6054.4 PU6010.10
51225_DL1: PQ6056.8 PU6010.15
51225_DL2: PQ6053.4 PU6010.11
51225_EN1: PR6278.1 PU6010.20
51225_FB1: PR6120.1 PR6281.1 PU6010.2
51225_FB2: PR6121.1 PR6279.2 PU6010.4
51225_SW1: PC6215.2 PL6013.2 PQ6056.9 PR6288.1 PU6010.18
51225_SW2: PC6213.1 PL6012.1 PQ6053.5 PQ6054.1 PQ6054.2 PQ6054.3 PR6289.1 PU6010.8
51225_VBST1: PR6287.2 PU6010.17
51225_VBST2: PR6286.1 PU6010.9
51225_VIN: PC6100.2 PR6130.2 PU6010.12
+AZA_VDD: C484.1 C485.1 C527.1 R367.1 R372.1 U23.1 U23.36
+G_SEN_PW: C412.1 C428.1 R318.2 R333.2 R334.2 U19.1 U19.8 U19.14
+TPVDD: C783.1 C790.1 CN17.8 Q42.3 R409.2 R410.2 R752.1
+TYPEC_VBUS: C4647.1 C4648.2 C4649.1 C4650.2 C4764.2 C4767.2 C4768.2 C4819.1 C4820.2 CN2021.A4 CN2021.A9 CN2021.B4 CN2021.B9 EC51.2 Q6062.1 Q6062.2 Q6062.3 R11195.2 R11200.1
+TYPEC_VBUS_C: C4765.2 C4817.1 C4818.2 Q6062.5 U28.14 U28.15
+VGPU_CORE: C4400.2 C4401.2 C4402.2 C4403.2 C4404.1 C4405.1 C4406.1 C4407.1 C4408.1 C4409.1 C4410.1 C4411.1 C4412.1 C4413.1 C4414.1 C4415.1 C4416.1 C4417.1 C4418.1 C4419.1 C4420.1 C4421.1 C4422.1 C4423.2 C4424.2 C4425.2 C4426.2 C4427.2 C4428.2 C4429.2 C4430.1 C4431.1 C4432.1 C4433.1 C4434.1 C4435.1 PC186.1 PC190.1 PC191.1 PC192.1 PC193.1 PC201.1 PC204.1 PC328.1 PL9.2 PL10.2 PR84.1 U3002.AA12 U3002.AA14 U3002.AA16 U3002.AA19 U3002.AA21 U3002.AA23 U3002.AB13 U3002.AB15 U3002.AB17 U3002.AB18 U3002.AB20 U3002.AB22 U3002.AC12 U3002.AC14 U3002.AC16 U3002.AC19 U3002.AC21 U3002.AC23 U3002.M12 U3002.M14 U3002.M16 U3002.M19 U3002.M21 U3002.M23 U3002.N13 U3002.N15 U3002.N17 U3002.N18 U3002.N20 U3002.N22 U3002.P12 U3002.P14 U3002.P16 U3002.P19 U3002.P21 U3002.P23 U3002.R13 U3002.R15 U3002.R17 U3002.R18 U3002.R20 U3002.R22 U3002.T12 U3002.T14 U3002.T16 U3002.T19 U3002.T21 U3002.T23 U3002.U1 U3002.U2 U3002.U3 U3002.U4 U3002.U5 U3002.U6 U3002.U7 U3002.U8 U3002.U13 U3002.U15 U3002.U17 U3002.U18 U3002.U20 U3002.U22 U3002.V1 U3002.V2 U3002.V3 U3002.V4 U3002.V5 U3002.V6 U3002.V7 U3002.V8 U3002.V13 U3002.V15 U3002.V17 U3002.V18 U3002.V20 U3002.V22 U3002.W2 U3002.W3 U3002.W4 U3002.W5 U3002.W7 U3002.W8 U3002.W12 U3002.W14 U3002.W16 U3002.W19 U3002.W21 U3002.W23 U3002.Y4 U3002.Y5 U3002.Y6 U3002.Y7 U3002.Y8 U3002.Y13 U3002.Y15 U3002.Y17 U3002.Y18 U3002.Y20 U3002.Y22
+VREF_CA_CPU: C1252.1 R10878.1 U35.AY67
+VREFDQ_SA_M3: TP4344.1 U35.AY68
+VREFDQ_SB_M3: C1329.1 R10932.1 U35.BA67
+WL_VDD: C338.2 C339.2 C340.1 C346.2 C347.1 C731.1 C735.1 C753.1 C755.1 CN10.2 CN10.4 CN10.72 CN10.74 Q23.2 R221.2 R237.1 R241.2 R242.2 R714.2
A_DE0: R11213.2 U9.29
A_DE1: R254.2 U9.28
A_EQ0: R258.2 U9.32
A_EQ1: R11211.2 U9.31
ACCEL_INT2: D35.1 R326.1
ACCEL_INT2_R: D35.2 U19.9
ACCEL_INTA: C425.2 D8.1 U35.AB1
ACCEL_INTA_R: D8.2 U19.11
ACIN: PR1.2 PR4.1 PR167.1 U45.72
ACZ_SDIN: R359.1 U23.8
ADOGND: C519.2 C520.2 C523.1 C524.2 C526.2 C529.1 C532.2 C534.2 C535.1 C536.2 C537.1 C538.1 C547.2 C550.2 C553.2 C554.2 CN2020.15 CN2020.22 CN2020.24 CN2020.26 R375.1 R390.1 R393.1 R394.1 R397.1 R399.1 R400.1 R401.2 R417.2 R423.2 R750.1 U23.25 U23.38
AMP_MUTE#: D16.1 U45.108
APS1: CN2.1 R289.2 R291.2
APS3: CN2.3 R272.2 R278.1 R289.1
APS7: CN2.7 R271.1 R272.1
AUX_CH_N: C343.2 U13.3
AUX_CH_P: C341.2 U13.2
B_DE0: R11214.2 U9.15
B_DE1: R203.2 U9.16
B_EQ0: R206.2 U9.13
B_EQ1: R11212.2 U9.14
BAT-V: PC120.1 PC121.2 PC125.2 PC126.1 PC127.1 PJ1.7 PJ1.8 PR169.2 PR175.2
BATLED0#: R428.1 R430.1 U45.29
BATLED1#: R429.1 R431.1 U45.25
BEEP_1: C476.2 C477.1 R352.1 R354.2
BI: PJ1.6 PR10.2 R11282.1 SW4.1 SW4.2
BI_GATE: C765.1 Q40.2 Q56.5 R719.2 SW1.3 SW1.4
BL#: Q3.2 Q3.3 R52.1
BL_ON: CN5.26 D1.2 Q3.6 Q4.3 R58.1
BOARD_ID0: R595.2 R600.1 U35.AN3
BOARD_ID1: R598.2 R599.1 U35.AN1
BOARD_ID2: R605.2 R608.1 U35.AN2
BOARD_ID3: R590.1 R592.2 U35.AM4
BOARD_ID4: C803.2 R441.1 R593.1 U35.AM1
BOARD_ID4_TOUCH_S: CN5.2 R441.2
BOARD_ID5: R606.2 R607.1 U35.AM2
BOARD_ID6: R764.2 R765.1 U35.AM3
BOARD_ID7: R766.2 R767.1 U35.AP4
BT_EN: CN10.54 U45.82
C_PEG_TX0: C652.2 U35.A17
C_PEG_TX1: C655.2 U35.C16
C_PEG_TX2: C662.2 U35.C17
C_PEG_TX3: C660.2 U35.A19
C_PEG_TX#0: C653.1 U35.B17
C_PEG_TX#1: C656.2 U35.D16
C_PEG_TX#2: C661.2 U35.D17
C_PEG_TX#3: C654.2 U35.B19
CATERR#: R788.2 TP65.1 U35.D63
CCD_PWR: C16.2 C27.2 CN5.32 CN5.33 R11.2
CFG4: R548.1 U35.E70
CFG_RCOMP: R156.2 U35.E60
CHA_SA0: JDIM1.256 R10872.2 R10882.1
CHA_SA1: JDIM1.260 R10880.2 R10886.1
CHA_SA2: JDIM1.166 R10877.1 R10889.2
CHB_SA0: JDIM2.256 R10924.2 R10943.1
CHB_SA1: JDIM2.260 R10937.1 R10940.2
CHB_SA2: JDIM2.166 R10923.2 R10927.1
CIIC_SCL: R11189.1 U13.30
CIIC_SDA: R11190.1 U13.29
CLK_PCI_EC: R373.2 R623.1 U45.13
CLK_PCI_LPC: C4723.1 R627.1 R694.2
CLK_PCI_LPC_C: CN10.71 R694.1
CLK_PCIE_LAN_REQ#: Q25.3 R229.1 R276.2 R281.2
CLK_PCIE_LANN: U15.24 U35.B40
CLK_PCIE_LANP: U15.23 U35.A40
CLK_PCIE_REQ0#: R234.1 R235.2 U35.AR10
CLK_PCIE_REQ1#: R215.1 R11111.2 U35.AT7
CLK_PCIE_REQ2#: R227.1 U35.AT8
CLK_PCIE_REQ3#: R618.1 TP22.1 U35.AT10
CLK_PCIE_REQ4#: R228.1 R229.2 U35.AU8
CLK_PCIE_REQ5#: R223.1 R224.2 U35.AU7
CLK_PCIE_VGA: U35.C42 U3002.AL13
CLK_PCIE_VGA#: U35.D42 U3002.AK13
CLK_PCIE_WLANN: CN10.49 U35.E40
CLK_PCIE_WLANP: CN10.47 U35.E38
CLK_PCIE_XDPN: TP93.1 U35.F43
CLK_PCIE_XDPP: TP94.1 U35.E43
CLK_PEGA_REQ#: Q4002.3 R235.1
CLK_SCLK: JDIM1.253 JDIM2.253 Q32.1 R329.1 R572.1 R11189.2
CLK_SDATA: JDIM1.254 JDIM2.254 Q32.4 R336.1 R576.1 R11190.2
CLKRUN#: C807.2 R630.2 R743.2 U35.AW11 U45.93
CLR_CMOS: Q6059.2 Q6060.2 R786.1 U45.79
CODEC_VREF: C535.2 U23.28
CPU_DRAMRST#: R670.2 R679.2 U35.AT13
CPU_THRMTRIP#: R529.2 R530.2 U35.C63
CRT_11: CN7.11 TP75.1
CRT_AUXN: C343.1 R10847.2
CRT_AUXP: C341.1 R10848.2
CRT_B1: C319.2 CN7.3 L5.2 U38.5 U38.6
CRT_BLU: C320.2 L5.1 R213.1 U13.21
CRT_CLK: R577.1 U35.N7
CRT_DATA: R152.1 U35.N8
CRT_G1: C333.2 CN7.2 L6.2 U38.2 U38.9
CRT_GRE: C334.2 L6.1 R219.1 U13.22
CRT_HPD: R10846.2 U13.32
CRT_R1: C336.2 CN7.1 L7.2 U38.1 U38.10
CRT_RED: C337.2 L7.1 R222.1 U13.23
CRT_TXN0: C331.1 R10843.2
CRT_TXN1: C315.1 R10845.2
CRT_TXP0: C335.1 R10842.2
CRT_TXP1: C329.1 R10844.2
CRTHSYNC: C718.1 CN7.13 R11268.2 R11269.2 U36.1 U36.10
CRTHSYNC_B: R11267.1 R11268.1
CRTVDD5: C300.2 C301.1 C304.2 C305.1 CN7.9 Q21.1 R601.2 R620.2 U36.2 U36.9
CRTVSYNC: C716.1 CN7.14 R11271.2 R11272.2 U36.4 U36.7
CRTVSYNC_B: R11270.1 R11271.1
CTL2: R360.2 U22.7
CTL3: R356.2 U22.8
D/C#: PC6.2 PR171.1 TP4366.1
DC-DET: R344.1 R350.2 U23.4
DCPRTC: C732.1 U35.BB10
DDCCLK: C714.1 CN7.15 R601.1 U13.15 U36.5 U36.6
DDCDAT: C724.1 CN7.12 R620.1 U13.16 U38.4 U38.7
DDI2_AUXN: R533.2 R10847.1 U35.E48
DDI2_AUXP: R532.1 R10848.1 U35.F48
DDI2_TXN0: R10843.1 U35.C50
DDI2_TXN1: R10845.1 U35.C52
DDI2_TXP0: R10842.1 U35.D50
DDI2_TXP1: R10844.1 U35.D52
DDR3_DRAMRST#: C750.1 C1258.2 C1317.2 JDIM1.108 JDIM2.108 R670.1
DDR4_SUSON_2V5: PR307.1 U45.122
DDR_VTT_CTRL: Q35.1 R621.2 U35.AW67
DDR_VTTREF: C1245.1 C1249.1 C1251.1 C1270.1 C1275.1 C1310.1 C1311.1 C1315.1 C1319.1 C1333.1 EC35.1 EC40.1 JDIM1.258 JDIM2.258 PC207.1 PU21.2 PU21.20
DDR_VTTT_PG_CTRL: PR6302.2 Q35.3 R682.2
DEVSLP0: R351.1 R573.1 U35.J1
DEVSLP0_R: CN14.9 R351.2
DEVSLP2: R575.1 R956.2 U35.J3
DEVSLP_N1: CN23.38 R956.1 R957.2
DGPU_D: PC113.2 PQ16.3 PQ19.2 PR161.2
DGPU_EVENT#: R4335.2 U35.AP5
DGPU_HOLD_RST#: R208.1 U35.AP7 U4001.1
DGPU_OPP#: Q4301.3 R382.1 U45.68
DGPU_OTP#: Q4301.6 R740.1 U45.124
DGPU_PGOK-1: C4202.1 Q4202.2 Q4203.3 R4205.1
DGPU_POK2: C4203.1 Q4203.2 R4207.1
DGPU_PSI: PR101.2 PR102.1 PR104.2 PR255.1 R4324.2 U3002.M4
DGPU_PW_CTRL#: R115.1 R127.2 U35.BA5
DGPU_PWR_EN: PR160.1 R256.1 R257.2 U35.AP8
DGPU_PWROK: Q4202.3 R110.1 R4204.1 R4206.2 U35.AM5
DMIC_CLK: R370.2 U23.3
DMIC_CLK0_R: TP4372.1 U35.H5
DMIC_CLK_L: C488.1 R370.1 R11047.2 R11186.2
DMIC_CLK_L1: C378.1 D4.1 R11179.2 U16.3
DMIC_CLK_L2: C4737.1 D4014.1 R11175.2 U4512.3
DMIC_CLK_L_R0: C357.1 D2.1 R11186.1 U17.3
DMIC_CLK_L_R1: R270.1 R11179.1 R11181.2
DMIC_CLK_L_R2: R11175.1 R11182.1
DMIC_DAT: R371.2 U23.2
DMIC_DAT_L: R270.2 R371.1 R11185.2
DMIC_DAT_L1: C379.1 D5.1 R11180.2 U16.4
DMIC_DAT_L2: C4736.1 D4013.1 R11176.2 U4512.4
DMIC_DAT_L_R0: C374.1 D3.1 R11185.1 U17.4
DMIC_DAT_L_R1: R11047.1 R11180.1 R11182.2
DMIC_DAT_L_R2: R11176.1 R11181.1
DMIC_DATA0_R: TP4373.1 U35.D7
DNBSWON#: R677.1 U45.123
DP_UTIL: R546.2 R553.2 U35.B52
DPWROK_R: R661.1 U35.BB20
EC_FPBACK#: Q4.2 U45.86
EC_GND: L11.1 R782.1 R783.1 R784.1 R785.1 U45.1 U45.27 U45.49 U45.91 U45.104
EC_ODD_EJ#: CN9.11 R209.1 R746.1
EC_ODD_EJ#_R: C799.1 R746.2 U45.94
EC_PECR_R: R738.1 U45.117
EC_PWROK: R130.2 R131.2 R560.2 U8.2 U45.33
EC_PWROK_R: R643.2 R647.1 U35.BA20
EC_RCIN#: R639.2 R652.2 U35.AW13
EC_TYPEC_CHG_HI: R11280.2 U45.3
EC_TYPEC_EN: R11153.1 U45.80
EC_TYPEC_EN_R: R11153.2 R11278.1 U28.6
ECAGND: C495.2 C516.1 L11.2 U45.75
EDP_AUX#_C: C2.2 CN5.22 R449.2 R450.1
EDP_AUX_C: C4.2 CN5.23 R447.1 R448.2
EDP_AUXN: C2.1 U35.E45
EDP_AUXP: C4.1 U35.F45
EDP_HPD: C804.2 R457.1 R563.2 U35.L10
EDP_HPD_R: CN5.25 R457.2
EDP_RCOMP: R154.1 U35.E52
EDP_TXN0: C12.1 U35.C47
EDP_TXN0_C: C12.2 CN5.16
EDP_TXN1: C8.1 U35.D46
EDP_TXN1_C: C8.2 CN5.19
EDP_TXN2: C3225.1 U35.A45
EDP_TXN2_C: C3225.2 CN5.7
EDP_TXN3: C3226.1 U35.A47
EDP_TXN3_C: C3226.2 CN5.4
EDP_TXP0: C13.1 U35.C46
EDP_TXP0_C: C13.2 CN5.17
EDP_TXP1: C10.1 U35.C45
EDP_TXP1_C: C10.2 CN5.20
EDP_TXP2: C3224.1 U35.B45
EDP_TXP2_C: C3224.2 CN5.8
EDP_TXP3: C3227.1 U35.B47
EDP_TXP3_C: C3227.2 CN5.5
EDP_VDD_EN: R37.1 U35.U13
EDP_VDD_EN_R: R37.2 R38.2 U1.3
ENSWREG: R11258.1 U15.34
EVDD10: C244.2 C4596.1 R11257.2 U15.20
FAN1_DAC: U12.4 U45.81
FAN1_RPM: C719.2 CN8.2 R609.2 U45.47
FB_CAL_PD_VDDQ: R859.2 U3002.J27
FB_CAL_PU_GND: R860.2 U3002.H27
FB_CAL_TERM_GND: R861.2 U3002.H25
FB_DLL_AVDD: C1211.1 C1212.1 L26.1 U3002.K27
FB_GND_SENSE: R858.1 U3002.F2
FB_PLL_AVDD: C963.1 C965.1 C4112.2 L4100.1 L4206.1 U3002.H17 U3002.U27
FB_VDDQ_SENSE: R857.1 U3002.F1
FBA_CMD0: U5.G12 U3002.U30
FBA_CMD1: U5.H10 U3002.T31
FBA_CMD2: U5.H11 U3002.U29
FBA_CMD3: U5.K11 U3002.R34
FBA_CMD4: U5.K10 U3002.R33
FBA_CMD5: U5.L12 U3002.U32
FBA_CMD6: U5.K4 U3002.U33
FBA_CMD7: U5.K5 U3002.U28
FBA_CMD8: U5.J4 U3002.V28
FBA_CMD9: U5.J5 U3002.V29
FBA_CMD10: U5.H4 U3002.V30
FBA_CMD11: U5.H5 U3002.U34
FBA_CMD12: U5.G3 U3002.U31
FBA_CMD13: R1466.1 U5.J2 U3002.V34
FBA_CMD14: R1467.1 U5.J3 U3002.V33
FBA_CMD15: U5.L3 U3002.Y32
FBA_CMD16: U7.L12 U3002.AA31
FBA_CMD17: U7.K10 U3002.AA29
FBA_CMD18: U7.K11 U3002.AA28
FBA_CMD19: U7.H11 U3002.AC34
FBA_CMD20: U7.H10 U3002.AC33
FBA_CMD21: U7.G12 U3002.AA32
FBA_CMD22: U7.H4 U3002.AA33
FBA_CMD23: U7.H5 U3002.Y28
FBA_CMD24: U7.J4 U3002.Y29
FBA_CMD25: U7.J5 U3002.W31
FBA_CMD26: U7.K4 U3002.Y30
FBA_CMD27: U7.K5 U3002.AA34
FBA_CMD28: U7.L3 U3002.Y31
FBA_CMD29: R1472.1 U7.J2 U3002.Y34
FBA_CMD30: R1473.1 U7.J3 U3002.Y33
FBA_CMD31: U7.G3 U3002.V31
FBA_DBI0: U5.D2 U3002.P30
FBA_DBI1: U5.D13 U3002.F31
FBA_DBI2: U5.P13 U3002.F34
FBA_DBI3: U5.P2 U3002.M32
FBA_DBI4: U7.P2 U3002.AD31
FBA_DBI5: U7.P13 U3002.AL29
FBA_DBI6: U7.D13 U3002.AM32
FBA_DBI7: U7.D2 U3002.AF34
FBA_DEBUG0: R4103.2 U3002.R32
FBA_DEBUG0_K: TP4106.1 U3002.R28
FBA_DEBUG1: R4105.2 U3002.AC32
FBA_DEBUG1_K: TP4107.1 U3002.AC28
FBA_EDC0: U5.C2 U3002.M31
FBA_EDC1: U5.C13 U3002.G31
FBA_EDC2: U5.R13 U3002.E33
FBA_EDC3: U5.R2 U3002.M33
FBA_EDC4: U7.R2 U3002.AE31
FBA_EDC5: U7.R13 U3002.AK30
FBA_EDC6: U7.C13 U3002.AN33
FBA_EDC7: U7.C2 U3002.AF33
FBB_CMD0: U3.G12 U3002.D13
FBB_CMD1: U3.H10 U3002.E14
FBB_CMD2: U3.H11 U3002.F14
FBB_CMD3: U3.K11 U3002.A12
FBB_CMD4: U3.K10 U3002.B12
FBB_CMD5: U3.L12 U3002.C14
FBB_CMD6: U3.K4 U3002.B14
FBB_CMD7: U3.K5 U3002.G15
FBB_CMD8: U3.J4 U3002.F15
FBB_CMD9: U3.J5 U3002.E15
FBB_CMD10: U3.H4 U3002.D15
FBB_CMD11: U3.H5 U3002.A14
FBB_CMD12: U3.G3 U3002.D14
FBB_CMD13: R1318.1 U3.J2 U3002.A15
FBB_CMD14: R1308.1 U3.J3 U3002.B15
FBB_CMD15: U3.L3 U3002.C17
FBB_CMD16: U4.L12 U3002.D18
FBB_CMD17: U4.K10 U3002.E18
FBB_CMD18: U4.K11 U3002.F18
FBB_CMD19: U4.H11 U3002.A20
FBB_CMD20: U4.H10 U3002.B20
FBB_CMD21: U4.G12 U3002.C18
FBB_CMD22: U4.H4 U3002.B18
FBB_CMD23: U4.H5 U3002.G18
FBB_CMD24: U4.J4 U3002.G17
FBB_CMD25: U4.J5 U3002.F17
FBB_CMD26: U4.K4 U3002.D16
FBB_CMD27: U4.K5 U3002.A18
FBB_CMD28: U4.L3 U3002.D17
FBB_CMD29: R1319.1 U4.J2 U3002.A17
FBB_CMD30: R1309.1 U4.J3 U3002.B17
FBB_CMD31: U4.G3 U3002.E17
FBB_DBI0: U3.D2 U3002.E11
FBB_DBI1: U3.D13 U3002.E3
FBB_DBI2: U3.P13 U3002.A3
FBB_DBI3: U3.P2 U3002.C9
FBB_DBI4: U4.P2 U3002.F23
FBB_DBI5: U4.P13 U3002.F27
FBB_DBI6: U4.D13 U3002.C30
FBB_DBI7: U4.D2 U3002.A24
FBB_DEBUG0: R4100.2 U3002.C12
FBB_DEBUG0_K: TP4104.1 U3002.G14
FBB_DEBUG1: R4102.2 U3002.C20
FBB_DEBUG1_K: TP4105.1 U3002.G20
FBB_EDC0: U3.C2 U3002.D10
FBB_EDC1: U3.C13 U3002.D5
FBB_EDC2: U3.R13 U3002.C3
FBB_EDC3: U3.R2 U3002.B9
FBB_EDC4: U4.R2 U3002.E23
FBB_EDC5: U4.R13 U3002.E28
FBB_EDC6: U4.C13 U3002.B30
FBB_EDC7: U4.C2 U3002.A23
FBVDDQ_EN: D4000.3 PR122.2 R4012.1
FCCM_A: PR42.2 PR238.1
FCCM_B: PR26.1 PR229.1 PR234.1
FCCM_C: PR46.2 PR240.1
G5335-AGND: PC92.2 PC293.2 PR100.2 PR109.2 PR117.2 PU22.4
G5335-AGND-1: PC89.2 PC272.2 PR82.2 PR87.2 PR92.2 PU15.4
G5335-BST: PR123.1 PU22.20
G5335-BST-1: PR99.1 PU15.20
G5335-EN: PC293.1 PR122.1 PU22.2
G5335-EN-1: PC272.1 PR83.1 PU15.2
G5335-FB: PC274.1 PR100.1 PR108.2 PU22.5
G5335-FB-1: PC235.1 PR86.2 PR92.1 PU15.5
G5335-LX: PC289.2 PL18.1 PR120.1 PU22.10 PU22.11 PU22.16 PU22.17 PU22.18 PU22.25
G5335-LX-1: PC267.2 PL15.1 PR98.1 PU15.10 PU15.11 PU15.16 PU15.17 PU15.18 PU15.25
G5335-PFM: PR103.1 PR109.1 PU22.3
G5335-PFM-1: PR87.1 PR93.1 PU15.3
G5335-PWRGD: PR110.1 PU22.1
G5335-PWRGD-1: PR94.1 PU15.1
G5335-SS: PC92.1 PU22.23
G5335-SS-1: PC89.1 PU15.23
G5335-TON: PR116.2 PU22.6
G5335-TON-1: PR97.2 PU15.6
G5335-VCC: PC280.1 PR111.2 PU22.21
G5335-VCC-1: PC243.1 PR88.2 PU15.21
G5719LX2.5V: PL17.1 PU16.3
G_MBCLK_R: C431.1 R329.2 R333.1 U19.4
G_MBDATA_R: C454.1 R334.1 R336.2 U19.6
GC6_FB_EN: D4000.1 R199.2 R204.1 R4328.2 U35.AN7
GC6_FB_EN_R: Q4300.1 R4326.2 R4329.1 U3002.P6
GFX_SCL: Q4302.4 R4341.1 U3002.T4
GFX_SDA: Q4302.1 R4342.1 U3002.T3
GPIO10_VREF: Q115.2 Q129.2 R4323.1 R4325.1 U3002.L1
GPIO12_ACIN: Q4301.4 R4319.1 R4346.2 U3002.N3
GPU_ALERT: R4317.2 U3002.M2
GPU_BUFRST: R4343.1 U3002.L2
GPU_EVENT#_D: Q4300.4 R4318.1 R4336.1 U3002.M7
GPU_OVT#: Q4301.1 R4316.2 U3002.M1
GPU_PEX_RST_HOLD#: R4322.1 U3002.P1 U4002.1
GPU_PWR_GD: D4000.2 PR252.2
GPU_THROTTING#: PQ40.3 R4346.1
GPX: TP4359.1 U44.3
GSPI0_MOSI: R619.2 U35.AR7
GSPI1_MOSI: R207.2 U35.AN5
H_CPU_SVIDART#: R552.1 U35.B63
H_CPU_SVIDCLK: PR35.1 PR341.2 U35.A63
H_CPU_SVIDDAT: PR40.2 PR340.2 R138.2 U35.D64
H_PECI: R738.2 U35.A54
H_PROCHOT#: PR32.1 PR174.1 PR200.2 PU5.10 Q30.3 R465.1 R531.1
H_PROCHOT#_R: R531.2 U35.C65
HDA_BCLK_R: R644.2 U35.AY22
HDA_RST#_R: R660.2 U35.AW22
HDA_SDO_R: R645.2 R737.2 U35.BB22
HDA_SYNC_R: C742.2 R667.2 U35.BA22
HDMI_5V: C383.1 CN12.18 D6.1 D30.2 D31.2 Q26.1
HDMI_DDCCLK_MB: CN12.15 R316.2 U18.19
HDMI_DDCCLK_SW: R322.1 U18.7 U35.L13
HDMI_DDCDATA_MB: CN12.16 R317.2 U18.20
HDMI_DDCDATA_SW: R319.1 U18.6 U35.L12
HDMI_EQ0: R11274.1 R11277.1 U18.8
HDMI_EQ1: R11275.1 R11276.1 U18.2
HDMI_MB_HPD: R720.1 R721.1 U18.21
HDMI_MB_HPD_R: Q41.3 R718.1 R11064.2 U18.5
HP-L2: C552.2 R421.1 R422.2 R423.1 U23.32
HP-L3: C553.1 CN2020.23 R422.1
HP-R2: C549.2 R417.1 R418.1 R420.2 U23.33
HP-R3: C550.1 CN2020.25 R420.1
HP_DET_CN: CN12.19 R721.2
HP_JD#: CN2020.14 R383.1
HSYNC: R11191.1 R11267.2 U40.2
HSYNC_C: R11191.2 U13.19
HWPG: D11.2 D14.2 D17.2 D18.2 D20.2 D4001.2 D4012.2 R102.2 R374.1 U45.21
HWPG_1.5V: D18.1 PR53.1 PU2.1
HWPG_1.05VGFX: PR317.1 PR318.1 TP76.1
HWPG_1.8VS5: D11.1 PR73.1 PU6.1
HWPG_1.35VGFX: PR110.2 PR296.1 R4207.2
HWPG_1VS5: D17.1 PR94.2 PR295.1
HWPG_2.5V: D4001.1 PR306.1 PR314.1
HWPG_+VCCOPC: D14.1 PR290.1 PR293.1
HWPG_VDDR: D20.1 PR107.1 PR267.2
I2C0_SCL: Q43.4 R166.2 R403.1 U35.U6
I2C0_SDA: Q43.1 R167.2 R405.1 U35.U7
I2C1_SCL: Q2.3 R13.2 R169.1 U35.U9
I2C1_SCL_C: Q2.4 R6.1 R12.1 R13.1
I2C1_SDA: Q2.6 R10.2 R165.1 U35.U8
I2C1_SDA_C: Q2.1 R5.1 R9.1 R10.1
I2C_TP_SCL_R: CN17.3 Q43.3 R403.2 R410.1
I2C_TP_SDA_R: CN17.4 Q43.6 R405.2 R409.1
I2CA_SCL: R4208.2 U3002.R4
I2CA_SDA: R4209.2 U3002.R5
I2CB_SCL: R4337.1 U3002.R7
I2CB_SDA: R4338.1 U3002.R6
I2CC_SCL: R4339.1 U3002.R2
I2CC_SDA: R4340.1 U3002.R3
ICMNT: C516.2 PC3.2 PR170.1 U45.67
ILIM_HI: R377.1 U22.16
ILIM_LO: R376.2 U22.15
IMVP_PWRGD: PR30.1 PR197.2 R478.1 U33.2
IMVP_PWRGD_3V: Q31.2 R113.2 R478.2 R485.2 U8.1 U33.4
INT_AMIC-VREFO: C534.1 R397.2 U23.27
INT_HDMI_HPD: Q41.1 R718.2 R722.2 U35.L9
INT_HDMICLK+: C389.1 U35.G56
INT_HDMICLK+_C: CN12.10 R303.1 U18.10
INT_HDMICLK+_C_R: C389.2 U18.31
INT_HDMICLK-: C387.1 U35.F56
INT_HDMICLK-_C: CN12.12 R303.2 U18.9
INT_HDMICLK-_C_R: C387.2 U18.32
INT_HDMITX0N: C398.1 U35.F53
INT_HDMITX0N_C: CN12.9 R312.2 U18.15
INT_HDMITX0N_C_R: C398.2 U18.26
INT_HDMITX0P: C405.1 U35.G53
INT_HDMITX0P_C: CN12.7 R312.1 U18.16
INT_HDMITX0P_C_R: C405.2 U18.25
INT_HDMITX1N: C406.1 U35.E58
INT_HDMITX1N_C: CN12.6 R314.2 U18.13
INT_HDMITX1N_C_R: C406.2 U18.28
INT_HDMITX1P: C407.1 U35.F58
INT_HDMITX1P_C: CN12.4 R314.1 U18.14
INT_HDMITX1P_C_R: C407.2 U18.27
INT_HDMITX2N: C408.1 U35.E55
INT_HDMITX2N_C: CN12.3 R315.2 U18.11
INT_HDMITX2N_C_R: C408.2 U18.30
INT_HDMITX2P: C411.1 U35.F55
INT_HDMITX2P_C: CN12.1 R315.1 U18.12
INT_HDMITX2P_C_R: C411.2 U18.29
INTRUDER#: R249.1 U35.AP16
IOAC_LAN_WAKE#: R715.2 U45.87
IOAC_RST#: R680.1 R11260.1 U45.85
IOAC_WLAN_WAKE#: Q23.6 R243.1 R244.2 U45.16
IRQ_SERIRQ: R629.2 U35.AY11 U44.27 U45.5
ISEN1_B: PC18.1 PR19.1 PR188.2 PU1.9
ISEN2_B: PC17.1 PR18.2 PR189.1 PR6301.1 PU1.10
ISL95857_COMP_A: PC24.2 PR199.1 PU1.16
ISL95857_COMP_B: PC21.2 PR195.1 PU1.4
ISL95857_COMP_C: PC37.2 PR216.1 PU1.24
ISL95857_FB_A: PR34.1 PR36.1 PR201.1 PU1.17
ISL95857_FB_B: PR23.1 PR24.1 PR194.1 PU1.5
ISL95857_FB_C: PR44.1 PR45.1 PR217.1 PU1.25
ISL95857_FCCM_A: PR42.1 PU1.21
ISL95857_FCCM_B: PR26.2 PU1.11
ISL95857_FCCM_C: PR46.1 PU1.29
ISL95857_IMON_A: PC23.1 PR202.1 PU1.14
ISL95857_IMON_B: PC22.1 PR198.1 PU1.2
ISL95857_IMON_C: PC36.1 PR207.1 PU1.23
ISL95857_ISUMN_A: PC34.2 PR211.1 PU1.20
ISL95857_ISUMN_B: PC19.1 PR192.2 PU1.8
ISL95857_ISUMN_C: PC40.2 PR220.1 PU1.28
ISL95857_NTC_A: PR235.1 PR236.1 PU1.15
ISL95857_NTC_B: PR226.1 PR227.1 PU1.3
ISL95857_PROG1: PR203.1 PU1.32
ISL95857_PROG2: PR206.1 PU1.31
ISL95857_PSYS: PR25.1 PU1.1
ISL95857_PWM1_B: PR27.2 PU1.12
ISL95857_PWM2_B: PR29.2 PU1.13
ISL95857_PWM_A: PR43.1 PU1.22
ISL95857_PWM_C: PR47.1 PU1.30
ISL95857_RTN_A: PC27.2 PC29.2 PR38.1 PR39.1 PU1.18
ISL95857_RTN_B: PC10.2 PC12.2 PR180.1 PR181.2 PU1.6
ISL95857_RTN_C: PC44.2 PC45.2 PR49.1 PR52.1 PU1.26
ISL95857_SCLK: PR35.2 PU1.37
ISL95857_SDA: PR40.1 PU1.35
ISL95857_VCC: PC32.1 PR204.2 PU1.34
ISL95857_VIN: PC35.1 PR212.1 PU1.33
ISL95857_VR_EN: PR28.2 PU1.40
ISL95857_VR_HOT: PR32.2 PU1.38
ISL95857_VR_READY: PR30.2 PU1.39
ISOLATEB: R11262.1 R11263.2 U15.31
ISUMN_A: PC30.2 PC31.1 PC33.1 PR41.2 PR208.1 PR211.2 PR214.1 PR243.2
ISUMN_B: PC14.1 PC17.2 PC18.2 PC20.2 PC134.2 PR17.1 PR21.1 PR22.1 PR182.1 PR192.1 PR241.1
ISUMN_C: PC38.2 PC39.1 PC43.1 PR48.2 PR219.1 PR220.2 PR221.1 PR242.2
ISUMP_A: PC30.1 PC31.2 PR205.2 PR208.2 PR215.1 PU1.19
ISUMP_B: PC20.1 PC134.1 PR20.1 PR22.2 PR190.1 PR193.2 PU1.7
ISUMP_C: PC38.1 PC39.2 PR218.2 PR219.2 PR222.1 PU1.27
JTAG_TCK: R4332.2 TP4300.1 U3002.AM10
JTAG_TDI: R4331.2 TP4303.1 U3002.AM11
JTAG_TDO: TP4305.1 U3002.AP12
JTAG_TMS: R4330.2 TP4301.1 U3002.AP11
JTAG_TRST#: R4334.2 TP4307.1 U3002.AN11
KB_BL_LED: Q19.2 U45.113
L_SPK+: R404.1 U23.42
L_SPK+_1: C545.1 CN18.4 R404.2
L_SPK-: R406.1 U23.43
L_SPK-_1: C546.1 CN18.3 R406.2
LAN_MCT0: R251.2 U42.24
LAN_MCT1: R11265.2 U42.21
LAN_MCT2: R262.2 U42.18
LAN_MCT3: R269.2 U42.15
LAN_MX0+: CN11.1 U42.14
LAN_MX0-: CN11.2 U42.13
LAN_MX1+: CN11.3 U42.17
LAN_MX1-: CN11.6 U42.16
LAN_MX2+: CN11.4 U42.20
LAN_MX2-: CN11.5 U42.19
LAN_MX3+: CN11.7 U42.23
LAN_MX3-: CN11.8 U42.22
LAN_XTAL2: C4605.2 U15.45 Y1.3
LAN_XTALI: C4606.2 U15.44 Y1.1
LANE0_N: C331.2 U13.6
LANE0_P: C335.2 U13.5
LANE1_N: C315.2 U13.8
LANE1_P: C329.2 U13.7
LANPWR#: R259.1 R260.2 U45.70
LANVCC: C350.2 C354.1 C365.1 C366.1 C367.2 C370.1 C377.2 Q39.2 R247.1 R248.2 R702.1 R11259.2 R11266.2 U15.11 U15.48
LCDVCC: C29.2 C30.1 C33.2 C34.1 C35.2 R28.1 U1.1
LCDVCC_R: C580.2 C581.1 CN5.34 CN5.35 CN5.36 R28.2
LID#: D1.1 D23.2 R53.2 R460.2 R11129.1
LID#15: MR1.2 R435.1 R11129.2
LINE1-L: C552.1 U23.22
LINE1-R: C549.1 U23.21
LINE1-VREFO-L: R421.2 U23.31
LINE1-VREFO-R: R418.2 U23.30
LM393_PIN2: PR146.2 PR262.2 PU4.2
LPC_LAD0: R659.1 R688.1 U44.24 U45.10
LPC_LAD0_C: CN10.64 R688.2
LPC_LAD1: R640.1 R690.1 U44.21 U45.9
LPC_LAD1_C: CN10.66 R690.2
LPC_LAD2: R653.1 R693.1 U44.18 U45.8
LPC_LAD2_C: CN10.68 R693.2
LPC_LAD3: R668.1 R696.1 U44.15 U45.7
LPC_LAD3_C: CN10.70 R696.2
LPC_LFRAME#: R699.2 U35.BA12 U44.20 U45.6
LPC_LFRAME#_C: CN10.73 R699.1
LPCPD: R744.2 U44.28
LPM_ZVM_N: PR280.1 R762.2
M_A_A0: JDIM1.144 U35.AY50
M_A_A1: JDIM1.133 U35.BB50
M_A_A2: JDIM1.132 U35.AY51
M_A_A3: JDIM1.131 U35.BA50
M_A_A4: JDIM1.128 U35.BB52
M_A_A5: JDIM1.126 U35.BA51
M_A_A6: JDIM1.127 U35.BA52
M_A_A7: JDIM1.122 U35.AW52
M_A_A8: JDIM1.125 U35.AY52
M_A_A9: JDIM1.121 U35.BB54
M_A_A10: JDIM1.146 U35.AT50
M_A_A11: JDIM1.120 U35.BA54
M_A_A12: JDIM1.119 U35.AW54
M_A_A13: JDIM1.158 U35.AU46
M_A_ACT#: JDIM1.114 U35.BA55
M_A_ALERT#: JDIM1.116 R11043.1 U35.AW50
M_A_BA#0: JDIM1.150 U35.AU52
M_A_BA#1: JDIM1.145 U35.AT48
M_A_BG#0: JDIM1.115 U35.AY55
M_A_BG#1: JDIM1.113 U35.AY54
M_A_CAS#: JDIM1.156 U35.AU48
M_A_CB0: JDIM1.92 R10896.2
M_A_CB1: JDIM1.91 R10871.2
M_A_CB2: JDIM1.101 R10875.2
M_A_CB3: JDIM1.105 R10881.2
M_A_CB4: JDIM1.88 R10879.2
M_A_CB5: JDIM1.87 R10884.2
M_A_CB6: JDIM1.100 R10888.2
M_A_CB7: JDIM1.104 R10892.2
M_A_CKE0: JDIM1.109 U35.BA56
M_A_CKE1: JDIM1.110 U35.BB56
M_A_CLK0: JDIM1.137 U35.AT53
M_A_CLK0#: JDIM1.139 U35.AU53
M_A_CLK1: JDIM1.138 U35.AT55
M_A_CLK1#: JDIM1.140 U35.AU55
M_A_CS#0: JDIM1.149 U35.AU45
M_A_CS#1: JDIM1.157 U35.AU43
M_A_DQ0: JDIM1.8 U35.AL71
M_A_DQ1: JDIM1.3 U35.AL68
M_A_DQ2: JDIM1.20 U35.AN68
M_A_DQ3: JDIM1.17 U35.AN69
M_A_DQ4: JDIM1.7 U35.AL70
M_A_DQ5: JDIM1.4 U35.AL69
M_A_DQ6: JDIM1.21 U35.AN70
M_A_DQ7: JDIM1.16 U35.AN71
M_A_DQ8: JDIM1.29 U35.AR70
M_A_DQ9: JDIM1.24 U35.AR68
M_A_DQ10: JDIM1.37 U35.AU71
M_A_DQ11: JDIM1.38 U35.AU68
M_A_DQ12: JDIM1.25 U35.AR71
M_A_DQ13: JDIM1.28 U35.AR69
M_A_DQ14: JDIM1.41 U35.AU70
M_A_DQ15: JDIM1.42 U35.AU69
M_A_DQ16: JDIM1.46 U35.BB65
M_A_DQ17: JDIM1.50 U35.AW65
M_A_DQ18: JDIM1.62 U35.AW63
M_A_DQ19: JDIM1.59 U35.AY63
M_A_DQ20: JDIM1.45 U35.BA65
M_A_DQ21: JDIM1.49 U35.AY65
M_A_DQ22: JDIM1.63 U35.BA63
M_A_DQ23: JDIM1.58 U35.BB63
M_A_DQ24: JDIM1.67 U35.BA61
M_A_DQ25: JDIM1.70 U35.AW61
M_A_DQ26: JDIM1.84 U35.BB59
M_A_DQ27: JDIM1.80 U35.AW59
M_A_DQ28: JDIM1.66 U35.BB61
M_A_DQ29: JDIM1.71 U35.AY61
M_A_DQ30: JDIM1.83 U35.BA59
M_A_DQ31: JDIM1.79 U35.AY59
M_A_DQ32: JDIM1.170 U35.AY39
M_A_DQ33: JDIM1.173 U35.AW39
M_A_DQ34: JDIM1.183 U35.AY37
M_A_DQ35: JDIM1.187 U35.AW37
M_A_DQ36: JDIM1.169 U35.BB39
M_A_DQ37: JDIM1.174 U35.BA39
M_A_DQ38: JDIM1.182 U35.BA37
M_A_DQ39: JDIM1.186 U35.BB37
M_A_DQ40: JDIM1.194 U35.AY35
M_A_DQ41: JDIM1.195 U35.AW35
M_A_DQ42: JDIM1.207 U35.AY33
M_A_DQ43: JDIM1.203 U35.AW33
M_A_DQ44: JDIM1.190 U35.BB35
M_A_DQ45: JDIM1.191 U35.BA35
M_A_DQ46: JDIM1.208 U35.BA33
M_A_DQ47: JDIM1.204 U35.BB33
M_A_DQ48: JDIM1.211 U35.AY31
M_A_DQ49: JDIM1.215 U35.AW31
M_A_DQ50: JDIM1.225 U35.AY29
M_A_DQ51: JDIM1.228 U35.AW29
M_A_DQ52: JDIM1.212 U35.BB31
M_A_DQ53: JDIM1.216 U35.BA31
M_A_DQ54: JDIM1.224 U35.BA29
M_A_DQ55: JDIM1.229 U35.BB29
M_A_DQ56: JDIM1.245 U35.AY27
M_A_DQ57: JDIM1.246 U35.AW27
M_A_DQ58: JDIM1.232 U35.AY25
M_A_DQ59: JDIM1.236 U35.AW25
M_A_DQ60: JDIM1.249 U35.BB27
M_A_DQ61: JDIM1.250 U35.BA27
M_A_DQ62: JDIM1.237 U35.BA25
M_A_DQ63: JDIM1.233 U35.BB25
M_A_DQS0: JDIM1.13 U35.AM69
M_A_DQS1: JDIM1.34 U35.AT70
M_A_DQS2: JDIM1.55 U35.AY64
M_A_DQS3: JDIM1.76 U35.BA60
M_A_DQS4: JDIM1.179 U35.AY38
M_A_DQS5: JDIM1.200 U35.BA34
M_A_DQS6: JDIM1.221 U35.AY30
M_A_DQS7: JDIM1.242 U35.BA26
M_A_DQS8: JDIM1.97 R10891.2
M_A_DQS#0: JDIM1.11 U35.AM70
M_A_DQS#1: JDIM1.32 U35.AT69
M_A_DQS#2: JDIM1.53 U35.BA64
M_A_DQS#3: JDIM1.74 U35.AY60
M_A_DQS#4: JDIM1.177 U35.BA38
M_A_DQS#5: JDIM1.198 U35.AY34
M_A_DQS#6: JDIM1.219 U35.BA30
M_A_DQS#7: JDIM1.240 U35.AY26
M_A_DQS#8: JDIM1.95 R10894.2
M_A_EVENT#: JDIM1.134 R10885.2 R10890.1
M_A_ODT0_DIMM: JDIM1.155 U35.AT45
M_A_ODT1_DIMM: JDIM1.161 U35.AT43
M_A_PARITY: JDIM1.143 U35.AT52
M_A_RAS#: JDIM1.152 U35.AU50
M_A_WE#: JDIM1.151 U35.AT46
M_B_A0: JDIM2.144 U35.BA46
M_B_A1: JDIM2.133 U35.AY46
M_B_A2: JDIM2.132 U35.AY47
M_B_A3: JDIM2.131 U35.BB46
M_B_A4: JDIM2.128 U35.BA47
M_B_A5: JDIM2.126 U35.AY48
M_B_A6: JDIM2.127 U35.BA48
M_B_A7: JDIM2.122 U35.AP48
M_B_A8: JDIM2.125 U35.BB48
M_B_A9: JDIM2.121 U35.AP50
M_B_A10: JDIM2.146 U35.AW46
M_B_A11: JDIM2.120 U35.AN48
M_B_A12: JDIM2.119 U35.AN50
M_B_A13: JDIM2.158 U35.BA43
M_B_ACT#: JDIM2.114 U35.AN53
M_B_ALERT#: JDIM2.116 R11044.1 U35.AN43
M_B_BA#0: JDIM2.150 U35.BB44
M_B_BA#1: JDIM2.145 U35.BA44
M_B_BG#0: JDIM2.115 U35.AP52
M_B_BG#1: JDIM2.113 U35.AN52
M_B_CAS#: JDIM2.156 U35.AY43
M_B_CB0: JDIM2.92 R10931.2
