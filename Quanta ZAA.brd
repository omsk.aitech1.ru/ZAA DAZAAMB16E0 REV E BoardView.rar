# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CHA_SA1: length 7.9
  BOTTOM w0.127: JDIM1.260 149.47,41.32 148.76,40.61 146.97,40.61 146.54,40.18 146.54,39.98 146.55,39.98 146.55,39.22 R10880.2 R10886.1
CHA_SA2: length 7.2
  TOP w0.127: R10889.2 R10877.1 126.82,47.53 v1(125.39,46.09)
  BOTTOM w0.127: v1(125.39,46.09) 125.97,45.51 JDIM1.166
CHB_SA0: length 8.6
  TOP w0.127: R10924.2 R10943.1 147.83,58.72 148.14,59.02 149.56,59.02 150.48,58.11 v1(150.48,57.88)
  BOTTOM w0.127: JDIM2.256 148.47,56.41 148.66,56.59 149.59,56.59 150.48,57.47 v1(150.48,57.88)
CHB_SA1: length 5
  TOP w0.127: v1(149.8,54.07) 149.8,54.24 149.27,54.78 148.24,54.78 148.06,54.96 R10937.1 149.03,55.31 R10940.2
  BOTTOM w0.127: JDIM2.260 149.47,54.4 v1(149.8,54.07)
CHB_SA2: length 10.2
  TOP w0.127: v1(125.39,57.53) 124.14,58.79 124.14,62.25 124.65,62.77 R10927.1 R10923.2
  BOTTOM w0.127: JDIM2.166 125.97,56.95 v1(125.39,57.53)
CIIC_SCL: length 2.1
  TOP w0.127: U13.30 24.28,64.58 R11189.1
CIIC_SDA: length 2.1
  TOP w0.127: U13.29 23.88,64.62 R11190.1
CLK_PCI_EC: length 115.8
  IN2 w0.14: v1(159.72,28.7) 160.15,28.26 163.4,28.26 163.41,28.26 166.75,28.26 167.77,29.28 168.38,29.28 169.64,30.54 169.96,30.54 170.43,30.54 172.4,32.51 172.4,32.91 173.42,33.93 180.12,33.93 180.7,34.51 183.67,34.51 183.85,34.34 183.86,34.35 185.72,34.35 187.92,36.55 v1(188.42,36.55) ; v1(151.78,44.06) 151.78,44.17 156.59,48.98 156.59,52.71 156.18,53.13 156.18,54.29 156.67,54.78 156.67,56.79 156.18,57.28 156.18,58.58 156.59,59 156.59,65.34 156.39,65.53 156.39,74.26 155.84,74.82 155.84,83.71 155.58,83.97 155.58,87.47 155.83,87.72 155.83,89.27 156.36,89.79 156.36,95.89 155.4,96.85 154.51,96.85 153.47,97.89 v1(153.19,97.89)
  BOTTOM w0.14: v1(153.19,97.89) 153.09,97.89 152.81,98.17 R623.1 ; v1(151.78,44.06) 151.78,40.55 154.95,37.38 154.95,32.13 155.96,31.11 155.96,29.18 156.5,28.65 v1(156.56,28.65) 159.67,28.65 v1(159.72,28.7) ; R373.2 189.13,36.98 188.7,36.55 v1(188.42,36.55) 188.37,36.6 U45.13
CLK_PCI_LPC: length 138.5
  IN2 w0.14: v1(200.59,173.5) 196.63,177.46 193.75,177.46 190.8,174.52 190.8,173.79 189.92,172.92 186.62,172.92 186.47,172.77 181.64,172.77 180.63,171.75 162.87,171.75 161.88,170.76 161.88,167.67 160.41,166.2 160.41,165.25 158.06,162.9 158.06,158.23 155.39,155.56 155.39,148.17 156.9,146.65 156.9,141.8 157.82,140.89 157.82,138.81 157,137.99 151.16,137.99 v1(151.09,137.92)
  BOTTOM w0.14: R694.2 201.44,173.04 200.97,173.5 v1(200.59,173.5) ; v1(151.09,137.92) 151.09,137.39 150.94,137.24 v1(150.94,134.8) 151.59,134.15 155.1,130.64 155.1,124.94 160.46,119.58 160.46,110.23 159.81,109.58 159.81,104.89 158.65,103.74 158.65,102.1 156.75,100.2 155.33,100.2 153.7,98.57 153.7,96.4 153.44,96.14 C4723.1 152.97,96.24 R627.1
CLK_PCI_LPC_C: length 11.9
  BOTTOM w0.14: CN10.71 192.1,174.5 192.92,173.68 193.86,173.68 194.47,173.07 194.47,172.36 195.41,171.42 196.98,171.42 198.38,172.82 v1(199.55,172.82) R694.1
CLK_PCIE_LAN_REQ#: length 177.6
  TOP w0.114: v1(154.74,91.43) 154.64,91.43 153.99,90.78 R229.1 ; R276.2 33.2,62.66 32.31,61.77 Q25.3 32.32,61.24 R281.2 36.33,60.79 36.33,60.12 34.93,58.72 v1(34.63,58.72) v1(33.81,58.72)
  IN2 w0.114: v1(33.81,58.72) 37.51,58.72 39.06,60.27 41.13,60.27 42.77,61.9 46.89,61.9 48.29,63.3 48.29,64.6 50.88,67.2 50.88,68.63 52.71,70.45 55.25,70.45 56.2,71.41 66.66,71.41 68.37,73.11 75.83,73.11 v1(77.58,71.37) ; v1(154.74,91.43) 153.73,90.42 153.73,77.09 154.5,76.31 v1(154.5,66.52)
  BOTTOM w0.114: v1(154.5,66.52) 154.5,66.07 152.74,64.31 151.14,64.31 149.23,66.21 146.92,66.21 143.44,69.69 117.73,69.69 116.05,68 114.9,68 106.03,76.88 81.54,76.88 77.58,72.92 v1(77.58,71.37)
CLK_PCIE_LANN: length 144.6
  TOP w0.114: U15.24 34.21,70.46 34.14,70.53 34.07,70.53 33.98,70.44 33.98,69.3 32.38,67.7 32.38,67.04 32,66.66 30.85,66.66 v1(30.56,66.37)
  IN2 w0.114: v1(30.56,66.37) 30.85,66.66 31.72,66.66 31.87,66.81 34.87,66.81 35.71,67.65 37.43,67.65 38.58,68.8 40.28,68.8 41.54,70.05 41.54,72.6 41.64,72.7 41.64,73.32 41.88,73.57 41.88,77.93 42.96,79.01 42.96,103.7 52.47,113.21 65.18,113.21 66.35,114.38 73.7,114.38 76,116.68 85.75,126.43 86.69,126.43 88.12,127.86 91.98,127.86 92.77,128.65 94.09,128.65 94.7,128.04 98.63,128.04 99.24,128.65 101.3,128.65 102.29,127.65 105.59,127.65 105.77,127.48 110.24,127.48 110.58,127.82 115.18,127.82 116.15,126.85 116.71,126.85 117.32,126.24 117.32,125.58 117.62,125.28 117.95,125.28 v1(118.17,125.06)
  BOTTOM w0.114: U35.B40 117.18,123.35 117.18,124 117.3,124.12 117.51,124.12 118.17,124.78 v1(118.17,125.06)
CLK_PCIE_LANP: length 144.6
  TOP w0.114: U15.23 34.25,70.86 34.13,70.75 33.98,70.75 33.76,70.53 33.76,69.39 32.16,67.79 32.16,67.13 31.91,66.87 30.85,66.87 v1(30.58,67.14)
  IN2 w0.114: v1(30.58,67.14) 30.85,66.87 31.63,66.87 31.78,67.03 34.78,67.03 35.62,67.86 37.34,67.86 38.49,69.01 40.19,69.01 41.32,70.14 41.32,72.69 41.42,72.79 41.42,73.41 41.66,73.66 41.66,78.02 42.74,79.1 42.74,103.79 52.38,113.43 65.09,113.43 66.26,114.6 73.61,114.6 74.73,115.72 75.85,116.84 85.66,126.65 86.6,126.65 88.03,128.07 91.89,128.07 92.68,128.86 94.18,128.86 94.79,128.25 98.54,128.25 99.15,128.86 101.39,128.86 102.38,127.87 105.68,127.87 105.86,127.69 110.15,127.69 110.5,128.04 115.27,128.04 116.24,127.07 116.8,127.07 117.53,126.33 117.53,125.67 117.71,125.5 117.94,125.5 v1(118.17,125.72)
  BOTTOM w0.114: v1(118.17,125.72) 118.62,125.27 118.62,124.87 U35.A40
CLK_PCIE_REQ0#: length 30.9
  TOP w0.114: R235.2 R234.1 152.08,89.15 151.91,88.97 v1(150.55,88.97) 150.34,88.97 150.06,89.25 149,89.25 148.61,88.86 144.91,88.86 144.25,89.51 143.86,89.51 141.51,91.85 139.88,91.85 138.11,93.63 138.11,100.3 136.29,102.11 136.29,104.68 v2(135.87,105.1)
  BOTTOM w0.127: U35.AR10 135.47,105.5 v2(135.87,105.1)
CLK_PCIE_REQ1#: length 22.5
  TOP w0.127: v2(136.78,105.18) 138.03,103.93 138.03,103.78 138.46,103.35 139.15,103.35 139.35,103.14 139.35,102.18 142.07,99.46 148.52,99.46 152.08,95.9 v1(152.36,95.9) R215.1 R11111.2
  BOTTOM w0.127: U35.AT7 v2(136.78,105.18)
CLK_PCIE_REQ2#: length 28.6
  TOP w0.114: R227.1 v1(152.48,91.84) 152.43,91.89 150.22,91.89 148.27,89.94 145.01,89.94 144.6,90.35 144.21,90.35 141.86,92.69 140.56,92.69 139.12,94.13 139.12,100.58 138.02,101.68 138.02,103.23 136.78,104.46 v1(136.78,104.53)
  BOTTOM w0.127: U35.AT8 v1(136.78,104.53)
CLK_PCIE_REQ3#: length 20.3
  IN1 w0.14: v1(143.16,101.24) 142.53,100.6 138.64,100.6 135.97,103.27 135.97,104.39 v2(135.88,104.48)
  BOTTOM w0.127: v2(135.88,104.48) 135.51,104.85 U35.AT10 ; v1(143.16,101.24) 143.16,101.34 143.74,101.92 144.92,101.92 145.85,100.98 TP22.1 146.49,100.98 146.87,101.37 147.76,101.37 148.01,101.11 150.55,101.11 151.31,100.35 R618.1
CLK_PCIE_REQ4#: length 29.1
  TOP w0.114: R229.2 R228.1 151.36,91.42 v1(151.26,91.42) 150.39,91.42 148.27,89.31 145.05,89.31 144.43,89.93 144.03,89.93 141.69,92.27 140.09,92.27 138.61,93.75 138.61,100.43 136.96,102.08 136.96,103.7 v2(136.78,103.88)
  BOTTOM w0.127: U35.AU8 v2(136.78,103.88)
CLK_PCIE_REQ5#: length 21.8
  TOP w0.114: R224.2 R223.1 152.83,94.25 152.71,94.25 v1(152.38,94.58) 148.01,98.95 141.87,98.95 138.69,102.13 v2(138.69,102.91)
  BOTTOM w0.089: U35.AU7 137.93,103.51 137.93,103.41 138.43,102.91 v2(138.69,102.91)
CLK_PCIE_VGA: length 81.7
  IN2 w0.114: v1(121.19,125.39) 121.19,125.67 121.29,125.78 122.05,125.78 122.68,126.4 122.68,127.13 125.53,129.99 129.46,129.99 131.6,132.13 139.31,132.13 140.53,133.34 151.34,133.34 151.63,133.64 160.22,133.64 161.26,134.68 173.93,134.68 174.34,134.27 174.34,129.67 173.51,128.85 172.19,128.85 171.6,128.26 v1(171.32,128.26)
  BOTTOM w0.076: 115.93,126.82 116.44,126.31 116.44,125.7 116.24,125.5 116.24,124.21 116.06,124.03 116.06,123.62 116.1,123.53 116.1,123.25 116.06,123.17 116.06,122.98 116.15,122.76 116.15,122.45 116.19,122.41 U35.C42
  BOTTOM w0.114: v1(171.32,128.26) 171.32,128.82 171.21,128.92 171.03,128.92 170.93,128.82 U3002.AL13 ; v1(121.19,125.39) 121.19,125.65 121.01,125.83 120.27,125.83 119.51,126.58 119.51,128.11 118.75,128.87 116.35,128.87 115.93,128.46 115.93,126.82
CLK_PCIE_VGA#: length 81.7
  IN2 w0.114: v1(121.19,126.21) 121.35,126.04 122.02,126.04 122.46,126.49 122.46,127.22 125.44,130.21 129.37,130.21 131.51,132.34 139.22,132.34 140.44,133.56 151.25,133.56 151.54,133.85 160.13,133.85 161.17,134.89 174.02,134.89 174.55,134.36 174.55,129.58 173.6,128.63 172.28,128.63 172.09,128.44 172.09,128.39 v1(172.21,128.27)
  BOTTOM w0.076: U35.D42 115.99,122.12 115.99,122.73 115.9,122.95 115.9,123.2 115.93,123.28 115.93,123.49 115.9,123.56 115.89,123.57 115.89,124.1 116.07,124.28 116.07,125.56 116.27,125.77 116.27,126.24 115.88,126.63 115.86,126.63 115.75,126.74 115.75,126.77 115.73,126.79
  BOTTOM w0.114: v1(121.19,126.21) 121.01,126.03 120.35,126.03 119.72,126.66 119.72,128.2 118.84,129.08 116.26,129.08 115.73,128.54 115.73,126.79 ; U3002.AK13 171.87,128.69 172.21,128.35 v1(172.21,128.27)
CLK_PCIE_WLANN: length 135.9
  IN2 w0.114: v2(117.57,121.26) 118.43,120.4 119.58,120.4 119.96,120.02 120.67,120.02 121.3,120.66 121.3,122.64 120.12,123.82 120.12,126.79 124.85,131.52 127.03,131.52 128.61,133.09 129.37,133.09 130.51,134.23 138.44,134.23 139.68,135.48 150.3,135.48 150.73,135.91 152.71,135.91 153.33,136.53 157.32,136.53 158.67,137.88 158.67,142.15 158.16,142.65 158.16,146.64 156.24,148.56 156.24,155.21 158.91,157.88 158.91,162.5 161.3,164.89 161.3,165.88 162.74,167.33 162.74,170.28 163.37,170.9 189.88,170.9 191.65,172.66 191.65,174.16 193.05,175.56 194.82,175.56 195.31,176.04 195.31,176.6 v1(195.53,176.83)
  BOTTOM w0.114: CN10.49 191.92,180 192.07,180.14 192.35,180.14 192.89,179.6 192.89,176.78 193.5,176.17 195.03,176.17 195.53,176.68 v1(195.53,176.83) ; U35.E40 117.76,121.26 v2(117.57,121.26)
CLK_PCIE_WLANP: length 135.9
  IN2 w0.114: v2(118.46,121.32) 118.46,121.44 118.34,121.56 118.09,121.56 118.01,121.48 118.01,121.09 118.49,120.62 119.67,120.62 120.05,120.24 120.58,120.24 121.09,120.75 121.09,122.55 119.91,123.73 119.91,126.88 124.76,131.73 126.94,131.73 128.52,133.31 129.28,133.31 130.42,134.45 138.35,134.45 139.59,135.69 150.21,135.69 150.64,136.13 152.62,136.13 153.24,136.75 157.23,136.75 158.45,137.97 158.45,142.06 157.94,142.56 157.94,146.55 156.19,148.3 156.03,148.47 156.03,155.3 158.69,157.97 158.69,162.59 161.08,164.98 161.08,165.97 162.53,167.42 162.53,170.36 163.28,171.11 189.79,171.11 191.43,172.75 191.43,174.25 192.96,175.78 194.74,175.78 195.08,176.12 195.08,176.59 v1(194.84,176.83)
  BOTTOM w0.114: v1(194.84,176.83) 195.03,176.64 195.03,176.47 194.94,176.38 193.59,176.38 193.11,176.87 193.11,179.69 192.44,180.36 192.06,180.36 191.92,180.5 CN10.47 ; v2(118.46,121.32) 118.46,121.01 118.6,120.87 118.83,120.87 U35.E38
CLK_PCIE_XDPN: length 1.5
  TOP w0.127: TP93.1 116.13,119.55 v1(115.74,119.94)
  BOTTOM w0.127: v1(115.74,119.94) 115.79,119.94 116.19,120.34 U35.F43
CLK_PCIE_XDPP: length 1.7
  TOP w0.127: TP94.1 115.81,120.67 v1(115.74,120.6)
  BOTTOM w0.127: U35.E43 115.82,120.6 v1(115.74,120.6)
CLK_PEGA_REQ#: length 53.4
  TOP w0.114: R235.1 153.99,89.64 v1(154.84,90.49)
  BOTTOM w0.102: 174.68,104.62 174.7,104.62
  BOTTOM w0.114: v1(154.84,90.49) 155.61,90.49 v1(155.85,90.74) 155.89,90.77 155.89,96.69 158.91,99.71 175.82,99.71 176.64,100.53 176.64,104.11 176.47,104.27 176.13,104.27 175.42,104.98 175.06,104.98 174.7,104.62 ; Q4002.3 169.81,112.47 168,110.66 168,107.16 168.59,106.57 168.59,104.64 168.81,104.41 170.52,104.41 170.72,104.62 174.68,104.62
CLK_SCLK: length 418.8
  TOP w0.127: v1(175.91,61.54) 176.5,62.12 181.27,62.12 183.8,59.6 183.8,56.28 186.82,53.26 191.17,53.26 195.26,49.17 195.26,49.15 197.12,47.29 199.56,47.29 200.35,48.08 206.85,48.08 206.93,48 209.84,48 214.74,52.9 214.74,58.15 216.04,59.46 218.52,59.46 219.42,60.36 224.96,60.36 225.06,60.46 225.71,60.46 v1(226.05,60.79) ; R11189.2 24.24,63.51 24.1,63.37 24.1,61.12 25.86,59.35 26.66,59.35 27.13,58.89 27.13,58.18 31.02,54.29 31.02,45.86 35.46,41.41 35.46,31.03 37.27,29.23 43.81,29.23 47.22,25.82 47.22,24.8 48.93,23.1 48.93,18.1 47.63,16.81 47.63,14.97 v1(47.92,14.68) ; v1(158.55,118.64) 158.93,118.26 v1(158.93,118.08) 158.93,116.38 158.77,116.22 R572.1 157.19,116.22 157.03,116.38 157.03,117.42 156.97,117.48 Q32.1
  IN2 w0.14: v1(148.34,46.25) 148.37,46.22 148.64,46.22 148.99,45.88 149.19,45.88 149.42,46.11 149.42,46.31 149.1,46.63 149.1,47.98 147.61,49.47 147.61,56.59 v1(149.49,58.47) ; v1(47.92,14.68) 48.2,14.4 52.5,14.4 52.84,14.74 54.63,14.74 55.96,13.41 58.06,13.41 60.15,15.49 65.52,15.49 68.08,18.04 68.08,19.16 72.23,23.31 75.96,23.31 77.4,24.75 80.46,24.75 87.97,32.25 106.75,32.25 110.85,28.15 114.05,28.15 114.63,27.57 151.87,27.57 154.36,30.06 154.36,30.3 155.07,31.01 v1(155.15,31.01) 155.37,30.79 155.54,30.79 157.96,33.2 163.94,33.2 164.79,34.06 166.64,34.06 167.43,34.84 167.87,34.84 170.22,37.19 170.77,37.19 171.71,38.14 171.71,39.68 172.59,40.56 172.59,41.95 174.54,43.89 174.54,44.58 175.53,45.58 175.53,49.36 176.02,49.84 176.02,52.06 177.09,53.13 177.09,54.56 177.47,54.94 177.47,56.73 176.49,57.72 176.49,59.38 176.1,59.76 176.1,61.35 v1(175.91,61.54) 176.1,61.73 176.1,62.25 175.55,62.81 175.42,62.81 172.36,65.87 172.36,66.55 169.53,69.37 169.53,74.17 169.35,74.36 169.35,78.6 169.86,79.11 169.86,82.49 170.57,83.21 170.57,85.02 170.67,85.12 170.67,86.77 170.57,86.86 170.57,88.95 171.75,90.13 171.75,97.54 171.11,98.17 171.11,107.16 169.46,108.82 168.49,109.79 167.92,109.79 164.04,113.66 164.04,114.03 163.34,114.73 163.33,114.74 162.96,114.74 162.83,114.88 158.95,118.75 158.67,118.75 v1(158.55,118.64)
  BOTTOM w0.127: v1(149.49,58.47) 148.44,59.51 148.44,61.92 147.72,62.64 JDIM2.253 ; v1(226.05,60.79) 225.75,60.5 225.54,60.5 R329.1 ; JDIM1.253 147.72,50.25 148.34,49.63 v1(148.34,46.25) 150.02,46.25 150.48,45.79 150.48,40.83 154.18,37.12 154.18,31.1 154.48,30.8 154.95,30.8 v1(155.15,31.01)
CLK_SDATA: length 417.5
  TOP w0.127: R11190.2 23.82,63.24 23.82,61 25.75,59.07 26.55,59.07 26.85,58.77 26.85,58.06 30.74,54.17 30.74,45.74 35.19,41.29 35.19,30.92 37.15,28.95 43.69,28.95 46.95,25.7 46.95,24.68 48.65,22.98 48.65,18.22 47.35,16.93 47.35,14.97 v1(47.06,14.68) ; v1(226.04,59.48) 226.04,60.07 225.94,60.18 225.18,60.18 225.08,60.08 219.54,60.08 218.64,59.18 216.16,59.18 215.02,58.03 215.02,52.79 209.95,47.72 208.37,47.72 207.41,46.77 205.52,46.77 204.49,47.8 200.46,47.8 199.68,47.01 197.26,47.01 197.24,46.98 197.01,46.98 194.98,49.02 194.98,49.04 191.03,52.98 186.7,52.98 183.52,56.15 183.5,56.15 183.5,56.51 183.52,56.53 183.52,59.48 181.16,61.84 176.92,61.84 v1(176.61,61.54) ; Q32.4 155.01,118.78 155.48,119.25 157.83,119.25 R576.1 158.41,119.15 v1(158.55,119.3)
  IN2 w0.14: v1(158.55,119.3) 158.81,119.04 159.07,119.04 159.16,118.96 162.95,115.17 163.09,115.03 163.46,115.03 163.55,114.94 164.33,114.15 164.33,113.79 168.04,110.08 168.61,110.08 169.66,109.02 171.41,107.28 171.41,98.29 172.04,97.66 172.04,90.01 170.87,88.83 170.87,86.98 170.96,86.89 170.96,85 170.87,84.9 170.87,83.09 170.15,82.37 170.15,78.98 169.64,78.48 169.64,74.48 169.82,74.29 169.82,69.5 172.65,66.67 172.65,65.99 175.54,63.1 175.67,63.1 175.96,62.81 175.96,62.81 176.4,62.37 176.4,61.75 v1(176.61,61.54) 176.4,61.32 176.4,59.88 176.78,59.5 176.78,57.84 177.77,56.85 177.77,54.82 177.38,54.43 177.38,53.01 176.31,51.94 176.31,49.72 175.82,49.24 175.82,45.46 174.83,44.46 174.83,43.77 172.88,41.83 172.88,40.44 172,39.56 172,38.01 170.89,36.9 170.34,36.9 167.99,34.55 167.55,34.55 166.76,33.76 164.91,33.76 164.06,32.91 158.08,32.91 155.66,30.5 155.35,30.5 v1(155.17,30.32) 155.07,30.42 154.9,30.42 154.65,30.18 154.65,29.94 151.99,27.27 114.51,27.27 113.93,27.86 110.73,27.86 106.62,31.96 88.09,31.96 80.58,24.45 77.52,24.45 76.08,23.02 72.35,23.02 68.37,19.04 68.37,17.92 65.64,15.2 60.27,15.2 58.18,13.11 55.84,13.11 54.51,14.45 52.97,14.45 52.62,14.1 47.63,14.1 v1(47.06,14.68) ; v1(148.64,44.57) 148.64,44.82 149.13,45.31 149.13,45.41 149.71,45.99 149.71,46.43 149.4,46.75 149.4,48.1 147.9,49.59 147.9,56.46 148.53,57.09 v1(149.49,57.09)
  BOTTOM w0.127: v1(149.49,57.09) 149.49,57.26 149.36,57.39 148.1,57.39 147.97,57.26 JDIM2.254 ; R336.1 225.44,60.22 225.91,60.22 226.04,60.09 v1(226.04,59.48) ; v1(155.17,30.32) 154.97,30.53 154.36,30.53 153.9,30.98 153.9,37 150.2,40.71 150.2,45.67 150.08,45.79 149.93,45.79 149.82,45.67 149.82,44.42 149.71,44.32 149.54,44.32 149.43,44.42 149.43,45.87 149.33,45.97 149.16,45.97 149.06,45.87 149.06,44.67 148.96,44.57 v1(148.64,44.57) 148.42,44.57 147.97,44.13 JDIM1.254
CLKRUN#: length 119.6
  IN1 w0.102: 165.82,78.2 v1(165.72,78.3)
  IN1 w0.14: 165.82,78.2 165.99,78.03 165.99,72.66 166.07,72.57 166.07,71.5 166.4,71.17 166.4,70.51 167.03,69.88 167.03,68.58 172.29,63.32 172.29,60.28 172.66,59.91 172.66,55.07 174.34,53.39 174.34,48.2 175.56,46.98 175.56,45.45 175.13,45.02 175.13,44.35 175.7,43.78 177.02,43.78 178.16,42.63 178.16,41.07 177.47,40.39 177.46,40.39 177.11,40.04 177.11,38.92 177.1,38.92 177.1,38.91 v1(177.11,38.91) ; v1(162.08,90.27) 162.57,89.78 162.57,83.81 164.41,81.97 164.41,80.88 165.72,79.57 v1(165.72,78.3)
  BOTTOM w0.079: 134.56,100.22 134.26,100.51 134.26,101.31 134.36,101.41 134.36,102.54 134.64,102.82 U35.AW11
  BOTTOM w0.127: U45.93 172.37,40.2 172.84,39.73 173.52,39.73 173.78,39.47 173.78,39.12 174.22,38.68 176.33,38.68 176.56,38.91 v1(177.11,38.91) ; 134.56,100.22 136.08,98.7 138.74,98.7 139.25,98.19 141.65,98.19 R630.2 142.16,97.93 142.42,98.19 144.96,98.19 145.22,98.44 148.01,98.44 150.55,95.9 150.55,91.71 149.74,90.9 149.74,89.22 151.18,87.78 153.22,87.78 153.42,87.57 155.66,87.57 155.84,87.76 156.89,87.76 159.4,90.27 v1(162.08,90.27) ; C807.2 162.07,71.22 162.03,71.26 R743.2 161.86,71.69 161.59,71.97 161.59,76.18 163.71,78.3 v1(164.07,78.3) v1(165.72,78.3)
CLR_CMOS: length 67.6
  TOP w0.127: Q6060.2 145.04,73.6 145.29,73.86 147.81,73.86 147.96,73.71 147.96,72.94 148.14,72.77 Q6059.2 149.64,73.6 151.77,73.6 152.14,73.23 R786.1 152.74,72.75 152.74,72.51 v1(153.12,72.13) 153.8,71.44 155.73,71.44 v1(155.89,71.29)
  IN1 w0.14: v1(155.66,43.73) 155.66,43.96 158.73,47.04 158.73,51.84 158.25,52.31 158.25,54.11 158.13,54.23 158.13,58.5 157.66,58.97 157.66,69.45 156.57,70.54 156.57,70.91 156.19,71.29 v1(155.89,71.29)
  BOTTOM w0.127: v1(155.66,43.73) 155.66,39.03 157.96,36.74 160.01,36.74 161.03,35.72 163.44,35.72 165.56,33.6 167.34,33.6 167.82,34.08 170.03,34.08 170.55,34.6 U45.79
CODEC_VREF: length 2
  BOTTOM w0.127: U23.28 205.4,27.55 C535.2
CPU_DRAMRST#: length 6.4
  TOP w0.076: v2(133.1,105.19) 132.75,104.84 131.86,104.84 131.72,104.69
  TOP w0.127: R670.2 R679.2 131.28,102.21 131.72,102.65 131.72,104.69
  BOTTOM w0.127: v2(133.1,105.19) 133.58,104.85 U35.AT13
CPU_THRMTRIP#: length 12.9
  BOTTOM w0.076: U35.C63 105.21,122.54 105.21,122.67 105.36,123 105.36,123.08 105.3,123.31 105.3,123.5 105.36,123.67 105.36,124.21 104.96,124.61
  BOTTOM w0.089: 104.96,124.61 104.96,125.01
  BOTTOM w0.127: 104.96,125.01 103.08,126.89 102.04,126.89 101.56,127.38 101.56,128.01 101.28,128.29 100.64,128.29 v1(100.26,128.67) R530.2 99.75,129.93 99.46,129.93 99.13,130.26 99.13,131.34 R529.2
CRT_11: length 3.1
  TOP w0.127: TP75.1 8.01,73.68 CN7.11
CRT_AUXN: length 117.1
  TOP w0.114: C343.1 28.39,66.57 28.65,66.31 29.26,66.31 29.37,66.42 29.37,66.56 v1(29.08,66.85)
  IN2 w0.114: v1(98.1,131.85) 97.85,132.1 97.85,132.32 97.21,132.96 92.4,132.96 90.34,130.89 85.84,130.89 72.92,117.97 59.53,117.97 58.87,117.3 51.32,117.3 39.87,105.85 39.87,83.45 38.87,82.44 38.87,81.88 38.25,81.26 38.25,79.31 37.81,78.87 37.81,76 36.93,75.12 36.93,74.75 35.34,73.16 35.34,72.69 34.35,71.7 32.34,71.7 29.24,68.6 29.24,67.01 v1(29.08,66.85)
  BOTTOM w0.114: R10847.2 98.25,131.69 v1(98.1,131.85)
CRT_AUXP: length 117.1
  TOP w0.114: C341.1 28.39,65.98 28.49,66.09 29.35,66.09 29.58,66.33 29.58,66.56 v1(29.87,66.85)
  IN2 w0.114: v1(97.44,131.85) 97.63,132.04 97.63,132.23 97.12,132.74 92.49,132.74 90.43,130.68 85.93,130.68 73.01,117.75 59.62,117.75 58.96,117.09 51.41,117.09 40.09,105.76 40.09,83.36 39.08,82.35 39.08,81.79 38.46,81.17 38.46,79.22 38.03,78.79 38.03,75.91 37.14,75.03 37.14,74.66 35.55,73.07 35.55,72.6 34.44,71.48 32.43,71.48 29.46,68.51 29.46,67.26 v1(29.87,66.85)
  BOTTOM w0.114: R10848.2 97.24,131.64 v1(97.44,131.85)
CRT_B1: length 9.4
  TOP w0.127: L5.2 12.78,77.74 12.65,77.61 C319.2 11.86,77.61 11.22,76.97 U38.5 U38.6 9.51,76.97 9.38,77.09 v1(9.38,77.95) 8.11,77.95 7.93,78.12 6.74,78.12 CN7.3
CRT_BLU: length 16.9
  TOP w0.127: L5.1 15.3,77.74 15.43,77.88 C320.2 16.18,77.88 v1(16.77,77.29) 17.53,76.52 17.53,73.6 17.13,73.2 17.13,69.08 17.99,68.22 18.24,68.22 18.62,67.84 19.21,67.84 19.5,67.55 R213.1
  TOP w0.203: R213.1 19.6,67.23 19.92,67.23 20.84,68.15 U13.21
CRT_CLK: length 16.7
  TOP w0.127: v1(150.09,118.13) 150.09,118.18 150.63,118.71 v1(151.24,118.71) 151.51,118.44 151.51,117.93 R577.1
  IN1 w0.127: 137.89,116.49 v2(137.71,116.3)
  IN1 w0.14: v1(150.09,118.13) 149,117.04 142.97,117.04 142.42,116.49 137.89,116.49
  BOTTOM w0.127: v2(137.71,116.3) 137.71,116.61 137.52,116.8 U35.N7
CRT_DATA: length 17.7
  TOP w0.127: R152.1 151.53,119.2 150.17,119.2 v1(149.92,118.94) 149.41,118.43 v1(149.41,118.13)
  IN1 w0.076: v2(136.47,116.24) 136.9,116.67 137.56,116.67 137.6,116.71 139.07,116.71 139.16,116.8
  IN1 w0.14: 139.16,116.8 142.3,116.8 142.82,117.32 148.6,117.32 v1(149.41,118.13)
  BOTTOM w0.127: U35.N8 136.47,116.48 v2(136.47,116.24)
CRT_G1: length 8.3
  TOP w0.127: L6.2 13.42,75.47 C333.2 12.12,75.47 U38.2 U38.9 9.9,75.46 v1(8.62,75.46) 8.16,75.92 6.81,75.92 5.87,76.86 CN7.2
CRT_GRE: length 14.9
  TOP w0.127: L6.1 15.69,75.46 C334.2 15.92,75.21 v1(15.92,74.42) 15.92,69.07 18.17,66.82 18.99,66.82 R219.1
  TOP w0.203: R219.1 19.51,66.34 20.92,67.75 U13.22
CRT_HPD: length 319.5
  TOP w0.127: R10846.2 147.65,118.4 v1(147.38,118.13) ; v1(176.56,44.52) 176.03,43.99 175.45,43.99 173.65,45.79 170.13,45.79 169.75,45.41 v1(169.75,44.23) ; U13.32 v1(25.08,65.2) 25.08,61.06 v1(25,60.98)
  IN1 w0.14: v1(166.78,76.85) 167.04,76.6 167.04,74.77 167.47,74.34 167.47,71.85 168.13,71.19 168.13,69.64 171.96,65.81 171.96,64.99 172.3,64.66 172.3,64.66 173.28,63.67 173.28,60.73 173.62,60.4 173.62,55.57 175.27,53.92 175.27,48.71 177.15,46.83 177.15,45.1 v1(176.56,44.52)
  IN2 w0.14: v1(169.75,44.23) 169.25,44.23 169.04,44.44 163.81,44.44 163.8,44.43 163.44,44.43 158.76,39.75 158.76,39.39 156.76,37.39 156.76,37.01 156.48,36.74 155.5,36.74 149.71,30.96 144.61,30.96 143.36,29.71 117.99,29.71 117.62,30.08 116.8,30.91 114.59,30.91 113.89,31.6 110.85,34.64 86.65,34.64 78.95,26.94 76.38,26.94 74.87,25.43 70.99,25.43 69.14,23.58 67.04,23.58 65.21,21.75 65.21,19.88 64.22,18.89 51.29,18.89 49.59,17.19 48.26,17.19 47.94,16.87 46.46,16.87 45.69,16.11 37.49,16.11 29.24,24.36 29.24,26.03 28.86,26.41 28.86,27.53 26.65,29.74 25.36,29.74 24.35,30.74 24.35,35.56 23.48,36.43 23.48,38.16 20.76,40.89 20.17,40.89 19.34,41.73 19.34,42.56 20.5,43.73 20.5,48.86 19.26,50.11 18.27,50.11 16.82,51.56 16.82,52.85 18.27,54.3 18.27,56.76 19.44,57.93 21.95,57.93 v1(25,60.98) ; v1(166.78,76.85) 166.78,76.88 166.71,76.96 166.71,77.62 166.86,77.77 166.86,79.73 166.76,79.82 166.76,82.19 166.48,82.48 166.48,83.9 167.25,84.68 167.25,85.66 167.56,85.96 167.56,89.03 168.77,90.25 168.77,97.09 168.27,97.59 168.27,105.17 164.65,108.79 164.65,109.88 161.2,113.33 158.54,116 157.63,116 155.99,117.63 147.64,117.63 147.38,117.9 v1(147.38,118.13)
CRT_R1: length 9.7
  TOP w0.127: CN7.1 6.61,75.46 7.58,75.46 8.07,74.97 U38.10 U38.1 11.12,74.97 11.31,74.77 v1(11.31,74.11) 11.31,73.74 C336.2 12.13,72.92 L7.2
CRT_RED: length 13.9
  TOP w0.127: R222.1 18.99,65.73 17.68,65.73 17.43,65.98 17.43,66.52 14.65,69.3 C337.2 14.63,71.72 L7.1
  TOP w0.203: U13.23 20.98,67.35 20.43,66.8 v1(20.43,66.31) 20.43,65.91 19.77,65.25 R222.1
CRT_TXN0: length 136.1
  TOP w0.114: v1(30.59,68.71) 30.3,68.42 29.95,68.42 29.1,69.28 28.49,69.28 28.39,69.38 C331.1
  IN2 w0.114: v1(111.28,129.31) 111.43,129.46 112.12,129.46 112.29,129.29 112.29,128.82 112.22,128.75 110.12,128.75 109.81,128.44 106.26,128.44 106.06,128.63 102.76,128.63 101.7,129.7 98.82,129.7 98.09,128.96 95.58,128.96 94.25,130.29 92.71,130.29 91.2,128.79 87.73,128.79 86.31,127.36 85.28,127.36 78.55,120.63 73.23,115.31 65.97,115.31 64.8,114.14 52.08,114.14 42.02,104.08 42.02,82.27 41.17,81.41 41.17,78.55 40.4,77.78 40.4,76.46 40.95,75.91 40.95,73.95 40.71,73.71 40.71,73.08 40.61,72.98 40.61,70.44 39.9,69.72 38.2,69.72 37.79,69.31 36,69.31 34.42,67.74 32.01,67.74 31.44,68.31 30.81,68.31 30.59,68.53 v1(30.59,68.71)
  BOTTOM w0.114: R10843.2 112.6,128.59 112.6,128.87 112.04,129.43 111.41,129.43 v1(111.28,129.31)
CRT_TXN1: length 129.6
  TOP w0.114: v1(31.93,69.41) 31.69,69.17 31.4,69.17 30.95,69.62 30.95,70.74 30.14,71.55 29.88,71.55 C315.1
  IN2 w0.114: v1(31.93,69.41) 32.26,69.08 32.42,69.08 32.93,68.57 34.35,68.57 35.77,70 36,70 40.26,74.26 40.26,75.71 39.77,76.2 39.77,78.05 40.53,78.81 40.53,81.82 41.29,82.58 41.29,105.26 50.81,114.78 62.46,114.78 63.63,115.94 72.93,115.94 79.49,122.51 83.35,126.37 86.4,129.42 90.88,129.42 92.38,130.92 94.52,130.92 95.84,129.6 97.81,129.6 98.57,130.36 102.18,130.36 103.02,129.52 109.54,129.52 v1(109.78,129.76)
  BOTTOM w0.114: v1(109.78,129.76) 110.03,129.51 110.35,129.51 110.58,129.28 110.58,128.52 R10845.2
CRT_TXP0: length 136.1
  TOP w0.114: v1(30.59,67.92) 30.3,68.21 29.86,68.21 29.01,69.06 28.6,69.06 28.39,68.85 C335.1
  IN2 w0.114: v1(30.59,67.92) 30.76,68.09 31.35,68.09 31.92,67.52 34.51,67.52 36.09,69.1 37.88,69.1 38.29,69.51 39.99,69.51 40.83,70.35 40.83,72.89 40.93,72.99 40.93,73.62 41.17,73.86 41.17,76 40.62,76.55 40.62,77.69 41.38,78.46 41.38,81.33 42.23,82.18 42.23,103.99 52.17,113.93 64.89,113.93 66.06,115.09 73.32,115.09 78.7,120.47 85.37,127.14 86.4,127.14 87.82,128.57 91.29,128.57 92.8,130.07 94.16,130.07 95.49,128.75 98.18,128.75 98.91,129.48 101.61,129.48 102.67,128.42 105.97,128.42 106.17,128.23 109.9,128.23 110.2,128.53 112.31,128.53 112.5,128.73 112.5,129.38 112.21,129.67 111.82,129.67 111.6,129.9 v1(111.6,129.91)
  BOTTOM w0.114: R10842.2 112.81,128.46 112.81,128.95 112.12,129.64 111.87,129.64 v1(111.6,129.91)
CRT_TXP1: length 129.6
  TOP w0.114: v1(31.93,68.7) 31.68,68.96 31.31,68.96 30.73,69.53 30.73,70.65 30.05,71.33 29.74,71.33 29.66,71.25 C329.1
  IN2 w0.114: v1(109.78,129.06) 109.54,129.3 102.93,129.3 102.09,130.14 98.66,130.14 97.9,129.38 95.75,129.38 94.43,130.71 92.47,130.71 90.97,129.2 86.49,129.2 83.51,126.22 79.64,122.35 73.02,115.73 63.72,115.73 62.55,114.56 50.9,114.56 41.51,105.18 41.51,82.49 40.75,81.73 40.75,78.72 39.99,77.96 39.99,76.29 40.48,75.8 40.48,74.17 36.09,69.78 35.86,69.78 34.44,68.36 32.84,68.36 32.33,68.87 32.1,68.87 v1(31.93,68.7)
  BOTTOM w0.114: R10844.2 110.38,128.52 110.38,129.19 110.27,129.31 110.03,129.31 v1(109.78,129.06)
CRTHSYNC: length 12.6
  TOP w0.127: CN7.13 7.13,79.14 8.57,79.14 9.47,80.05 U36.10 U36.1 11.34,80.05 v1(11.74,79.65) 12,79.39 C718.1 13,79.39 R11268.2 13.51,80.97 14.18,80.97 14.81,81.6 14.81,82.54 14.05,83.31 R11269.2
CRTHSYNC_B: length 8.8
  TOP w0.127: v1(15.3,87.07) 15.45,86.92 15.45,81.58 v1(15.2,81.33) 14.59,80.72 14.04,80.72 R11268.1
  BOTTOM w0.127: v1(15.3,87.07) R11267.1
CRTVDD5: length 1.2
  TOP w0.762: 6.93,80.29 CN7.9
  vias: v1(9.1,80.44) v1(10.19,84.3) v1(10.22,83.59) v3(7.55,80.28) v3(8.44,80.28)
CRTVSYNC: length 12.2
  TOP w0.127: CN7.14 7.23,81.55 U36.7 U36.4 v1(12.1,81.55) 12.33,81.55 12.45,81.43 C716.1 R11271.2 13,82.65 12.15,83.51 10.83,83.51 10.42,83.1 9.95,83.1 9.43,83.62 R11272.2
CRTVSYNC_B: length 7.1
  TOP w0.127: v1(13.44,83.1) 13.49,83.1 13.78,82.81 R11271.1
  BOTTOM w0.127: v1(13.44,83.1) 13.47,83.1 13.49,83.13 13.49,84.58 13.11,84.96 11.51,84.96 v1(11.11,85.36) 9.84,86.63 R11270.1
CTL2: length 4.2
  TOP w0.127: U22.7 16.14,26.24 15.89,25.99 v1(15.89,24.92) 15.89,24.09 16.06,23.92 R360.2
CTL3: length 3.7
  TOP w0.127: U22.8 16.3,25.74 16.19,25.62 16.19,25.32 16.57,24.94 v1(16.57,23.79) 16.95,23.41 R356.2
D/C#: length 2.3
  TOP w0.305: PR171.1 150.97,187.9 TP4366.1
  TOP w0.381: PR171.1 151.56,187.32 PC6.2
DC-DET: length 5
  BOTTOM w0.127: R344.1 202.98,39.36 202.98,38.07 203.32,37.73 R350.2 203.51,37.51 203.4,37.4 U23.4
DCPRTC: length 21.7
  BOTTOM w0.127: U35.BB10 135.25,100.78 136.31,99.71 139.25,99.71 139.76,99.21 144.45,99.21 144.71,99.47 148.64,99.47 151.59,96.51 151.59,94.24 C732.1
DDCCLK: length 27
  TOP w0.127: U13.15 22.68,70.94 22.54,71.09 22.54,71.27 21.27,72.54 21.27,73.91 20.1,75.08 19.61,75.08 v1(19.32,75.37) ; CN7.15 v1(8.64,82.21) 8.8,82.05 U36.6 U36.5 10.8,82.06 10.95,82.06 11.18,82.29 v1(11.59,82.29) 11.88,82.58 C714.1
  IN2 w0.14: v1(19.32,75.37) 19.04,75.08 15.93,75.08 14.53,76.47 14.53,78.25 13.25,79.53 12.63,79.53 12.25,79.92 12.25,81.63 v1(11.59,82.29)
  BOTTOM w0.127: v1(11.59,82.29) 11.97,81.91 R601.1
DDCDAT: length 25.8
  TOP w0.127: v1(19.32,74.53) 19.61,74.82 20,74.82 21.01,73.81 21.01,72.44 22.28,71.17 U13.16 ; C724.1 12.05,76.6 v1(11.69,76.25) 11.47,76.47 U38.4 U38.7 8.98,76.47 v1(8.69,76.75) 8.59,76.86 CN7.12
  IN2 w0.14: v1(11.69,76.25) 12.25,76.8 12.25,79.01 12.5,79.27 13.14,79.27 14.27,78.14 14.27,76.36 15.82,74.82 19.04,74.82 v1(19.32,74.53)
  BOTTOM w0.127: v1(11.69,76.25) 12.05,76.6 C724.1
DDI2_AUXN: length 21.8
  IN2 w0.114: v2(113,121.24) 112.84,121.08 112.71,121.08 112.54,121.24 112.54,122.23 111.12,123.65 110.1,123.65 107.05,126.7 105.07,126.7 104.78,126.99 100.9,126.99 100.56,127.33 100.56,127.55 100.67,127.65 100.9,127.65 v1(101.06,127.82)
  BOTTOM w0.114: v2(113,121.24) 113.22,121.24 U35.E48 ; R10847.1 98.1,130.29 98.1,129.8 R533.2 98.46,128.94 99.24,128.16 100.01,128.16 100.35,127.82 v1(101.06,127.82)
DDI2_AUXP: length 21.9
  IN2 w0.114: v2(113,120.58) 112.73,120.85 112.63,120.85 112.61,120.86 112.61,120.86 112.33,121.15 112.33,122.14 111.03,123.44 110.01,123.44 106.96,126.49 104.98,126.49 104.69,126.78 100.81,126.78 100.35,127.24 100.35,127.46 100.17,127.64 v1(99.82,127.64)
  BOTTOM w0.114: R10848.1 97.59,130.08 97.59,129.69 R532.1 97.47,129.43 99.26,127.64 v1(99.82,127.64) ; U35.F48 113.23,120.34 v2(113,120.58)
DDI2_TXN0: length 6
  BOTTOM w0.076: 112.76,124.08 112.78,124.06 112.78,124 112.79,123.99 112.79,123.67 112.73,123.5 112.73,123.31 112.8,123.08 112.8,123 112.72,122.83 112.72,122.62 U35.C50
  BOTTOM w0.114: 112.76,124.08 112.76,126.21 112.66,126.31 112.66,127.55 112.6,127.6 112.25,127.6 112.2,127.55 R10843.1
DDI2_TXN1: length 6.1
  BOTTOM w0.076: U35.C52 111.2,122.6 111.2,122.76 111.1,122.98 111.1,123.17 111.14,123.24 111.14,123.53 111.11,123.59 111.11,123.97 110.98,124.1
  BOTTOM w0.114: 110.98,124.1 110.8,124.28 110.8,125.88 110.47,126.21 110.47,127.5 110.57,127.6 110.85,127.6 110.93,127.53 R10845.1
DDI2_TXP0: length 6
  BOTTOM w0.076: U35.D50 112.51,121.98 112.88,122.36 112.88,122.79 112.96,122.97 112.96,123.1 112.9,123.33 112.9,123.47 112.96,123.64 112.97,123.65 112.97,124.07 112.96,124.08
  BOTTOM w0.114: 112.96,124.08 112.96,126.29 112.86,126.39 112.86,127.17 R10842.1
DDI2_TXP1: length 6.2
  BOTTOM w0.076: U35.D52 111.03,122.12 111.03,122.73 110.94,122.95 110.94,123.2 110.98,123.28 110.98,123.49 110.95,123.56 110.95,123.56 110.95,123.82 110.78,124
  BOTTOM w0.114: R10844.1 110.27,127.17 110.27,126.12 110.6,125.79 110.6,124.18 110.78,124
DDR3_DRAMRST#: length 136.5
  TOP w0.127: R670.1 130.43,100.73 C750.1 129.48,100.47 129.93,100.02 131.53,100.02 131.71,100.2 131.71,102.25 131.98,102.53 131.98,103.45 v2(132.13,103.59) ; C1258.2 109.61,45.21 v1(109,45.82) v1(109,46.45) 109,46.6 109.78,47.39 109.78,51.02 109.15,51.66 109.15,53.42 v1(109.84,54.1) 110.17,54.44 C1317.2
  IN2 w0.127: v2(132.13,103.59) 132.48,103.23 132.84,103.23 133.14,103.23 133.91,102.46 133.91,102.28 142.4,93.8 142.4,92.2 143.82,90.77 144.25,90.77 150.22,84.81 150.22,73.58 150.45,73.35 150.45,60.93 148.84,59.32 148.84,59 148.2,58.37 148.19,58.37 146.96,57.14 146.96,50.97 142.8,46.81 142.8,43.34 138.59,39.13 135.6,39.13 134.35,40.38 128.17,40.38 127.59,40.96 127.59,41.88 127.49,41.98 127.49,41.99 127.22,42.26 127.21,42.26 126.2,43.27 121.73,43.27 118.55,46.45 117.99,46.45 117,47.44 116.19,47.44 115.73,46.98 113.54,46.98 113.32,47.21 112.26,47.21 112.11,47.06 110.14,47.06 109,45.92 v1(109,45.82)
  BOTTOM w0.127: v1(109,45.82) 109.47,45.34 JDIM1.108 ; v1(109.84,54.1) 109.47,54.47 JDIM2.108
DDR4_SUSON_2V5: length 20.9
  BOTTOM w0.127: PR307.1 166.65,44.37 166.94,44.08 167.09,44.08 167.25,43.92 168.09,43.92 v1(168.26,43.76) 171.38,43.76 172.42,42.72 172.42,42.06 172.73,41.75 172.73,41.35 173.01,41.07 173.01,40.65 173.16,40.49 173.84,40.49 174.05,40.28 180.35,40.28 181.67,41.6 181.7,41.6 181.72,41.63 182.04,41.63 182.35,41.93 182.86,41.93 183.18,42.25 U45.122
DDR_VTT_CTRL: length 11.2
  BOTTOM w0.079: 97.34,101.75 98.74,101.75 99.52,102.53 100.42,102.53 100.62,102.74 100.89,102.74 101.07,102.56 101.38,102.56 101.58,102.76 101.58,103.01 101.66,103.09 102.42,103.09 U35.AW67
  BOTTOM w0.127: Q35.1 93.35,101.72 v1(93.86,102.23) 94.6,101.48 R621.2 95.17,101.48 95.43,101.75 97.34,101.75
DDR_VTTREF: length 126.7
  IN1 w1.016: 42.04,58.58 42.04,58.91 43.68,60.55 46.38,60.55 47.1,59.83 50.6,59.83 54.32,63.55 55.83,63.55 59.51,67.23 69.95,67.23 76.51,60.67 76.51,55.95 77.5,54.96 77.5,50.97 78.66,49.82 78.66,47.96 78.96,47.66 78.96,47.65 79.2,47.41 79.2,45.54 81.49,43.25 108.54,43.25 108.95,42.84 117.68,42.84 118.16,43.32 123.87,43.32 124.03,43.48 144.56,43.48 145.04,43
  BOTTOM w0.203: v1(148.65,54.1) 148.97,54.42 JDIM2.258
  vias: v1(147.45,44.93) v1(147.81,54.25) v1(147.86,45.46) v1(148.97,41.8) v3(42.03,57.83)
DDR_VTTT_PG_CTRL: length 93.4
  TOP w0.127: PR6302.2 44.82,62.84 v1(44.05,62.84)
  BOTTOM w0.127: Q35.3 89.6,102.38 R682.2 v1(88.87,102.39) 79.1,112.16 75.49,112.16 72.07,108.73 69.51,108.73 59.22,98.44 50.6,98.44 45.55,93.39 45.55,80.9 49.8,76.65 49.8,71.13 47.4,68.73 47.4,67.98 44.49,65.07 44.49,63.15 44.18,62.84 v1(44.05,62.84)
DEVSLP0: length 149
  IN1 w0.14: v1(222.94,40.41) 221.29,38.75 v1(221.29,37.89)
  IN2 w0.14: v1(208.06,49.55) 208.03,49.52 204.97,49.52 204.54,49.09 203.39,49.09 202,50.48 197.32,50.48 192.41,55.39 187.38,55.39 182.96,59.81 182.96,61.29 179.95,64.31 179.13,64.31 178.57,64.87 177.12,66.31 176.82,66.31 173.74,69.39 173.74,80.96 174.74,81.96 174.74,91.23 174.47,91.5 174.47,93.92 174.55,94 174.55,95.6 173.98,96.18 173.98,101.44 173.37,102.04 173.37,107.7 170.02,111.05 170.02,111.77 169,112.8 168.42,112.8 163.45,117.77 159.88,121.33 157.42,121.33 156.48,122.27 149.64,122.27 148.01,120.64 145.55,120.64 145.34,120.44 143.71,120.44 v1(143.61,120.34)
  BOTTOM w0.114: 140.81,118.98 U35.J1
  BOTTOM w0.127: R573.1 143.78,120.16 v1(143.61,120.34) 142.54,119.27 141.11,119.27 140.81,118.98 ; v1(221.29,37.89) 217.95,41.23 217.59,41.23 v1(217.28,41.55) 217.28,46.02 214.38,48.91 208.69,48.91 v1(208.06,49.55) ; R351.1 v1(222.94,40.41)
DEVSLP0_R: length 7.3
  BOTTOM w0.127: R351.2 v1(225.46,40.41) 225.79,40.41 229.4,44.01 CN14.9
DEVSLP2: length 82.3
  TOP w0.127: v1(146.39,120.14) 146.39,120.59 146.18,120.8 146.18,121.69 146.59,122.09 146.92,122.09 147.76,122.93 158.6,122.93 164.98,116.56 v1(165.11,116.56) v1(165.77,116.56)
  IN1 w0.14: v1(165.77,116.56) 167.56,114.76 173.18,114.76 173.64,114.29 173.64,112.69 171.94,110.99 171.94,106.17 171.68,105.91 171.68,99.33 172.29,98.72 172.29,91.36 172.32,91.36 173.22,90.46 173.22,89.34 173.41,89.15 v1(173.41,88.97)
  BOTTOM w0.076: U35.J3 139.8,118.6 140.32,118.59 140.48,118.53 140.68,118.44 140.86,118.44 141.22,118.08
  BOTTOM w0.127: v1(146.39,120.14) 146.39,119.93 146.92,119.4 146.92,119.23 R575.1 146.5,118.64 143.95,118.64 143.69,118.38 142.04,118.38 141.74,118.08 141.22,118.08 ; R956.2 166.6,92.97 166.87,93.25 166.87,94.49 167.27,94.89 169.22,94.89 169.81,94.3 169.81,93.29 170.01,93.09 170.36,93.09 171.46,91.99 171.46,89.91 171.68,89.68 172.7,89.68 v1(173.41,88.97)
DEVSLP_N1: length 3.2
  BOTTOM w0.127: CN23.38 165.5,95.88 165.5,94.57 165.41,94.48 R957.2 R956.1
DGPU_D: length 369
  TOP w0.127: v1(154.95,20.42) v1(155.63,20.42) 156.03,20.42 162.54,26.92 168.71,26.92 170.03,25.6 171.04,25.6 171.84,24.8 v1(171.84,24.53) ; PC113.2 53.47,72.16 v1(54.03,72.71)
  TOP w0.381: PQ16.3 50.6,73.55 52.16,73.55 PR161.2 52.77,72.94 PC113.2
  IN1 w0.102: 123.75,44.22 138.03,44.22 139.58,45.77 v1(140.67,45.77)
  IN1 w0.14: v1(214.64,39.44) 216.41,41.22 221.88,41.22 222.61,41.96 222.61,47.1 220.5,49.21 220.5,50.74 221.15,51.38 225.26,51.38 227.49,53.62 227.49,60.93 225.65,62.78 223.35,62.78 222.81,63.31 219.79,63.31 219.54,63.56 219.54,65.77 220.66,66.89 220.66,80.82 224.83,84.99 227.39,84.99 230.35,87.95 230.35,88.82 231.86,90.32 231.86,96.62 229.09,99.38 229.09,104.39 230.23,105.53 230.23,111.92 230.66,112.35 230.66,116.38 230.56,116.48 v1(230.56,116.78) ; v1(54.03,72.71) 55.51,71.24 60.08,71.24 60.6,70.73 73.93,70.73 77.57,67.09 77.57,57 79.05,55.52 79.05,51.41 80.44,50.02 80.44,46.59 83.06,43.97 108.86,43.97 109.25,43.58 117.4,43.58 117.86,44.04 123.58,44.04 123.75,44.22
  IN2 w0.14: v1(140.67,45.77) 140.67,45.21 140.39,44.93 v1(140.39,41.75) ; v1(214.64,39.44) 209.33,39.44 207.52,37.63 206.07,37.63 205.78,37.35 200.47,37.35 200.32,37.49 195.5,37.49 191.08,33.07 191.08,32.29 189.95,31.16 189.95,29.43 188.46,27.94 186.64,27.94 185.98,28.59 178.9,28.59 177.12,26.82 177.1,26.82 174.12,26.82 v1(171.84,24.53)
  BOTTOM w0.127: v1(140.39,41.75) 140.39,39.03 139.12,37.76 139.12,36.32 140.47,34.97 142.22,34.97 144.07,33.12 144.07,31.19 144.83,30.42 144.83,27.92 150.98,21.76 155.4,21.76 155.71,21.46 155.71,20.77 155.35,20.42 v1(154.95,20.42) ; PQ19.2 198.66,105.68 198.81,105.84 198.81,107.21 199.45,107.84 200.21,107.84 201.35,106.7 205.03,106.7 208.59,110.26 210.37,110.26 210.53,110.42 215.06,110.42 215.6,110.95 219.98,110.95 223.09,114.07 226.45,114.07 229.39,117.01 230.33,117.01 v1(230.56,116.78)
DGPU_EVENT#: length 59.1
  TOP w0.127: v1(137.74,105.82) 138,105.56 139.6,105.56 141.48,103.68 143.08,103.68 143.27,103.48 143.38,103.38 144.07,102.69 145,102.69 145.1,102.59 157.84,102.59 158.87,101.56 160.18,101.56 161.37,100.37 v1(161.37,100.2) 161.58,99.99 162.34,99.99 162.59,100.25 162.59,100.96 165.28,103.65 175.67,103.65 176.26,104.24 180.4,104.24 180.52,104.36 181.44,104.36 181.72,104.64 181.72,105.51 181.57,105.66 v1(181.57,106.29)
  BOTTOM w0.127: U35.AP5 137.82,105.82 v1(137.74,105.82) ; v1(181.57,106.29) 181.77,106.5 183.67,106.5 184.23,105.94 185.5,105.94 185.74,106.18 187.77,106.18 188.62,107.03 R4335.2
DGPU_HOLD_RST#: length 79.9
  TOP w0.114: 137.43,107.57 137.17,107.31
  TOP w0.127: 137.17,107.31 137.17,107 137.64,106.53 v1(137.64,106.48) ; v1(181.21,104.82) 180.55,104.82 180.32,104.59 176.1,104.59 175.42,103.91 v1(162.64,103.91) 162.49,103.91 161.73,104.67 159.39,104.67 159.05,104.33 R208.1 158.65,104.16 157.84,103.35 147.41,103.35 146.48,104.27 146.48,104.27 146.34,104.41 145.41,104.41 145,104.01 143.83,104.01 143.39,104.44 141.89,104.44 139.6,106.73 138.64,106.73 137.79,107.57 137.43,107.57
  BOTTOM w0.079: v1(137.64,106.48) 137.57,106.48 U35.AP7
  BOTTOM w0.127: v1(181.21,104.82) 181.35,104.68 182.41,104.68 182.45,104.72 187.02,104.72 187.44,104.3 192.82,104.3 193.25,103.87 206.95,103.87 209.63,106.55 U4001.1
DGPU_OPP#: length 125.1
  TOP w0.127: Q4301.3 v1(172.8,114.29)
  IN1 w0.14: v1(172.8,114.29) 171.66,113.15 171.66,106.38 171.33,106.05 171.33,99.29 172.01,98.61 172.01,89.58 170.82,88.39 170.82,87.1 171.08,86.84 171.08,86.43 171.98,85.52 171.98,79.46 172.81,78.64 172.81,75.14 172.26,74.6 172.26,70.66 177.55,65.38 177.55,64.81 177.55,62.21 178.55,61.21 178.55,59.44 176.33,57.22 176.33,55.78 179.03,53.08 179.41,53.08 181.01,51.48 181.72,51.48 182.56,52.32 186.52,52.32 187.23,53.03 190.86,53.03 191.22,52.67 191.22,52.24 190.91,51.94 190.35,51.94 188.68,50.26 183.29,50.26 182.73,49.7 182.73,48.69 182.45,48.41 182.4,48.41 180.93,46.93 180.93,46.16 182.05,45.04 182.05,43.09 180.16,41.2 179.9,41.2 179.61,40.91 179.61,34.18 179.23,33.8 175.19,33.8 171.28,29.89 170.21,29.89 v1(170.14,29.97)
  BOTTOM w0.127: U45.68 170.37,30.2 v1(170.14,29.97) 170.03,29.86 R382.1
DGPU_OTP#: length 110
  TOP w0.127: Q4301.6 168.17,112.99 168.09,112.91 168.09,112.76 v1(168.74,112.11)
  IN1 w0.14: v1(176.84,38.3) 176.85,38.3 176.85,38.28 176.97,38.16 176.97,36.91 175.88,35.81 175.27,35.81 171.33,31.87 167.6,31.87 166.96,31.23 v1(165.86,31.23) ; v1(168.74,112.11) 171.38,109.47 171.38,106.5 170.68,105.8 170.68,97.14 171.23,96.59 171.23,89.19 170.54,88.5 170.54,86.98 170.8,86.73 170.8,86.31 171.66,85.45 171.66,79.39 172.53,78.52 172.53,75.26 171.98,74.71 171.98,70.55 177.27,65.26 177.27,62.09 178.27,61.09 178.27,59.82 v1(177.25,58.8)
  IN2 w0.14: v1(176.84,38.3) 176.34,38.8 176.34,40.43 176.36,40.45 176.36,42.56 176.18,42.74 176.18,44.25 176.1,44.33 176.1,44.82 176.47,45.19 176.47,45.19 177.25,45.97 177.25,51.09 178.03,51.87 178.03,54.17 178.47,54.6 178.47,57.07 177.53,58.01 177.53,58.52 v1(177.25,58.8)
  BOTTOM w0.127: v1(176.84,38.3) 176.89,38.25 179.25,38.25 179.94,38.93 180.9,38.93 183.98,42.01 U45.124 ; v1(165.86,31.23) 165.92,31.23 v1(166.55,30.6) 166.8,30.36 R740.1
DGPU_PGOK-1: length 9
  BOTTOM w0.127: Q4203.3 163.3,138.4 162.41,138.4 v1(162.26,138.55) 161.22,139.59 160.33,139.59 159.42,140.51 Q4202.2 159.95,141.12 159.95,142.39 160.42,142.85 ; 160.42,142.85 R4205.1 ; 160.42,142.85 C4202.1
DGPU_POK2: length 3.3
  BOTTOM w0.127: C4203.1 162.88,142.73 v1(162.74,142.87) ; C4203.1 162.88,141.75 162.62,141.49 Q4203.2 ; C4203.1 R4207.1
DGPU_PSI: length 111.4
  TOP w0.127: v1(185.91,64.56) 185.86,64.61 185.86,65.02 183,67.88 174.14,67.88 172.75,69.26 v1(172.75,74.37) 172.75,76.61 171.72,77.64 169.63,77.64 167.67,79.6 167.67,80.51 167.21,80.96 167.21,82.22 164.88,84.56 164.88,87.07 167.92,90.11 170.65,90.11 176.69,96.15 176.69,100.16 180.64,104.11 181.54,104.11 182.08,104.64 182.37,104.64 182.9,105.17 182.9,109.38 183.19,109.67 183.19,111.52 R4324.2 183.95,112.28 183.95,115.72 186.05,117.81 186.05,119.77 186.42,120.14 v1(186.42,121.56)
  IN1 w0.14: v1(204.73,60.5) 204.5,60.27 204.5,58.95 203.74,58.19 197.64,58.19 196.03,59.8 195.47,59.8 192.49,62.78 190.25,62.78 189.78,63.26 188.25,63.26 186.95,64.56 v1(185.91,64.56)
  BOTTOM w0.102: U3002.M4 186.83,121.22 186.49,121.56 v1(186.42,121.56)
  BOTTOM w0.127: v1(204.73,60.5) 204.91,60.68 PR101.2
  BOTTOM w0.305: PR102.1 205.69,58.69 PR104.2 ; PR104.2 204.64,59.68 PR255.1 ; PR104.2 PR101.2
DGPU_PW_CTRL#: length 31.7
  TOP w0.127: v1(160.94,106.62) 160.7,106.39 R127.2 R115.1 159.32,106.34 158.27,106.34 v1(158.01,106.08)
  IN1 w0.14: v1(158.01,106.08) 157.86,106.08 157.41,105.62 157.41,104.5 156.81,103.91 155.21,103.91 154.29,104.83 154.29,105.69 153.81,106.17 150.09,106.17 147.99,104.06 144.94,104.06 144.48,103.6 v1(144.48,101.24)
  BOTTOM w0.127: v1(144.48,101.24) 144.48,101.01 144.28,100.81 143.9,100.81 143.19,100.1 139.92,100.1 139.53,100.48 138.99,100.48 138.64,100.83 138.64,101.35 U35.BA5
DGPU_PWR_EN: length 210.5
  TOP w0.127: R257.2 156.6,74.18 v1(156.6,74.06) R256.1 156.28,73.04 153.14,73.04 152.28,73.91 v1(152.28,74.01) ; v1(54.84,70.96) 54.75,70.87 PR160.1
  IN1 w0.14: v1(54.84,70.96) 57.27,70.96 57.28,70.96 59.89,70.96 60.4,70.45 73.82,70.45 77.29,66.98 77.29,56.88 78.77,55.4 78.77,51.29 80.16,49.91 80.16,48.32 v1(79.86,48.03)
  IN2 w0.14: v1(79.86,48.03) 80.07,47.82 80.07,46.88 81.36,45.59 81.36,44.19 82.7,42.86 85.1,42.86 87.95,40 96.2,40 96.75,40.56 97.75,40.56 98.94,41.75 104.68,41.75 105.92,40.51 109.8,40.51 110.02,40.74 119.87,40.74 121.04,39.56 122.07,39.56 123.38,38.25 127.34,38.25 128.68,36.9 132.48,36.9 133.39,37.82 138.92,37.82 144.32,43.21 148.68,43.21 154.08,48.61 154.08,49.02 153.8,49.3 153.27,49.3 152.76,49.8 152.76,62.63 152.42,62.97 152.42,64.12 151.77,64.76 151.77,72.38 152.28,72.89 v1(152.28,74.01) 151.85,74.44 151.85,75.94 151.05,76.74 151.05,84.97 151.42,85.34 151.42,95.19 148.44,98.17 140.67,98.17 135.38,103.45 135.38,106.06 v1(135.81,106.48)
  BOTTOM w0.127: v1(135.81,106.48) 136.14,106.15 U35.AP8
DGPU_PWROK: length 73.1
  TOP w0.127: v1(162.57,105.53) v1(162.08,105.05) 159.41,105.05 158.96,104.6 158.73,104.6 157.76,103.63 154.96,103.63 R110.1 154.02,103.6 147.52,103.6 146.59,104.53 146.45,104.67 145.3,104.67 144.9,104.26 143.93,104.26 143.5,104.69 142.02,104.69 139.63,107.08 138.97,107.08 138.42,107.63 v2(138.42,107.88)
  IN1 w0.14: v1(157.13,140.43) 157.13,136.85 154.62,134.34 154.62,124.07 161.92,116.77 161.92,115.45 v1(163.15,114.22)
  BOTTOM w0.127: v2(138.42,107.88) 138.15,107.61 U35.AM5 ; Q4202.3 160.08,138.96 159.36,139.68 R4206.2 R4204.1 v1(157.13,140.43) ; v1(163.15,114.22) 163.15,110.49 161.65,108.98 161.65,106.17 162.29,105.53 v1(162.57,105.53)
DMIC_CLK: length 2.4
  BOTTOM w0.127: U23.3 203,36.57 v1(202.72,36.85) 202.49,37.08 R370.2
DMIC_CLK0_R: length 12.1
  BOTTOM w0.076: 140.68,117.23 139.41,117.23 139.16,117.48 139.16,117.67 138.97,117.86 138.78,117.86 138.53,118.11 138.53,118.62 138.15,118.99 U35.H5
  BOTTOM w0.127: TP4372.1 147.96,117.67 146.06,117.67 145.98,117.6 142.2,117.6 141.82,117.23 140.68,117.23
DMIC_CLK_L: length 14.5
  IN1 w0.14: v1(205.47,47.49) v1(205.47,48.66)
  BOTTOM w0.127: R370.1 C488.1
  BOTTOM w0.14: R11186.2 R11047.2 204.92,48.86 205.11,48.66 v1(205.47,48.66) ; C488.1 202,39.51 201.85,39.66 201.85,40.33 202.09,40.57 202.09,41.84 202.24,41.99 202.65,41.99 203.76,43.11 203.76,43.96 205.52,45.71 205.52,47.44 v1(205.47,47.49)
DMIC_CLK_L1: length 97
  TOP w0.127: v1(187.08,62.28) 186.38,62.28 184.55,64.1 184.55,64.85 182.57,66.83 171.62,66.83 171.46,67 170.3,67 169.48,66.19 165.28,66.19 164.8,65.7 160.98,65.7 160.27,66.42 160.27,67.05 158.16,69.16 153.18,69.16 153.03,69.31 138.43,69.31 C378.1 D4.1 v1(133.56,76.25) 133.56,77.46 135.45,79.36 135.45,84.99 135.06,85.38 134.44,85.38 133.89,84.82 U16.3
  IN1 w0.14: v1(201.22,47.19) 201.22,48.38 v1(199.98,49.63)
  BOTTOM w0.127: v1(187.08,62.28) 187.08,62.27 187.08,61.89 190.91,58.06 190.91,57.02 198.3,49.63 v1(199.98,49.63) ; R11179.2 v1(201.22,47.19)
DMIC_CLK_L2: length 62.5
  TOP w0.127: U4512.3 171.7,84.82 171.84,84.96 171.84,85.62 172.26,86.04 172.44,86.04 172.84,85.63 172.84,83.06 172.14,82.37 v1(170.82,82.37)
  BOTTOM w0.127: v1(170.82,82.37) 170.82,82.42 171.23,82.82 v1(171.28,82.82) 171.53,82.57 C4737.1 D4014.1 172.01,80.99 172.52,80.47 173.81,80.47 174.31,79.97 174.31,74.91 173.55,74.15 173.55,67.32 174.9,65.97 184.5,65.97 185.25,65.22 185.25,63.32 190.63,57.93 190.63,56.89 198.41,49.12 R11175.2
DMIC_CLK_L_R0: length 151.7
  TOP w0.127: U17.3 83.9,84.82 84.33,85.25 84.33,87.7 84.91,88.27 87.81,88.27 88.01,88.07 88.01,87.28 87.66,86.93 v1(87.56,86.93) ; v1(152.3,66.29) 152.53,66.06 155.42,66.06 158.96,62.52 161.87,62.52 162.02,62.37 164.21,62.37 164.7,62.86 169.97,62.86 170.89,63.77 173.92,63.77 175.17,65.02 180.06,65.02 181.28,63.8 181.88,63.8 185.58,60.1 185.58,57.02 187.77,54.83 191.84,54.83 196.11,50.57 204.65,50.57 205.7,49.52 207.04,49.52 v1(207.37,49.19) v1(208.03,48.53)
  BOTTOM w0.127: R11186.1 207.45,49.12 v1(208.03,48.53) ; v1(152.3,66.29) 152.1,66.09 151.77,66.09 150.15,67.71 147.31,67.71 143.58,71.44 135.23,71.44 123.07,83.61 93.8,83.61 90.36,87.06 C357.1 88.17,86.93 v1(87.56,86.93) 86.9,86.93 D2.1
DMIC_CLK_L_R1: length 2.1
  BOTTOM w0.127: R11179.1 203.02,47.2 R11181.2 203.71,48.1 203.82,48 R270.1
DMIC_CLK_L_R2: length 1
  BOTTOM w0.127: R11175.1 R11182.1
DMIC_DAT: length 2.6
  BOTTOM w0.127: R371.2 201.61,37.23 202.6,36.24 U23.2
DMIC_DAT_L: length 12.5
  BOTTOM w0.14: R11185.2 205.77,47.95 205.72,48 R270.2 204.93,47.37 205.23,47.07 205.23,45.84 203.47,44.08 203.47,43.23 202.53,42.29 202.09,42.29 201.73,41.93 201.73,40.56 201.61,40.43 v1(201.61,39.23) R371.1
DMIC_DAT_L1: length 98
  TOP w0.127: v1(187.13,62.99) 186.06,62.99 184.83,64.22 184.83,64.97 182.69,67.11 171.74,67.11 171.57,67.28 170.18,67.28 169.53,66.63 165.24,66.63 164.59,65.98 161.1,65.98 160.55,66.53 160.55,67.16 158.28,69.44 153.29,69.44 153.14,69.59 138.66,69.59 135.63,72.62 C379.1 135.62,74.22 D5.1 v1(135.62,76.02) 135.62,76.83 136.59,77.81 136.59,85.46 135.54,86.52 132.19,86.52 131.65,85.98 131.65,85.36 132.19,84.82 U16.4
  BOTTOM w0.127: v1(187.13,62.99) 187.61,62.5 187.61,61.77 191.19,58.19 191.19,57.14 198.25,50.08 R11180.2
DMIC_DAT_L2: length 63.1
  TOP w0.127: U4512.4 169.58,84.82 168.52,85.88 167.92,85.88 167.63,85.6 167.63,84.4 167.99,84.05 167.99,83.29 168.28,83 v1(168.28,82.99)
  BOTTOM w0.127: v1(168.28,82.99) 168.5,82.77 169.75,82.77 170.23,82.3 C4736.1 D4013.1 v1(171.15,81.05) 171.55,81.05 172.41,80.19 173.68,80.19 174.03,79.84 174.03,75.03 173.27,74.27 173.27,67.2 174.78,65.69 184.38,65.69 184.97,65.11 184.97,63.16 190.35,57.78 190.35,56.76 198.33,48.79 199.87,48.79 R11176.2
DMIC_DAT_L_R0: length 155.2
  TOP w0.127: v1(207.3,48.53) 206.58,49.25 205.58,49.25 204.54,50.29 195.99,50.29 191.73,54.55 187.64,54.55 185.27,56.92 185.27,60.01 181.76,63.52 181.24,63.52 179.97,64.79 175.33,64.79 174.04,63.49 171,63.49 170.09,62.58 164.82,62.58 164.38,62.14 162.51,62.14 161.98,61.61 159.47,61.61 155.31,65.78 152.48,65.78 v1(152.28,65.58) ; v1(87.54,86.06) 88.29,86.81 88.29,88.92 87.8,89.42 83.94,89.42 81.64,87.11 81.64,85.25 82.07,84.82 U17.4
  BOTTOM w0.127: R11185.1 206.77,48.01 v1(207.3,48.53) ; D3.1 v1(87.54,86.06) C374.1 90.96,86.06 93.69,83.33 122.95,83.33 135.12,71.17 143.46,71.17 147.2,67.43 150.03,67.43 151.66,65.81 152.05,65.81 v1(152.28,65.58)
DMIC_DAT_L_R1: length 3.2
  BOTTOM w0.127: R11047.1 R11182.2 203.02,49.91 v1(202.96,49.98) 202.85,50.08 R11180.1
DMIC_DAT_L_R2: length 2
  BOTTOM w0.127: R11181.1 201.71,48.1 201.61,48.2 R11176.1 201.23,48.06 v1(200.67,47.49)
DMIC_DATA0_R: length 8.8
  BOTTOM w0.076: 141.36,122.07 141.31,122.07 141,121.76 140.57,121.76 139.28,123.06 139.02,123.06 138.74,122.77 138.46,122.77 137.45,121.76 U35.D7
  BOTTOM w0.127: TP4373.1 141.94,122.65 141.36,122.07
DNBSWON#: length 91
  IN1 w0.14: v1(160.18,84.81) 160.86,84.12 160.86,83.56 164.83,79.6 164.83,72.23 165.21,71.84 165.21,71.33 165.36,71.19 165.36,70.08 165.99,69.44 165.99,68.15 171.25,62.89 171.25,59.85 171.62,59.48 171.62,54.64 172.87,53.39 172.87,51.65 172.62,51.4 172.62,48.21 173.35,47.47 173.35,46.67 173.81,46.22 173.81,44.62 173.81,44.19 174.09,43.91 175.27,42.74 176,42.74 176.35,42.39 176.35,40.87 175.88,40.4 v1(175.88,39.21)
  BOTTOM w0.127: v1(160.18,84.81) 159.33,84.81 157.26,82.73 149.28,82.73 145.46,86.56 143.06,86.56 138.49,91.13 v1(138.49,91.14) R677.1 ; v1(175.88,39.21) 176.1,39.44 178.21,39.44 178.42,39.24 180.89,39.24 183.58,41.93 U45.123
