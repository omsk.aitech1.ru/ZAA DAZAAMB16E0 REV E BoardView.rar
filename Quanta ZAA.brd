# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_TXN3/PEG_TXN10_L1_N: length 4.2
  BOTTOM w0.114: C4664.2 163.06,106.88 163.06,106.67 163.11,106.62 163.38,106.35 163.38,105.23 163.11,104.96 163.11,104.49 163.25,104.35 CN23.47
SATA_TXP0: length 171.5
  IN2 w0.114: v1(208.69,50.36) 208.51,50.54 208.51,51.47 207.81,52.17 198.02,52.17 193.35,56.84 188.5,56.84 184.65,60.69 184.65,62.07 182.27,64.45 182.27,64.86 181.57,65.56 181.21,65.56 180.77,66 179.47,66 176,69.47 176,74.31 175.49,74.81 175.49,80.33 176.43,81.26 176.43,88.94 176.75,89.26 176.75,91.43 177.06,91.73 177.06,95.82 177.7,96.46 177.7,100.86 176,102.56 176,104.74 175.55,105.2 175.55,107.69 175.08,108.16 175.08,109.01 174.29,109.79 174.29,111.18 173.03,112.44 172.14,112.44 165.4,119.18 164.81,119.18 162.25,121.75 162.25,123.06 161.56,123.75 161.56,125.03 159.01,127.58 144.91,127.58 143.35,126.02 138.37,126.02 137.85,126.54 136.02,126.54 134.59,125.1 128.88,125.1 v2(128.56,125.42)
  BOTTOM w0.114: U35.A21 128.73,123.89 128.83,124 128.83,125.14 v2(128.56,125.42) ; v1(208.69,50.36) 208.48,50.58 208.48,50.76 208.55,50.83 213.92,50.83 217.93,46.83 217.93,42.31 222.32,37.91 222.32,36.63 224.02,34.93 224.02,34.07 223.91,33.95 223.61,33.95 C522.2
SATA_TXP0_C: length 8.5
  BOTTOM w0.114: CN14.2 229.81,30.54 228.19,30.54 227.34,31.39 224.97,31.39 223.83,32.53 223.83,32.95 C522.1
SATA_TXP1: length 197.5
  IN2 w0.114: v2(128.26,122.2) 128,121.94 127.8,121.94 126.63,123.11 126.63,125.11 127.9,126.38 131.38,126.38 132.7,127.71 135.11,127.71 135.35,127.95 138.2,127.95 138.64,127.52 142.28,127.52 143.81,129.04 159.66,129.04 163.05,125.65 163.05,124.4 163.71,123.74 163.71,122.41 165.39,120.72 165.97,120.72 169.14,117.55 171.08,117.55 174.64,114 174.64,112.9 175.09,112.44 175.75,111.79 175.75,110.4 177.92,108.23 177.92,106.93 178.12,106.73 178.12,105.18 177.46,104.52 177.46,103.39 179.16,101.69 179.16,95.85 178.64,95.33 178.64,88.99 177.89,88.24 177.89,80.65 176.96,79.72 176.96,75.42 177.46,74.92 177.46,69.72 179.9,67.28 181.56,67.28 181.82,67.02 182.23,67.02 186.19,63.06 186.19,61.28 187.33,60.14 188.65,60.14 190.44,58.35 194.78,58.35 199.41,53.73 204.93,53.73 206.89,55.7 206.89,58.62 206.64,58.87 206.64,60.19 208.01,61.56 208.01,62.91 208.34,63.24 208.57,63.24 v1(208.77,63.04)
  BOTTOM w0.114: U35.C21 128.73,122.63 128.63,122.73 128.45,122.73 128.35,122.63 128.35,122.29 v2(128.26,122.2) ; v1(208.77,63.04) 209.02,63.29 210.57,63.29 211.46,62.4 213.24,62.4 215.78,64.94 221.29,64.94 221.84,65.49 221.84,82.35 223.9,84.42 228.43,84.42 228.52,84.33 C751.2
SATA_TXP1_C: length 12.6
  BOTTOM w0.114: C751.1 229.72,84.26 230.02,84.26 230.31,84.55 231.51,85.76 231.51,88.32 233.17,89.97 233.17,93.56 233.3,93.69 233.53,93.69 CN9.2
SATA_TXP3/PEG_TXP9_L0: length 66.6
  IN2 w0.114: v1(165.94,122.22) 165.73,122 165.61,122 164.76,122.85 164.76,124.19 164.48,124.47 164.48,125.76 160.14,130.11 143.38,130.11 141.88,128.61 138.86,128.61 138.59,128.87 134.84,128.87 134.58,128.61 132.33,128.61 130.9,127.18 127.4,127.18 126.43,126.21 126.16,126.21 126.09,126.28 v1(126.09,126.54)
  BOTTOM w0.076: 126.7,122.85 U35.C24
  BOTTOM w0.079: v1(126.09,126.54) 126.37,126.26 126.42,126.26 126.7,125.98 126.7,125.65 126.43,125.38 126.43,124.49 126.7,124.23 126.7,122.85
  BOTTOM w0.114: v1(165.94,122.22) 165.72,121.99 165.51,121.99 165.26,121.74 165.26,118.56 166.32,117.5 166.32,109.18 165.94,108.8 165.94,108.51 C1177.1
SATA_TXP3/PEG_TXP9_L0_N: length 4.1
  BOTTOM w0.114: C1177.2 165.89,106.97 165.89,104.49 165.75,104.35 CN23.37
SATA_TXP3/PEG_TXP10_L1: length 70.7
  IN2 w0.114: v1(125.69,124.15) 125.49,124.35 125.21,124.35 125.06,124.49 124.76,124.8 124.76,126.5 126.15,127.9 130.57,127.9 131.84,129.17 134.17,129.17 134.74,129.74 139.02,129.74 139.31,129.45 141.53,129.45 143.09,131.01 152.36,131.01 152.65,131.3 160.17,131.3 165.61,125.85 165.61,124.43 165.72,124.33 166.02,124.33 v1(166.25,124.55)
  BOTTOM w0.114: v1(125.69,124.15) 125.69,124.18 125.91,123.95 125.91,123.59 126.25,123.25 U35.B25 ; v1(166.25,124.55) 166.06,124.37 165.5,124.37 163.57,122.44 163.57,117.66 164.12,117.11 164.12,110.43 162.72,109.04 162.72,108.21 C4665.1
SATA_TXP3/PEG_TXP10_L1_N: length 4.2
  BOTTOM w0.114: C4665.2 162.85,106.84 162.85,106.58 162.95,106.47 163.16,106.26 163.16,105.32 162.89,105.05 162.89,104.49 162.75,104.35 CN23.49
SATAGP0: length 13.1
  BOTTOM w0.076: 140.86,119.77 140.7,119.77 140.55,119.82 140.44,119.82 140.25,119.77 U35.H2
  BOTTOM w0.127: 140.86,119.77 141.15,120.06 141.15,120.39 141.84,121.08 148.03,121.08 R568.2 148.77,121.79 149.54,121.03 149.54,120.65 R570.2 149.97,120.21 v1(149.26,119.5)
SATAGP1: length 10.8
  BOTTOM w0.076: U35.H3 139.51,119.22 140.62,119.22 140.95,119.55 141.18,119.55
  BOTTOM w0.127: v1(147.73,119.2) 147.16,119.76 R569.1 147.16,120.58 146.92,120.82 141.94,120.82 141.46,120.34 141.46,119.83 141.18,119.55
SB_ACDC: length 86.6
  IN1 w0.14: v1(175.8,38.22) 175.34,38.68 175.34,41.94 175.07,42.22 175.05,42.22 174.05,43.22 173.89,43.22 172.74,44.37 172.74,47.21 172.1,47.85 172.1,51.61 172.35,51.86 172.35,53.18 171.1,54.42 171.1,59.26 170.73,59.63 170.73,62.68 165.47,67.93 165.47,69.23 164.28,70.42 164.28,79.41 160.18,83.51 v1(160.18,83.64)
  BOTTOM w0.127: U45.84 172.7,36.6 173.13,37.03 174.54,37.03 174.65,36.91 175.02,36.91 175.13,37.03 175.19,37.03 175.8,37.64 v1(175.8,38.22) ; R676.1 v1(137.34,91.98) 137.34,91.08 142.65,85.77 145.13,85.77 148.93,81.97 157.94,81.97 159.4,83.43 159.98,83.43 v1(160.18,83.64)
SD_CLK_R: length 2.3
  TOP w0.114: R11141.1 32.43,23.63 32.37,23.57 CN4.5
SEN_A: length 39.8
  TOP w0.127: v2(172.37,161) 172.56,160.81 R1438.2
  IN1 w0.14: v2(195.33,162.94) 194.85,163.42 194.85,167.1 v1(195.13,167.38)
  BOTTOM w0.127: v1(195.13,167.38) 192.09,170.42 186.51,170.42 186.02,169.93 v1(182.84,169.93) 176.82,169.93 175.79,168.9 174.28,168.9 173.08,167.71 173.08,161.68 172.4,161
  BOTTOM w0.14: U5.J10 196.04,161.31 195.59,161.31 195.33,161.56 v2(195.33,162.94)
  BOTTOM w0.152: U7.J10 v2(172.37,161) 172.4,161
SEN_B: length 38.9
  TOP w0.127: v2(213.39,121.58) 213.41,121.6 R1323.2 213.41,122.64 213.92,123.16 v1(214.43,123.16) 216.8,123.16 v1(217.05,122.91)
  IN2 w0.14: v1(217.05,143.78) 214.26,143.78 213.32,144.72 v2(213.32,144.93)
  BOTTOM w0.127: U3.J10 213.01,121.2 v2(213.39,121.58) ; U4.J10 213.32,145.13 v2(213.32,144.93) ; v1(217.05,122.91) 218.12,123.97 219.89,123.97 222.21,126.28 222.21,130.25 220.25,132.2 220.25,135.61 221.67,137.03 221.67,140.71 220.66,141.73 220.63,141.73 218.57,143.78 v1(217.05,143.78)
SENSEA: length 4.1
  BOTTOM w0.203: R383.2 209.6,35.26 209.51,35.35 R378.2 209.05,35.32 209.05,34.64 208.79,34.39 v1(208.67,34.39) 208.45,34.6 U23.13
SIO_A20GATE: length 4.8
  BOTTOM w0.127: U45.126 184.78,44.05 185.6,44.88 185.6,46.22 184.97,46.86 TP77.1
SIO_EXT_SCI#: length 127.6
  TOP w0.127: v1(185.98,32.91) 186.54,32.91 187.33,33.7 188.5,33.7 189.62,34.82 v1(189.62,41.75) 189.62,42.03 v1(190.18,42.59) ; v1(173.89,105.1) 172.29,105.1 171.53,105.86 164.81,105.86 162.97,107.69 162.97,109.32 162.68,109.61 162.68,113.11 162.04,113.75 162.04,116.98 157.71,121.3 152.92,121.3 152.08,120.46 152.08,119.92 R781.1 151.81,119.65 R571.1
  IN1 w0.14: v1(190.18,42.59) 190.18,44.32 190.79,44.93 190.79,46.6 193.15,48.97 193.15,53.36 190.69,55.82 184.46,55.82 181.71,58.57 180.85,58.57 179.11,60.31 179.11,61.44 178.11,62.44 178.11,64.58 178.11,65.61 172.82,70.9 172.82,74.36 173.41,74.95 173.41,78.83 172.75,79.49 172.75,80.3 173.39,80.94 173.39,86.79 174.53,87.93 174.53,90.62 173.37,91.78 173.37,99.6 173.58,99.8 173.58,104.78 v1(173.89,105.1)
  BOTTOM w0.127: v1(185.98,32.91) 186.29,32.6 U45.23
SIO_RCIN#: length 97.1
  IN1 w0.14: v1(176.1,36.8) 176.03,36.88 176.03,37.59 176.32,37.88 176.32,38.44 176.32,38.87 176.59,39.14 176.59,40.26 176.87,40.54 176.87,42.6 176.22,43.26 175.48,43.26 174.43,44.31 174.43,47.38 173.82,47.99 173.82,53.18 172.14,54.85 172.14,59.69 171.77,60.07 171.77,63.11 166.51,68.36 166.51,69.66 165.88,70.29 165.88,71.06 165.67,71.26 165.67,72.15 165.35,72.47 165.35,75.61 165.14,75.81 165.14,76.17 165.35,76.38 165.35,77.85 165.21,77.99 165.21,79.65 164.03,80.83 164.03,81.4 161.44,83.99 161.44,84.36 160.3,85.5 v1(160.19,85.5)
  BOTTOM w0.127: U45.4 186.42,40.2 186.19,40.43 186.19,40.74 185.53,41.4 184.36,41.4 180.83,37.87 180.31,37.87 179.68,37.23 178.57,37.23 178.12,36.79 176.12,36.79 v1(176.1,36.8) ; v1(160.19,85.5) 159.11,85.5 156.85,83.24 149.49,83.24 145.67,87.07 143.31,87.07 139.5,90.88 v1(139.5,92.06) R652.1
SLEEVE: length 22
  IN1 w1.016: v1(209.53,32.99) 209.53,32.89 207.99,31.35 207.99,27.52 206.81,26.33 206.81,23.49 208.36,21.94 208.36,17.62 206.71,15.97 206.71,15.63
  BOTTOM w0.203: v1(209.53,32.99) 208.92,32.99 208.54,32.6 U23.18
  vias: v1(205.7,14.4) v1(206.33,14.4) v1(206.99,14.4)
SLEEVE_R:
  vias: v1(208.41,14.4)
SM_RCOMP_0: length 1.4
  TOP w0.381: v2(131.3,105.83) 131.22,105.75 R685.2
  BOTTOM w0.305: v2(131.3,105.83) U35.AR18
SM_RCOMP_1: length 2.5
  TOP w0.381: R678.2 130.36,104.36 v1(130.59,104.59) 131.17,105.18 v2(131.3,105.18)
  BOTTOM w0.305: v2(131.3,105.18) U35.AT18
SM_RCOMP_2: length 1.4
  TOP w0.381: v2(131.3,104.53) 131.3,104.52 R681.2
  BOTTOM w0.305: v2(131.3,104.53) U35.AU18
SMB1ALERT#: length 352
  TOP w0.114: v2(137.64,107.12) 138.14,106.61 138.14,106.23
  TOP w0.127: R205.1 158.53,102.25 157.95,102.84 146.89,102.84 v1(146.69,103.04) 146.49,102.84 145.21,102.84 145.1,102.94 144.17,102.94 143.56,103.56 143.45,103.66 143.18,103.93 141.61,103.93 139.73,105.81 138.56,105.81 138.14,106.23
  IN2 w0.14: v1(49.33,28.42) 49.33,27.96 50.48,26.82 53.27,26.82 55.43,24.66 62.79,24.66 65.08,26.94 67.87,26.94 69.63,28.71 72.52,28.71 76.85,33.04 76.85,39.55 79.79,42.49 84.87,42.49 87.9,39.45 109.14,39.45 110.14,40.46 112.71,40.46 112.99,40.18 112.99,39.52 113.28,39.23 114.63,37.88 127.17,37.88 128.43,36.62 132.59,36.62 133.51,37.54 139.03,37.54 144.43,42.93 148.8,42.93 154.51,48.65 154.51,49.96 153.55,50.92 153.55,62.95 153.21,63.3 153.21,75.77 152.43,76.55 152.43,91.39 153.49,92.44 153.49,94.77 148.93,99.33 142.17,99.33 140.54,100.96 140.54,102.89 138.36,105.07 138.36,105.96 138.14,106.18 138.14,106.89 137.92,107.12 v2(137.64,107.12)
  BOTTOM w0.127: R218.2 U12.1 68.64,111.1 58.27,100.73 49.65,100.73 43.26,94.34 v1(43.26,78.91) 43.26,77.51 43.77,77 44.13,76.64 47.01,76.64 47.82,75.82 47.82,72.89 45.4,70.46 45.4,68.83 31.6,55.04 31.6,43.73 34.33,41 34.33,36.31 34.7,35.94 34.7,29.36 v1(35.52,28.54) 35.85,28.87 46.97,28.87 47.43,28.42 v1(49.33,28.42) ; U35.AM7 137.3,107.45 v2(137.64,107.12)
SMB_ME1_CLK: length 8.1
  BOTTOM w0.076: U35.W3 139.51,114.46 139.66,114.6 140.79,114.6 141.42,113.97 143.46,113.97 143.52,113.91 143.54,113.91
  BOTTOM w0.127: 143.54,113.91 144.29,113.91 144.92,114.54 145.67,114.54 R171.2
SMB_ME1_DAT: length 8.5
  BOTTOM w0.076: U35.V3 139.19,115.02 139.33,115.16 139.35,115.16 139.36,115.17 140.97,115.17 142,114.14 143.46,114.14 143.52,114.19 143.54,114.19
  BOTTOM w0.127: R175.2 145.62,114.76 144.83,114.76 144.26,114.19 143.54,114.19
SMBALERT#: length 5.1
  TOP w0.127: v2(135.83,115.19) 135.94,115.19 136.33,114.8 v1(139.23,114.8) R160.1
  BOTTOM w0.127: v2(135.83,115.19) 135.48,115.54 U35.R10
SML0ALERT#: length 10.2
  BOTTOM w0.127: R586.2 150.07,113.57 145.62,113.57 145.35,113.3 144.1,113.3 143.93,113.47 140.92,113.47 U35.W1
SP1: length 63.3
  TOP w0.114: v1(29.37,26.66) 29.4,26.63 R11254.1
  TOP w0.127: v1(33.33,74.57) 34.11,74.57 34.22,74.46 U15.14
  BOTTOM w0.114: v1(33.33,74.57) 33.05,74.85 31.63,74.85 v1(30.56,73.78) 28.92,72.14 28.92,67.94 28.82,67.84 28.66,67.84 28.56,67.94 28.56,71.44 28.45,71.55 28.29,71.55 28.19,71.44 28.19,66.08 28.46,65.81 28.46,60.13 27.58,59.24 27.58,44.89 27.16,44.47 27.16,42.18 27.79,41.54 27.79,36.1 29.07,34.82 29.07,26.96 v1(29.37,26.66)
SP1=SD_D1: length 5.6
  TOP w0.127: CN4.8 25.74,23.18 26.12,23.57 28.28,23.57 28.62,23.91 C4611.1 R11254.2
SP2: length 63.2
  TOP w0.114: R11253.1 31.31,25.77 v1(30.46,26.61)
  TOP w0.127: v1(33.84,74.11) 33.84,74.09 33.87,74.06 U15.15
  BOTTOM w0.114: v1(30.46,26.61) 29.44,27.64 29.44,34.98 28.17,36.24 28.17,41.68 27.53,42.33 27.53,44.32 27.95,44.74 27.95,59.09 28.83,59.97 28.83,65.96 28.56,66.24 28.56,67.05 29.29,67.79 29.29,71.95 29.39,72.05 29.56,72.05 29.66,71.95 29.66,68.42 29.76,68.32 29.93,68.32 30.03,68.42 v1(30.03,72.44) 30.03,72.6 31.85,74.43 32.85,74.43 33.17,74.11 v1(33.84,74.11)
SP2=SD_D0=MS_D1: length 5.7
  TOP w0.127: R11253.2 C4612.1 30.53,24.12 30.26,23.85 29.32,23.85 28.73,23.26 27.52,23.26 27.37,23.11 CN4.7
SP3: length 67.5
  TOP w0.114: v1(31.63,26.56) 31.76,26.44 R11255.1
  TOP w0.127: U15.16 v1(33.31,73.66)
  BOTTOM w0.114: v1(31.63,26.56) 30.06,28.13 30.06,35.23 28.81,36.48 28.81,37.97 29.09,38.25 30.88,38.25 31.01,38.37 31.01,38.74 30.88,38.87 29.05,38.87 28.94,38.98 28.94,39.38 29.05,39.49 30.88,39.49 31.01,39.62 31.01,39.99 30.88,40.11 29,40.11 28.81,40.3 28.81,40.61 28.94,40.74 29.72,40.74 29.85,40.86 29.85,41.23 29.72,41.36 28.94,41.36 28.81,41.49 28.81,42.27 28.57,42.51 28.57,58.83 29.47,59.73 29.47,65.65 29.67,65.86 30.97,65.86 31.65,66.54 31.65,67.79 31.43,68.02 31.43,68.65 30.65,69.43 30.65,71.06 30.77,71.18 31.86,71.18 31.96,71.28 31.96,71.7 31.86,71.8 30.88,71.8 30.77,71.91 30.77,72.31 30.88,72.42 31.82,72.42 31.93,72.54 v1(31.93,72.89) 31.93,73.63 32.11,73.81 33.16,73.81 v1(33.31,73.66)
SP3=SD_CLK=MS_D0: length 3.2
  TOP w0.114: v1(32.49,27.2) 32.54,27.2 33.16,26.58 R11255.2 33.16,26.14 33,25.98 33,25.76 C4616.1 33,25.33 33,25.09 33.21,24.88 R11141.2
SP4: length 65.6
  TOP w0.114: R11136.1 v1(38.03,25.55) 37.57,25.55 35.97,27.15 33.49,27.15 32.99,27.65 32.99,27.65 32.76,27.88 32.76,28.4 33.12,28.76 33.24,28.76 v1(33.31,28.82)
  TOP w0.127: U15.17 33.9,73.26 33.87,73.24 v1(33.87,73.21)
  BOTTOM w0.114: v1(33.87,73.21) 34.77,72.32 34.77,68.92 34.02,68.17 34.02,65.33 34.33,65.02 34.33,62.35 34.23,62.25 33.81,62.25 33.71,62.35 33.71,64.41 33.6,64.51 33.18,64.51 33.08,64.41 33.08,61.07 30.18,58.16 30.18,43.18 32.62,40.74 32.62,36.16 32.16,35.71 32.16,32.81 32.25,32.72 32.85,32.72 32.95,32.62 32.95,32.2 32.85,32.1 32.4,32.1 32.29,31.99 32.29,31.59 32.4,31.48 32.85,31.48 32.95,31.38 32.95,30.96 32.85,30.86 32.29,30.86 32.16,30.73 32.16,29.71 33.05,28.82 v1(33.31,28.82)
SP4=SD_CMD=MS_D2: length 3.2
  TOP w0.127: CN4.2 39.87,23.41 39.82,23.46 v1(39.82,23.95) C4614.1 R11136.2
SP5: length 66.1
  TOP w0.114: v1(33.2,72.92) 33.36,72.76 34.09,72.76 34.19,72.86 U15.18 ; R11137.1 41.18,25.55 v1(40.95,25.78) 38.96,27.77 33.75,27.77 v1(33.38,28.14)
  BOTTOM w0.114: v1(33.38,28.14) 32.65,28.14 31.48,29.31 31.48,35.94 32,36.46 32,40.48 29.56,42.92 29.56,58.42 31.12,59.99 31.12,63.41 31.24,63.52 31.38,63.52 31.49,63.41 31.49,61.04 31.61,60.93 31.75,60.93 31.86,61.04 31.86,64.97 32.65,65.76 32.65,67.8 34.13,69.29 34.13,69.3 34.14,69.31 34.14,71.98 v1(33.2,72.92)
SP5=SD_D3=MS_D3: length 3.2
  TOP w0.127: CN4.1 42.37,23.89 v1(42.43,23.95) 42.61,24.13 C4613.1 R11137.2
SP6: length 66.2
  TOP w0.114: v1(34.07,28.24) 34.17,28.14 40.72,28.14 43.31,25.55 v1(43.57,25.55) R11138.1 ; v1(32.7,73.32) 32.7,72.66 32.9,72.46 U15.19
  BOTTOM w0.114: v1(34.07,28.24) 34.07,27.96 33.76,27.66 32.48,27.66 30.94,29.19 30.94,36.24 31.63,36.93 31.63,40.33 29.19,42.77 29.19,58.57 30.09,59.47 30.09,64.09 32.28,66.28 32.28,67.95 33.76,69.44 33.76,71.47 32.7,72.54 v1(32.7,73.32)
SP6=SD_D2=MS_CLK: length 3.3
  TOP w0.114: R11138.2 C4615.1 45.15,23.74 44.87,23.46 CN4.9
SP7: length 63.5
  TOP w0.114: v1(36.76,68.57) 36.9,68.72 U15.28 ; R11139.1 26.73,25.67 v1(27.31,26.26) 28.78,27.73 30.38,27.73 32.75,30.09 v1(32.82,30.09)
  BOTTOM w0.114: v1(32.82,30.09) 33.31,30.09 33.8,30.59 33.8,33.24 33.7,33.34 32.9,33.34 32.8,33.45 32.8,33.67 32.9,33.78 33.66,33.78 33.76,33.88 33.76,34.13 33.66,34.23 32.9,34.23 32.78,34.35 32.78,34.55 32.9,34.67 33.66,34.67 33.8,34.81 33.8,35.79 33.59,36 33.59,40.69 30.8,43.48 30.8,57.91 35.03,62.14 35.03,66.9 35.13,67 35.39,67 35.49,66.9 35.49,63.29 35.59,63.19 35.87,63.19 35.97,63.29 35.97,67.79 v1(36.76,68.57)
SP7=SD_WP=MS_BS: length 4.8
  TOP w0.127: R11139.2 v1(26,24.65) 25.7,24.65 24.54,23.49 23.6,23.49 23.29,23.18 CN4.11
SP8: length 64
  TOP w0.114: R11256.1 27.62,25.7 29.14,27.22 v1(29.95,27.22) 30.49,27.22 32.75,29.48 v1(33.31,29.48) ; U15.42 41.96,72.46 41.99,72.44 v1(41.99,72.41)
  BOTTOM w0.114: v1(33.31,29.48) 34.17,30.35 34.17,35.94 33.96,36.15 33.96,40.84 31.17,43.63 31.17,57.75 35.13,61.71 35.27,61.71 35.46,61.52 35.46,61.38 34.02,59.94 34.02,59.78 34.19,59.61 34.35,59.61 36.56,61.82 36.56,63.14 38.94,65.53 38.94,66.77 38.31,67.41 38.31,69.21 39.12,70.02 39.71,70.02 41.99,72.31 41.99,72.41 v1(41.99,72.41)
SP8=SD_CD#: length 4.7
  TOP w0.127: CN4.10 24.44,23.01 25.3,23.87 27.31,23.87 27.62,24.18 R11256.2
SPI_CLK_8M: length 3.9
  TOP w0.127: R684.1 R687.2 181.15,51.57 v1(181.57,51.99)
  BOTTOM w0.127: v1(181.57,51.99) 180.9,51.33 U41.6
SPI_CS0#_UR_ME: length 19.5
  TOP w0.127: R602.1 R591.2 178.53,57.18 178.82,56.89 178.82,55.24 v1(179.03,55.04)
  BOTTOM w0.127: v1(179.03,55.04) 179.03,54.46 177.36,52.79 176.5,52.79 175.93,52.22 175.93,51.36 175.43,50.86 175.43,50.86 172.98,48.41 172.98,46.27 173.16,46.1 173.16,45.23 173.67,44.72 173.89,44.72 174.78,43.84 U45.101
SPI_HOLD_IO3_ME: length 3.6
  TOP w0.127: R698.1 179.19,51.57 v1(179.15,51.53) 179.15,51.24 178.48,50.56 R239.2
  BOTTOM w0.127: v1(179.15,51.53) 179.63,51.05 U41.7
SPI_SI_8M: length 3.1
  TOP w0.127: R654.2 182.84,51.57 v1(182.86,51.56) 182.88,51.57 R691.1
  BOTTOM w0.127: v1(182.86,51.56) 182.84,51.57 182.7,51.57 182.17,51.05 U41.5
SPI_SO_8M: length 4.9
  TOP w0.127: R650.2 R588.2 179.85,57.18 180.12,56.92 v1(180.12,55.85)
  BOTTOM w0.127: v1(180.12,55.85) 179.63,56.33 U41.2
SPI_WP_IO2_ME: length 5
  TOP w0.127: v1(181.57,56) 181.69,56.13 v1(181.69,57.04) 181.56,57.18 R649.2 R589.2
  BOTTOM w0.127: U41.3 180.9,56.66 v1(181.57,56)
SPKR: length 153.2
  TOP w0.127: v1(212.99,40.96) 212.71,40.96 211.64,42.03 208.9,42.03 207.28,43.66 206.54,43.66 205.73,44.46 194.48,44.46 193.94,45.01 193.94,47.31 v1(192.17,49.08) 191.69,49.55 189.59,49.55 189.34,49.8 188.8,49.8 188.07,50.54 183.22,50.54 181.77,49.09 181.77,48.67 181.31,48.22 180.18,48.22 180.08,48.12 175.96,48.12 175.16,48.91 170.14,48.91 168.46,47.24 154.26,47.24 153.04,48.46 153.04,49.45 154.69,51.1 v1(155.43,51.1)
  IN2 w0.14: v1(155.43,51.1) 154.62,51.91 154.62,63.39 154.27,63.74 154.27,65.36 155.02,66.11 155.02,76.51 154.23,77.3 154.23,89.15 155.31,90.23 155.31,94.29 154.84,94.76 154.72,94.76 148.49,100.98 144.96,100.98 144.71,100.73 144.33,100.73 v1(143.82,101.24)
  BOTTOM w0.079: U35.AW5 138.48,103.29 138.85,103.29 139.07,103.06 139.07,102.04 139.16,101.95 139.16,101.39 139.34,101.21 139.34,100.97 139.58,100.73 139.68,100.73
  BOTTOM w0.127: 139.68,100.73 140.06,100.35 143.06,100.35 143.82,101.11 v1(143.82,101.24) 144.25,101.67 144.79,101.67 145.09,101.37 145.09,101.21 145.95,100.35 146.36,100.35 147.12,101.11 147.61,101.11 147.86,100.86 150.05,100.86 R624.1 150.56,99.96 151.19,99.33 R625.2 ; v1(212.99,40.96) 212.99,40 212.27,39.29 D9.2
SRTC_RST#: length 161.9
  TOP w0.127: Q6059.3 150.37,74.8 150.81,74.37 v1(150.81,74.21) ; v1(81.01,49.22) 80.45,49.78 v1(80.45,50.16) 80.45,50.44 80.19,50.69 79.42,50.69 C382.1 R300.2
  IN1 w0.14: v2(131.3,107.1) 131.22,107.1 130.88,106.77 130.88,104.53 130.82,104.46 130.82,103.4 133.17,101.05 133.37,101.05 136.99,97.43 138.41,97.43 140.95,94.89 140.95,93.19 150.63,83.51 150.63,76.65 151.44,75.84 151.44,74.49 151.16,74.21 v1(150.81,74.21)
  IN2 w0.14: v1(81.01,49.22) 81.79,49.22 83.17,47.85 83.17,46.93 82.61,46.37 82.61,44.11 83.34,43.38 85.32,43.38 88.17,40.53 93.14,40.53 95.07,42.46 118.88,42.46 121.26,40.08 122.28,40.08 123.6,38.77 127.88,38.77 128.16,38.49 138.86,38.49 144.1,43.73 148.47,43.73 152.52,47.78 152.52,48.98 151.97,49.52 151.21,49.52 150.96,49.78 150.96,56.71 151.52,57.27 151.52,62.18 151.22,62.47 151.22,63.58 150.81,64 v1(150.81,74.21)
  BOTTOM w0.127: U35.AN18 131,106.8 v2(131.3,107.1)
SSD_ID: length 101.8
  TOP w0.127: v1(149.99,120.97) 149.97,120.97 150.18,121.18 150.18,121.3 150.43,121.56 157.92,121.56 162.33,117.15 162.33,113.82 162.93,113.22 162.93,109.76 163.25,109.44 163.25,107.77 164.91,106.12 171.64,106.12 172.03,105.72 174.22,105.72 v1(174.36,105.59) 174.77,105.18 179.03,105.18 179.2,105.35 v1(179.25,105.35)
  BOTTOM w0.127: v1(179.25,105.35) 179.63,104.97 179.63,104.31 179.99,103.95 180.53,103.41 185.96,103.41 186.34,103.03 192.29,103.03 192.72,102.6 207.44,102.6 208.03,102 213.46,102 213.8,101.66 213.8,100.58 214.7,99.68 219.32,99.68 219.79,99.21 220.48,99.21 220.61,99.08 226.75,99.08 228.05,100.38 233.33,100.38 234.02,99.69 CN9.7 ; v1(149.99,120.97) 149.99,121.31 R568.1
STRAP0: length 13
  BOTTOM w0.127: v1(193.66,109.75) 193.54,109.86 192.48,109.86 R4300.1 192.24,110.1 R4308.2 191.17,110.1 190.63,110.64 190.63,112.39 190.81,112.57 190.81,112.77 190.82,112.77 190.82,115.08 190.68,115.21
  BOTTOM w0.14: 190.68,115.21 189.76,116.14 189.76,118.89 189.33,119.32 U3002.J2
STRAP1: length 17.7
  TOP w0.127: v1(189.73,122.4) 189.92,122.4 190.71,121.61 190.71,119.52 191.54,118.68 192.85,118.68 196.78,114.75 v1(196.78,113.33) 196.78,111.9 R4309.2 R4301.1
  BOTTOM w0.14: v1(189.73,122.4) 189.73,123.23 U3002.J7
STRAP2: length 17.3
  TOP w0.127: R4302.1 R4310.2 195.83,111.83 195.83,112.73 195.83,112.74 195.83,113.11 196.27,113.55 v1(196.27,114.57) 196.27,114.78 192.69,118.36 191.47,118.36 190.43,119.4 190.43,121.49 189.96,121.96 189.35,121.96 v1(188.93,122.39)
  BOTTOM w0.14: U3002.J6 v1(188.93,122.39)
STRAP3: length 13.1
  TOP w0.127: v1(188.88,121.54) 188.92,121.54 189.41,121.05 189.41,120.36 189.29,120.24 189.29,119.27 189.79,118.76 189.79,114.35 190.05,114.09 v1(190.05,113.43) 190.05,113.42 189.46,112.84 189.46,111.95 R4311.2 R4303.1
  BOTTOM w0.102: U3002.J5 188.93,121.54 v1(188.88,121.54)
STRAP4: length 11.3
  BOTTOM w0.127: R4304.1 R4312.2
  BOTTOM w0.14: U3002.J3 188.93,119.95 188.93,118.48 189.19,118.23 189.19,115.29 v1(189.66,114.82) 189.99,114.48 189.99,113.75 189.46,113.22 189.46,111.95 R4312.2
SUSACK#_R: length 24.8
  TOP w0.127: v1(144.07,100.32) 144.66,99.74 148.6,99.74 148.8,99.54 151.95,99.54 153.04,100.63 TP4368.1
  IN1 w0.14: v1(144.07,100.32) 143.59,99.84 138.23,99.84 135.69,102.38 135.69,104.06 135.39,104.36 135.39,105.68 135.2,105.87 v2(134.95,105.87)
  BOTTOM w0.127: v2(134.95,105.87) 134.67,106.15 U35.AP11
SUSB#: length 482.3
  TOP w0.076: 134.37,103.22 134.39,103.23 134.39,105.49 v2(134.04,105.84)
  TOP w0.127: v1(166.85,90.36) 165.66,89.17 165.66,88.58 164.62,87.54 164.62,84.45 166.96,82.11 166.96,80.59 v1(167.21,80.33) 167.21,79.7 169.55,77.36 170.73,77.36 171.28,76.81 171.28,75.56 171.68,75.15 171.68,70.61 168.47,67.39 164.92,67.39 164.53,67 163.5,67 163.1,67.4 162.1,67.4 159.11,70.38 156.34,70.38 156.16,70.2 153.61,70.2 153.36,70.45 144.51,70.45 143.69,71.27 143.69,75.56 146.13,78 146.13,84.91 143.39,87.65 143.09,87.65 140.9,89.83 139.32,89.83 136.14,93.01 136.14,98.25 134.36,100.03 134.36,102.29 134.37,102.31 134.37,103.22 ; v1(178.77,34.41) 178.77,34.28 v1(179.41,33.65) 180.4,32.66 182.28,32.66 183.42,31.52 184.84,31.52 185.38,30.98 v1(185.86,30.98) ; v1(38.69,53.31) 38.68,53.3 38.06,53.3 37.65,52.88 37.65,52.34 37.39,52.09 PQ6057.2 36.63,52.27 v1(35.59,53.31)
  IN1 w0.14: v1(167.21,80.33) 167.78,79.77 167.78,77.04 167.78,75.22 168.14,74.86 168.14,72.09 168.92,71.32 168.92,69.77 172.93,65.76 172.93,64.94 173.55,64.33 173.55,64.33 173.95,63.93 173.95,61.08 174.34,60.69 174.34,56.3 174.93,55.71 174.93,55.52 176.04,54.41 176.04,54.41 176.31,54.14 176.31,54.13 177.42,53.03 177.42,50.82 178.34,49.89 178.34,46.63 179.52,45.45 179.52,44.17 179.2,43.86 v1(179.2,41.4) 179.29,41.31 179.29,34.93 v1(178.77,34.41) 178.44,34.08 175.06,34.08 171.81,30.83 168.74,30.83 168.03,30.12 159.26,30.12 158.36,31.02 v1(158.21,31.02) 156.74,31.02 148.16,22.45 139.63,22.45 138.63,23.45 125.29,23.45 123.86,22.02 117.59,22.02 113.65,25.95 107.12,25.95 104.53,28.54 88.88,28.54 81.11,20.77 72.27,20.77 67.76,16.26 61.01,16.26 60.1,17.17 44.49,17.17 43.73,17.93 39.55,17.93 37.37,20.11 37.37,27.81 38.58,29.02 38.58,41.36 39.33,42.11 39.33,42.86 39.39,42.92 39.39,52.61 v1(38.69,53.31) ; v1(87.56,126.64) 84.77,126.64 64.19,106.06 50.76,106.06 46.41,101.72 46.41,84.75 45.56,83.9 45.56,80.24 48.24,77.56 48.24,70.32 48,70.07 47.3,70.07 43.72,66.49 42.32,66.49 36.05,60.22 36.05,53.77 v1(35.59,53.31)
  IN2 w0.14: v1(185.86,30.98) 186.42,30.98 187.84,32.4 190.51,32.4 v1(190.58,32.48)
  BOTTOM w0.127: U35.AP15 132.98,105.84 v2(134.04,105.84) ; v1(179.2,41.4) 179.41,41.19 180.55,41.19 181.46,42.11 181.82,42.11 181.98,42.27 U45.119 ; U49.2 192.72,35.45 192.44,35.17 192.44,32.3 192.21,32.07 190.99,32.07 v1(190.58,32.48) ; v1(166.85,90.36) 166.17,91.04 R282.2 ; U50.2 157.61,31.48 158.07,31.02 v1(158.21,31.02) ; U47.2 v1(87.56,126.64)
SUSC#: length 140.2
  TOP w0.127: v1(175.83,57.53) 174.89,56.58 174.89,52.42 175.47,51.84 v1(176.23,51.84) v1(176.92,51.84)
  IN1 w0.14: v1(178.82,36.14) 178.71,36.25 178.71,37.2 178.72,37.21 178.72,43.45 177.92,44.26 177.92,49.92 176.92,50.92 v1(176.92,51.84) ; v1(175.83,57.53) 176.31,58.01 176.31,58.74 177.58,60.01 177.58,61.39 176.99,61.98 176.99,65.15 171.7,70.43 171.7,75.02 172.25,75.57 172.25,78.41 171.38,79.28 171.38,80.84 170.5,81.73 170.36,81.87 170.36,82.89 168.85,84.4 168.85,86.14 v1(168.45,86.53) 168.45,86.81 170.26,88.62 170.26,88.62 170.9,89.25 170.9,92.61 170.44,93.07 168.33,93.07 v1(168.28,93.11)
  BOTTOM w0.079: 131.64,100.59 131.64,100.72 131.69,100.76 131.69,101.35 131.64,101.4 U35.BA16
  BOTTOM w0.127: v1(175.83,57.53) 175.6,57.53 173.92,55.85 173.92,54.43 174.5,53.84 U48.2 ; U45.18 182.56,34.6 181.07,36.09 178.87,36.09 v1(178.82,36.14) ; v1(168.28,93.11) 167.19,92.02 167.19,90.69 R274.2 ; 131.64,100.59 131.63,100.58 131.63,99.97 133.42,98.18 133.68,98.18 136.07,95.79 136.07,94.63 136.58,94.13 136.58,91.43 142.5,85.52 145.02,85.52 148.82,81.72 158.04,81.72 159.51,83.18 167.39,83.18 167.72,83.51 167.72,83.88 167.44,84.15 167.44,85.52 v1(168.45,86.53)
SUSCLK: length 235.5
  TOP w0.127: R11279.2 139.25,74.56 143.61,70.2 153.25,70.2 153.51,69.95 156.27,69.95 156.44,70.12 159.01,70.12 161.99,67.14 163,67.14 163.39,66.75 164.63,66.75 165.03,67.14 168.65,67.14 169.35,67.84 172.9,67.84 173.12,67.62 182.9,67.62 185.35,65.17 185.35,64.46 186.32,63.49 188.93,63.49 190.14,62.29 190.14,61.35 191.08,60.41 194.68,60.41 v1(195.48,59.61) 195.99,59.1 195.99,58.1 197.27,56.83 208.35,56.83 v1(208.67,57.14)
  IN2 w0.14: v1(208.67,57.14) 208.71,57.18 208.71,58.74 209.46,59.49 209.46,61.32 210.11,61.97 210.11,63.11 211.05,64.05 211.05,66.49 211.99,67.43 211.99,82.24 210.9,83.33 210.9,102 212.45,103.55 212.45,105.66 214.31,107.51 218,107.51 220.92,110.43 220.92,142.76 220.52,143.16 220.52,145.25 220.88,145.61 220.88,154.72 218.89,156.71 208.84,156.71 202.26,163.29 202.26,167.92 201.62,168.56 201.62,172.07 201.73,172.17 201.73,177.2 202.35,177.82 v1(202.62,177.82)
  BOTTOM w0.127: 202.24,183.92 U43.2 ; 202.24,183.92 202.11,183.92 201.99,183.79 201.99,182.9 202.85,182.04 202.85,179.75 202.98,179.62 202.98,178.18 v1(202.62,177.82) ; 202.24,183.92 201.99,184.17 201.99,184.93 202.11,185.06 202.75,185.06 202.88,185.19 R716.2
SUSCLK_R: length 39.1
  TOP w0.127: v1(133.41,97.56) 135.89,95.07 135.89,92.91 139.21,89.58 140.8,89.58 142.98,87.4 143.29,87.4 145.88,84.81 145.88,81.73 139.49,75.34 v1(137.55,75.34) R11279.1
  BOTTOM w0.079: 131.17,100.68 131.17,100.76 131.34,100.93 131.34,101.24 131.07,101.51 U35.BA17
  BOTTOM w0.127: v1(133.41,97.56) 133.41,97.61 131.17,99.85 131.17,100.68
SUSD: length 11.1
  TOP w0.381: v1(75.11,101.52) 74.33,100.73 v1(70.67,100.73) PC101.2 69.69,101.15 70.11,101.57 PQ8.3 68.59,102.13 68.4,102.32 PR142.2
  BOTTOM w0.381: 75.11,100.48 v1(75.11,101.52)
SUSLED#: length 163.3
  TOP w0.127: v1(61.19,11.27) 60.43,12.03 55.68,12.03 55.25,12.47 55.25,14.9 56.6,16.25 56.6,17.83 56.04,18.38 v1(56.04,18.71) 56.04,20.14 55.82,20.36 R427.1 R433.1
  IN2 w0.14: v1(184.56,31.06) 183.74,31.06 183.59,31.21 182.48,31.21 181.84,31.85 175.4,31.85 169.16,25.6 163.23,25.6 158.86,21.23 154.93,21.23 152.84,21.23 151.82,20.21 141.66,20.21 139.45,22.42 135.49,22.42 134.8,21.74 126.73,21.74 124.72,19.73 112.12,19.73 102.77,29.08 89.5,29.08 82,21.57 78.73,21.57 77.29,20.13 73.59,20.13 71.3,17.85 71.3,16.26 66.29,11.25 64.17,11.25 63.4,12.01 61.93,12.01 v1(61.19,11.27)
  BOTTOM w0.127: v1(184.56,31.06) 184.64,31.06 185.24,30.45 186.19,30.45 186.34,30.6 U45.28
SUSON: length 37.4
  IN1 w0.14: v1(182.17,46.73) 182.33,46.58 182.33,42.97 v1(180.09,40.74)
  BOTTOM w0.127: v1(182.17,46.73) 182.17,47.05 R739.1 181.78,47.43 181.41,47.81 181.41,47.82 181.3,47.93 181.29,47.93 181.29,48.43 181.57,48.71 181.57,49.22 181.49,49.3 181.49,51.15 182.45,52.12 182.45,54.48 183.39,55.42 v1(183.39,56.18) 182.68,56.18 181.67,55.16 179.63,55.16 179.25,55.54 178.9,55.54 178.49,55.13 178.49,54.28 177.25,53.04 176.4,53.04 175.66,52.31 175.25,52.31 175.15,52.21 U48.1 175.15,50.94 174.79,50.58 172.96,50.58 172.47,51.07 R790.2 ; v1(180.09,40.74) 180.12,40.76 180.48,40.76 181.57,41.85 181.95,41.85 182.38,42.29 U45.120
SUSON_R: length 284.2
  TOP w0.127: PQ6.2 73.84,106.19 v1(72.9,106.19) ; v1(44.46,52.16) 44.39,52.16 44.27,52.28 44.27,52.77 PR263.2 ; v1(45.55,62.94) 45.78,62.94 46.41,62.31 PR304.2
  IN1 w0.14: v1(45.55,62.94) 45.55,63.42 44.88,64.09 43.01,64.09 38.31,59.39 38.31,54.35 39.67,52.98 39.67,40.88 40,40.55 40,38.65 v1(39.5,38.15) ; v1(169.14,52.72) 166.14,49.72 166.14,46.37 164.59,44.82 164.25,44.82 160.53,41.09 160.53,40.65 157.69,37.81 157.56,37.81 154.97,35.23 154.09,35.23 150.01,31.15 146.53,31.15 144.2,28.82 128.06,28.82 127.67,28.82 124.45,32.04 113.01,32.04 112.65,31.67 107.58,31.67 106.27,32.98 105.29,32.98 105.28,33 86.78,33 79.1,25.32 62.64,25.32 60.76,23.44 53.98,23.44 52.91,24.51 48.85,24.51 43.77,29.59 43.77,32.73 44.51,33.47 44.51,34.26 43.36,35.4 43.36,35.96 v1(43.47,36.06)
  IN2 w0.14: v1(72.9,106.19) 70.87,104.16 51.95,104.16 50.32,102.53 50.32,100.02 47.96,97.66 47.96,88.95 51.95,84.97 51.95,83.05 51.33,82.43 51.33,69.96 46.05,64.69 46.05,63.44 v1(45.55,62.94) ; v1(43.47,36.06) 41.59,36.06 v1(39.5,38.15)
  BOTTOM w0.127: v1(169.14,52.72) 169.14,53.11 169.27,53.23 v1(171.63,53.23) 172.02,53.23 R790.1 172.77,52.78 173.01,52.55 173.77,52.55 173.85,52.63 U48.4 ; v1(45.55,62.94) 45.55,62.41 45.07,61.93 42.64,61.93 41.4,60.7 41.4,57.42 41.72,57.11 41.72,56.38 41.5,56.16 41.5,54.63 43.02,53.12 43.5,53.12 v1(44.46,52.16)
SYS_HWPG: length 201.6
  TOP w0.127: v1(56.09,43.12) 55.89,43.12 55.73,42.97 PR6283.2
  IN1 w0.14: v1(37.8,38.25) 37.98,38.07 37.98,31.41 37.12,30.55 37.12,29.17 36.38,28.44 36.38,19.2 38.92,16.66 40.63,16.66 41.98,15.31 48.11,15.31 48.62,14.8 54.26,14.8 54.59,15.13 59.32,15.13 59.58,14.87 68.45,14.87 72.14,18.56 81.16,18.56 89.67,27.07 104.1,27.07 108.27,22.89 109.52,22.89 112.38,20.03 126.25,20.03 126.36,20.14 150.63,20.14 150.94,19.83 152.97,19.83 154.83,21.69 154.95,21.69 v1(158.04,24.78)
  BOTTOM w0.127: v1(37.8,38.25) v1(38.36,38.81) 39.12,39.57 50.83,39.57 51.67,40.41 52.36,40.41 53.63,41.68 57.26,41.68 57.66,42.08 57.66,42.39 56.83,43.23 56.19,43.23 v1(56.09,43.12) ; D4012.1 157.05,25.78 v1(158.04,24.78) 158.07,24.76 158.32,24.76 158.48,24.91 165.13,24.91 165.41,25.19 165.41,28.14 165.03,28.52 165.03,28.95 165.41,29.33 165.41,31.96 165.39,31.97 165.39,32.44 165.98,33.02 167.15,33.02 167.93,33.8 U45.77
SYS_PEX_RST_MON#: length 48.9
  TOP w0.127: v1(214.58,108.55) v1(213.57,108.55) 211.77,108.55 210.95,109.37 v1(210.95,109.72)
  BOTTOM w0.102: 188.78,117.11 188.27,117.62 188.27,119.15 188.02,119.4 188.02,119.91 187.63,120.3 U3002.L3
  BOTTOM w0.127: 188.78,117.11 188.78,115.34 188.91,115.21 R4321.1 188.53,114.58 188.46,114.51 188.46,108.82 188.99,108.29 190.11,108.29 190.38,108.56 194.19,108.56 194.98,107.77 194.98,107.56 196.68,105.86 196.68,105.02 197.14,104.57 200.69,104.57 200.69,104.54 206.2,104.54 206.94,105.28 206.94,108.22 208.44,109.72 v1(210.95,109.72) ; U4002.2 215.59,106.69 215.19,107.08 215.19,107.6 214.97,107.83 R11108.2 v1(214.58,108.55)
SYS_PWROK: length 166.8
  TOP w0.127: R113.1 185.14,35.01 184.71,34.59 v1(184.13,34.59) 183.3,34.59 182.68,35.2 182.68,35.68 182.35,36.01 182.35,36.44 182.19,36.61 U8.4 181.31,36.61 181.18,36.75 R560.1 181.18,38.01 181.36,38.19 181.36,38.19 181.47,38.31 181.47,38.31 181.69,38.53 v1(182.86,38.53)
  IN1 w0.14: v1(183.97,49.19) 183.97,47.2 185.17,46 185.17,41.91 182.86,39.6 v1(182.86,38.53)
  IN2 w0.14: v1(151.29,120.92) 152.11,121.75 156.25,121.75 157.26,120.75 159.73,120.75 163.08,117.4 163.78,116.69 168.2,112.27 168.2,111.81 168.76,111.25 169.09,111.25 172.85,107.49 172.85,101.82 173.45,101.22 173.45,91.72 174.22,90.96 174.22,82.2 173.21,81.19 v1(173.21,79.68) 173.2,79.68 173.2,69.49 178.91,63.79 179.73,63.79 182.23,61.29 182.23,59.81 183.97,58.07 v1(183.97,49.19)
  BOTTOM w0.127: R556.1 149.15,122.96 151.19,120.92 v1(151.29,120.92) ; R643.1 132.9,94.61 133.1,94.41 133.1,92.07 145.23,79.94 159.24,79.94 160.24,80.94 162.48,80.94 163.76,82.21 167.04,82.21 168.81,80.44 171.41,80.44 172.17,79.68 v1(173.21,79.68)
SYS_PWROK_R: length 13.4
  BOTTOM w0.076: 139.25,124.48 138.87,124.48 138.23,123.85 138.23,123.01 U35.B6
  BOTTOM w0.127: R556.2 R131.1 147.5,123.97 147.39,124.09 147.39,124.24 146.86,124.76 v1(146.56,124.76) 146.39,124.76 145.97,124.34 R555.1 145.84,123.84 142.55,123.84 142.13,124.26 141.17,124.26 140.95,124.48 139.25,124.48
SYS_RESET#: length 58.8
  TOP w0.127: R267.2 173.16,99.46 v1(172.98,99.64) v1(172.42,100.2) ; v1(171.86,115.46) v1(169.81,115.46) 169.17,115.46 168.81,115.82 164.93,115.82 158.35,122.4 147.96,122.4 147.35,121.79 v1(147.35,121.69)
  IN1 w0.14: v1(172.42,100.2) 172.47,100.25 172.47,108.45 174.28,110.26 174.28,114.68 172.95,116 172.27,116 171.86,115.59 v1(171.86,115.46)
  BOTTOM w0.076: 141.61,122.78 141.24,122.4 140.65,122.4 140.57,122.49 140.48,122.57 140.48,122.72 140.31,122.9 140.07,122.9 140,122.97 140,123.21 139.88,123.32 139.88,123.34 139.83,123.39 139.43,123.39 139.35,123.31 138.8,123.31 U35.B5
  BOTTOM w0.127: 141.61,122.78 142.09,123.26 144.91,123.26 145.46,122.71 R561.2 145.46,122.26 145.68,122.04 146.12,122.04 147,122.04 v1(147.35,121.69)
SYS_SHDN#: length 345.7
  TOP w0.127: PR6278.2 53.22,34.31 v1(53.52,34.01)
  TOP w0.203: v1(53.85,42.16) 53.83,42.13 53.83,41.83 53.21,41.21 PU6010.6
  TOP w0.254: v1(47.94,106.9) v1(47.12,106.9) 46.46,106.9 PQ14.3
  IN1 w0.14: v1(98.58,135.63) 98.08,135.63 89.59,127.15 84.77,127.15 66.17,108.55 50.35,108.55 48.7,106.9 v1(47.94,106.9) 46.03,105 46.03,84.77 45.28,84.02 45.28,80.13 47.94,77.47 47.94,71.59 46.92,70.57 46.92,70.09 43.6,66.77 42.21,66.77 35.77,60.33 35.77,57.36 34.37,55.96 34.37,53.67 35.72,52.32 35.72,51.1 v1(35.87,50.95)
  IN2 w0.14: v1(53.52,34.01) 53.3,34.23 53.3,37.64 53.83,38.17 53.83,42.13 v1(53.85,42.16) ; v1(176.51,37.33) 175.95,37.33 174.35,35.73 172.96,35.73 170.83,33.6 170.83,33.08 169.78,32.02 168.11,32.02 166.18,30.1 159.17,30.1 153.92,24.85 151.67,24.85 151.25,24.43 125.24,24.43 122.95,22.14 113.51,22.14 111.21,24.44 111.21,25.16 109.99,26.37 109.04,26.37 108.62,26.79 108.62,28.23 106.1,30.75 88.79,30.75 81.29,23.25 78.02,23.25 76.58,21.81 72.85,21.81 69.58,18.54 69.58,16.95 66.59,13.96 61.03,13.96 58.97,11.91 55.28,11.91 54.06,13.13 v1(53.73,13.13)
  BOTTOM w0.127: U45.2 186.28,41 185.65,41.63 184.25,41.63 180.84,38.22 179.94,38.22 179.94,38.22 179.46,37.74 178.36,37.74 177.91,37.29 176.55,37.29 v1(176.51,37.33) ; v1(98.58,135.63) 98.71,135.5 Q5.3 ; v1(53.73,13.13) 53.73,13.18 54.57,14.02 54.57,20.04 53.52,21.08 v1(53.52,34.01)
  BOTTOM w0.203: v1(53.85,42.16) 53.7,42.01 53.12,42.01 52.86,41.75 49.23,41.75 48.77,41.29 43.21,41.29 36.96,47.54 36.96,49.85 v1(35.87,50.95)
  BOTTOM w0.206: v1(53.85,42.16) 55.14,42.16 PR6280.2
SYSTEM_AGND: length 3.4
  TOP w0.508: v3(57.21,37.48) 57.46,37.48 57.97,36.98 57.97,36.42 57.64,36.09 56.58,36.09 PR6124.2
  vias: v1(56.09,40.58)
TEMP_MBAT#: length 307.3
  TOP w0.305: PR12.1 152.58,177.95 v1(153.17,177.37) 153.17,177.11 153.42,176.85 153.42,174.04 154.17,173.29 PR9.1 154.41,173.16 154.41,172.61 154.31,172.51 154.31,172.23 v1(154.29,172.21) 154.31,172.18 154.31,172.13 155.25,171.19 155.25,170.4 155.77,169.89 PR8.2
  IN2 w0.14: v1(176.13,34.72) 176.26,34.58 178.29,34.58 178.58,34.87 180.15,34.87 180.43,35.16 184.14,35.16 184.44,34.87 185.28,34.87 190.95,40.53 199.26,40.53 201.05,38.74 205.2,38.74 205.49,39.03 206.92,39.03 208.79,40.9 209.37,40.9 215.25,46.77 215.25,51.2 215.4,51.36 215.4,52.16 214.67,52.89 214.67,55.13 214.43,55.38 213.8,56 213.8,58.37 214.43,58.99 214.43,59.99 216.18,61.74 216.18,64.25 217.62,65.69 217.62,67.24 220.17,69.79 220.17,86.46 217.63,89 217.63,95.64 224.4,102.41 225.23,102.41 229.57,106.74 229.57,111.37 227.53,113.41 227.53,158.68 224.47,161.74 224.47,166.71 231.66,173.9 231.66,180.84 231.66,180.84 231.66,181.5 231.66,181.51 231.66,186.33 228.45,189.53 212.55,189.53 206.86,183.84 205.92,183.84 205.42,184.34 204,184.34 203.44,184.91 200.56,184.91 196.55,180.89 193.35,180.89 188.78,176.32 180.93,176.32 179.09,174.48 159.29,174.48 157.95,173.15 155.18,173.15 154.29,172.25 v1(154.29,172.21)
  BOTTOM w0.127: v1(176.13,34.72) 176.56,34.28 176.56,31.21 175.7,30.35 174.92,30.35 173.07,32.2 U45.73
TERM9:
  vias: v1(25.51,89.55) v3(25.28,94.15) v3(25.28,93.11)
TESTMODE: length 3.4
  TOP w0.127: v1(171.33,125.75) 170.85,126.23 170.19,126.23 169.88,125.93 R4011.1
  BOTTOM w0.127: U3002.AK11 171.33,126.64 v1(171.33,125.75)
TH_FAN_POWER:
  vias: v1(63.55,117.73)
THRMTRIP#: length 7.2
  BOTTOM w0.127: R530.1 100.01,130.2 v1(99.55,130.66) 99.55,131.05 99.56,131.05 99.75,131.24 99.75,133.29 99.51,133.53 99.51,133.53 99.38,133.67 R488.1 100.46,134.11 100.84,134.49 Q5.1
TP_INT:
  vias: v1(130.03,180.54) v1(130.38,180) v1(130.54,180.94)
TP_INT_PCH: length 137.1
  TOP w0.127: v1(132.29,179.5) 132.49,179.29 Q1.3 131.48,178.45 131.1,178.07 131.1,177.31 131.35,177.06 v1(131.78,177.06)
  IN1 w0.14: v1(131.78,177.06) 131.63,176.91 130.84,176.91 128.25,174.31 128.25,173.71 129.11,172.84 130.56,172.84 130.99,172.41 130.99,171.44 132.21,170.23 132.21,168.98 131.04,167.81 127.44,167.81 124.31,164.69 118.52,164.69 117.68,163.84 117.67,163.84 117.62,163.79 116.07,163.79 115.12,162.84 115.12,159.33 115.4,159.05 115.4,158.41 115.2,158.21 115.2,148.28 118.5,144.98 123.04,144.98 126.12,141.9 126.12,139.92 127.77,138.27 138.94,138.27 141.08,136.14 145.04,136.14 v1(145.88,136.98)
  BOTTOM w0.076: U35.AB3 139.78,112.51 140.05,112.51 140.18,112.64 142.07,112.64
  BOTTOM w0.127: v1(145.88,136.98) 146.26,136.6 146.26,134.18 151.69,128.75 151.69,123.46 155.16,120 155.16,117.34 156.88,115.62 156.88,112.74 155.91,111.78 151.62,111.78 150.35,113.05 145.68,113.05 145.42,112.8 145.42,112.36 145.22,112.16 142.55,112.16 142.07,112.64 ; R8.1 132.77,179.95 132.31,179.5 v1(132.29,179.5)
TP_PWR:
  vias: v1(117.66,171.65) v1(118.32,171.5) v1(118.7,170.94) v1(118.98,171.62)
TP_RST#: length 1.5
  BOTTOM w0.127: CN5.29 120.65,169.23 120.79,169.23 R444.1
TPCLK: length 64.9
  IN2 w0.14: v1(119.95,25.04) 120.16,25.25 120.16,25.67 120.71,26.22 125.97,26.22 126.38,26.63 152.75,26.63 158.38,32.25 164.32,32.25 165.18,33.12 167.03,33.12 167.82,33.9 168.28,33.9 169.42,35.05 170.13,35.05 173.22,38.14 173.22,38.38 173.04,38.56 172.83,38.56 172.82,38.57 v1(172.7,38.45)
  BOTTOM w0.127: v1(172.7,38.45) 172.5,38.65 172.35,38.65 172.29,38.6 U45.89 ; R411.1 119.63,21.77 R415.2 119.93,22.77 120.12,22.96 120.12,24.86 v1(119.95,25.04)
TPCLK_R: length 5.1
  BOTTOM w0.127: R411.2 119.66,19.84 C787.2 120.14,19.36 120.14,18.95 120.36,18.73 120.36,17.51 120,17.15 CN17.7
TPD_EN: length 71.6
  IN1 w0.14: v1(125.81,26.77) 126.02,26.56 146.22,26.56 154.33,34.67 156.76,34.67 158.93,36.85 161.25,36.85 163.16,34.93 166.92,34.93 167.23,35.25 167.74,35.25 169.72,37.23 170.2,37.23 171.05,38.08 171.05,41.17 170.41,41.8 v1(170.41,44.23)
  BOTTOM w0.127: CN17.1 126,21.22 126.28,21.5 126.28,22.57 125.81,23.03 v1(125.81,26.77) ; v1(170.41,44.23) 170.4,44.24 170.36,44.24 170.01,44.6 170.01,44.91 169.94,44.97 169.94,45.5 v1(170.24,45.79) 170.42,45.98 R190.2
TPD_INT#: length 188.7
  TOP w0.127: v1(170.39,45.16) 170.41,45.16 170.49,45.08 173.31,45.08 175.33,43.06 175.58,43.06 175.61,43.03 181.91,43.03 182.18,42.77 185.83,42.77 v1(186.21,42.39) 186.67,42.39 188.19,43.91 188.58,43.91 v1(189.19,44.52) 189.26,44.6 189.26,45.38 v1(189.64,45.77)
  IN1 w0.14: v1(125.5,21.84) 125.76,21.84 150.65,21.84 158.07,29.26 166.55,29.26 167.67,28.14 170.77,28.14 175.6,32.96 182.38,32.96 182.99,33.57 182.99,34.59 186.21,37.82 v1(186.21,42.39)
  IN2 w0.14: v1(156.37,114.65) 158.5,114.65 163.68,109.47 163.68,108.38 166.81,105.25 166.81,105.23 167.21,104.83 167.21,103.94 167.3,103.85 167.3,91.05 167.25,90.99 167.25,90.57 167.28,90.54 167.28,89.86 167.28,89.86 167.28,89.51 167.1,89.32 167.1,86.15 166.8,85.85 166.8,84.87 166.02,84.09 166.02,82.29 166.31,82 166.31,79.63 166.4,79.54 166.4,78 165.94,77.54 165.94,76.35 166.15,76.14 166.15,70.46 166.45,70.17 166.45,67.35 172.32,61.48 172.32,60.49 172.8,60.01 172.8,54.81 172.49,54.5 172.49,50.74 171.26,49.5 171.26,46.03 v1(170.39,45.16)
  BOTTOM w0.127: v1(189.64,45.77) 189.08,45.21 R349.2 ; R164.1 154.07,112.41 154.16,112.49 Q20.1 156.37,113.66 v1(156.37,114.65) ; v1(125.5,21.84) 125,21.34 CN17.2
TPD_INT#_D: length 17.1
  BOTTOM w0.076: 142.8,113.25 139.18,113.25 139.03,113.41 U35.W4
  BOTTOM w0.127: v1(152.94,114.78) 152.94,113.76 153.17,113.53 Q20.3 152.43,113.51 152.11,113.19 R164.2 151.77,113.56 151.43,113.9 151.43,114.04 R177.1 150.66,113.31 145.64,113.31 145.42,113.09 143.15,113.09 142.98,113.25 142.8,113.25
TPDATA: length 65.4
  IN2 w0.14: v1(120.63,25.01) 120.45,25.19 120.45,25.55 120.83,25.93 126.09,25.93 126.5,26.33 152.87,26.33 158.5,31.96 164.44,31.96 165.3,32.82 167.15,32.82 167.94,33.61 168.4,33.61 169.55,34.75 170.25,34.75 173.51,38.02 173.51,38.5 173.16,38.86 172.95,38.86 v1(172.7,39.11)
  BOTTOM w0.127: R412.1 120.9,21.77 R416.2 120.62,22.77 120.4,22.99 120.4,24.78 v1(120.63,25.01) ; U45.90 172.4,39 172.46,38.93 172.52,38.93 v1(172.7,39.11)
TPDATA_R: length 5.1
  BOTTOM w0.127: R412.2 120.93,19.84 C788.2 120.42,19.33 120.42,19.06 120.64,18.85 120.64,17.51 121,17.15 CN17.6
TPM_BADD: length 3
  BOTTOM w0.127: U44.6 165.12,68.56 v1(165.22,68.46) 165.31,68.37 166.25,68.37 166.55,68.07 R729.2
TPM_CLKRUN#: length 1.2
  BOTTOM w0.127: U44.13 162.66,72.46 162.65,72.47 R743.1
TPM_LRESET#: length 1.5
  BOTTOM w0.127: R742.2 164.12,76.29 U44.17
TPM_PP: length 4.5
  BOTTOM w0.127: TP4358.1 166.85,66.51 166.88,66.51 166.99,66.62 166.99,68.04 166.96,68.07 166.96,68.09 166.12,68.93 U44.4
TS_EN: length 322.3
  TOP w0.127: v1(131.1,179.45) v1(129.24,179.45) 129.2,179.45 R442.1
  IN2 w0.14: v1(191.01,29.15) 191.97,30.11 191.97,32.7 195.05,35.78 200.48,35.78 201.1,36.41 203.61,36.41 204.05,35.97 206.61,35.97 206.73,36.09 207.68,36.09 208.06,36.47 209.23,36.47 210.09,37.33 211.36,37.33 212.25,38.22 214.99,38.22 217.25,40.48 217.25,47.55 221.43,51.73 222.79,51.73 224.77,53.72 224.77,60.76 220.07,65.46 220.07,65.83 222.26,68.01 222.26,80.46 225.79,83.99 227.13,83.99 233.1,89.96 233.1,105.07 231.78,106.4 231.78,113.35 229.84,115.3 229.84,159.54 226.75,162.63 226.75,166.11 233.71,173.07 233.71,189.29 233.07,189.93 229.53,193.47 206.64,193.47 205.63,192.46 202.18,192.46 197.98,188.26 196.63,188.26 193.12,184.75 193.05,184.75 190.13,181.83 184.84,181.83 184.39,181.39 179.65,181.39 177.6,183.44 177.6,184.64 176.34,185.9 168.31,185.9 165.23,188.97 140.2,188.97 138.49,187.26 138.49,186.07 134.73,182.31 134.73,181.55 133.18,180 131.65,180 v1(131.1,179.45)
  BOTTOM w0.127: v1(191.01,29.15) 190.97,29.12 R751.1 ; R443.1 131.67,180.02 v1(131.1,179.45)
TS_EN_C: length 4.8
  BOTTOM w0.127: U45.32 187.89,29 188.14,28.75 v1(188.14,28.26) 188.67,28.26 188.81,28.4 189.59,28.4 189.59,28.41 189.72,28.41 189.84,28.52 189.84,28.74 189.95,28.85 C800.1 190.18,27.99 R751.2
TS_EN_R: length 3.4
  TOP w0.127: v1(127.81,178.09) R442.2 127.81,179.28 v1(127.51,179.57)
  BOTTOM w0.127: v1(127.51,179.57) 127.51,178.64 CN5.6
TST: length 3.4
  TOP w0.178: U9.22 v1(28.15,119.4)
  BOTTOM w0.508: v1(28.15,119.4) v1(28.15,120.03) 28.15,121.06 R11209.1 R617.1
TYPEC_CHG: length 2.7
  TOP w0.127: U28.7 32.81,110.75 33.2,111.14 v1(33.53,111.14) R11205.2
TYPEC_CHG_HI: length 5.3
  TOP w0.127: R11280.1 v1(35.1,113.05) R11198.2 33.74,112.29 32.31,110.86 U28.8
TYPEC_SBU1: length 11.8
  TOP w0.127: v1(14.05,116.63) 14.05,116.05 14.31,115.79 TP143.1 14.57,115.6 U4513.4
  IN2 w0.14: v1(14.05,116.63) 14.05,116.81 13.9,116.96 13.9,118.61 12.3,120.21 10.65,120.21 10.12,120.75 v1(9.07,120.75)
  BOTTOM w0.127: CN2021.A8 8.02,120.65 8.11,120.75 v1(9.07,120.75)
TYPEC_SBU2: length 19
  TOP w0.102: CN2021.B8 5.31,119.04 6.71,119.04
  TOP w0.127: v1(14.05,113.63) 13.85,113.63 13.11,114.37 13.11,116.63 12.13,117.61 9.98,117.61 v1(9.65,117.94) 8.5,117.94 7.4,119.04 6.71,119.04 ; TP144.1 18.34,115.29 17.66,115.97 v1(17.25,115.97) 17.22,116 U4513.7
  BOTTOM w0.127: v1(14.05,113.63) 14.92,113.63 v1(17.25,115.97)
UART2_CTS#: length 7.5
  BOTTOM w0.076: U35.AD4 139.23,111.29 139.31,111.29 139.33,111.32 140.6,111.32 140.77,111.4 141.41,111.4 141.43,111.42 142.15,111.42 142.17,111.4
  BOTTOM w0.127: R290.1 145.79,111.86 144.33,111.86 TP4357.1 143.74,111.27 142.3,111.27 142.17,111.4
UART2_RTS#: length 11.7
  BOTTOM w0.079: 141.76,110.51 141.65,110.51 141.51,110.65 139.78,110.65 U35.AD3
  BOTTOM w0.127: TP4356.1 149.71,111.81 149.68,111.77 R283.1 149.28,111.77 148.85,111.34 148.72,111.34 147.63,110.26 145.65,110.26 145.4,110.51 141.76,110.51
UART2_RXD: length 8.2
  BOTTOM w0.127: R275.1 148.52,111.7 147.58,110.76 TP4354.1 141.73,110.76 141.58,110.92 U35.AD1
UART2_TXD: length 8
  BOTTOM w0.076: U35.AD2 140.63,111.15 140.71,111.19 141.73,111.19 141.73,111.19
  BOTTOM w0.127: 141.73,111.19 141.77,111.23 142.03,111.23 142.21,111.06 142.51,111.06 142.52,111.07 144.24,111.07 144.52,111.35 146.13,111.35 146.56,111.77 R280.1 147.65,111.77 TP4355.1
USB2_ID: length 6
  BOTTOM w0.127: U35.AG3 139.6,109.6 139.9,109.89 140.98,109.89 141.04,109.82 141.51,109.82 141.94,110.26 144.57,110.26 144.97,109.85 R587.1
USB2_TYPC_7N_C: length 18
  TOP w0.114: v1(9.15,119.65) 8.96,119.84 8.96,120.02 9.02,120.09 10.5,120.09 10.78,119.81 12.13,119.81 14.17,117.77 16.34,117.77 U4513.9 16.48,117.77 16.69,117.77 17.86,118.94 17.91,118.94 18.08,118.77 18.58,118.77 18.69,118.66 R818.2
  IN2 w0.114: v1(9.15,119.65) 8.91,119.41 8.91,119.23 8.59,118.92 7.8,118.92 6.92,119.8 6.35,119.8 CN2021.B7
  BOTTOM w0.114: CN2021.A7 8.65,120.15 v1(9.15,119.65)
USB2_TYPC_7P_C: length 17.9
  TOP w0.114: R819.2 18.74,119.48 18.58,119.32 18.08,119.32 17.91,119.15 17.77,119.15 16.6,117.99 15.57,117.99 U4513.1 15.34,117.99 14.26,117.99 12.22,120.02 10.87,120.02 10.59,120.3 8.93,120.3 8.74,120.11 8.74,119.73 8.69,119.68 v1(8.46,119.68)
  IN2 w0.114: v1(8.46,119.68) 8.62,119.68 8.69,119.6 8.69,119.32 8.5,119.13 7.89,119.13 7.01,120.01 6.15,120.01 6.05,120.11 CN2021.B6
  BOTTOM w0.114: v1(8.46,119.68) 8.46,119.86 8.41,119.92 8.04,119.92 7.92,119.81 7.92,119.74 7.84,119.65 CN2021.A6
USB3_RXN0: length 289.6
  TOP w0.114: v1(37.11,14.8) 36.82,14.51 36.82,14 33.75,10.93 24.07,10.93 20.67,7.53 19.14,7.53 18.74,7.93 18.74,8.91 C518.2 18.68,9.61 18.68,9.84 R392.2
  IN2 w0.114: v2(136.81,118.73) 137.24,119.16 137.24,119.57 137.51,119.84 138.3,119.84 138.51,120.06 138.89,120.06 139.31,119.64 145.05,119.64 145.32,119.37 151.55,119.37 152.26,120.08 156.04,120.08 158.44,117.69 158.67,117.69 166.39,109.96 166.39,109.23 170.24,105.38 170.24,96.54 170.9,95.88 170.9,90.52 169.54,89.16 169.54,85.71 169.62,85.62 169.62,83.46 169,82.84 169,79.46 168.5,78.95 168.5,74 168.68,73.82 168.68,69.01 171.5,66.19 171.5,65.52 174.55,62.47 174.55,62.47 174.63,62.39 174.63,61.39 175.04,60.98 175.04,56.49 175.66,55.87 175.66,54.74 175.16,54.25 175.16,50.21 174.36,49.41 174.36,45.62 173.68,44.94 173.68,44.25 171.72,42.28 171.72,40.93 170.86,40.06 170.86,38.49 170.41,38.04 169.87,38.04 167.52,35.69 167.07,35.69 166.29,34.91 164.03,34.91 163.92,35.02 159.57,35.02 159.06,34.51 157.3,34.51 151.21,28.42 115.01,28.42 114.17,29.26 113.37,29.26 111.94,30.68 109.53,30.68 107.11,33.1 87.57,33.1 80.07,25.6 77.05,25.6 75.61,24.16 71.85,24.16 67.23,19.54 67.23,18.4 65.18,16.35 62.08,16.35 61.66,16.77 52.37,16.77 50.86,15.26 48.66,15.26 48.32,15.6 46.98,15.6 46.22,14.84 42.97,14.84 42.37,14.24 37.01,14.24 36.86,14.4 36.86,14.55 v1(37.11,14.8)
  BOTTOM w0.114: U35.H8 136.32,118.95 136.54,118.73 v2(136.81,118.73)
USB3_RXN0_R: length 9.2
  TOP w0.114: R392.1 18.7,11.3 18.7,11.73 18.93,11.96 18.93,12.44 18.85,12.52 18.55,12.52 U24.6 18.41,12.52 15.37,12.52 15,12.88 14.19,12.88 13.62,12.31 13.1,12.31 12.92,12.14 CN16.5
USB3_RXN1: length 284.1
  TOP w0.114: R355.2 23.03,29.48 C475.2 23.43,29.88 24.65,29.88 25.56,28.98 25.56,28.63 v1(25.27,28.34)
  IN2 w0.114: v1(25.27,28.34) 25.62,28.7 25.62,28.84 25.86,29.08 26.35,29.08 28.23,27.2 28.23,26.08 28.59,25.71 28.59,24.11 37.23,15.48 45.96,15.48 46.72,16.24 48.2,16.24 48.52,16.56 50.12,16.56 51.8,18.23 64.47,18.23 66.25,20.01 66.25,21.89 66.79,22.44 68.09,22.44 68.6,22.94 69.4,22.94 71.25,24.79 75.35,24.79 76.78,26.23 79.62,26.23 87.39,34.01 109.64,34.01 112.33,31.32 113.75,29.89 114.43,29.89 115.27,29.05 150.94,29.05 157.71,35.82 163.72,35.82 164.26,36.35 167.28,36.35 169.61,38.69 169.61,40.39 170.48,41.26 170.48,42.1 172.51,44.13 172.51,44.86 173.15,45.51 173.15,49.1 174.53,50.47 174.53,54.51 174.97,54.95 174.97,55.66 174.4,56.23 174.4,60.67 173.92,61.15 173.92,61.96 168.05,67.84 168.05,73.56 167.86,73.74 167.86,79.22 168.37,79.72 168.37,81.08 167.61,81.84 167.61,83.29 168.59,84.26 168.59,85.95 168.9,86.26 168.9,89.48 169.41,89.98 169.41,97.44 168.95,97.89 168.95,105.38 165.49,108.85 165.49,109.95 158.77,116.67 157.85,116.67 155.86,118.66 145.09,118.66 144.75,119.01 140.1,119.01 139.72,118.63 138.6,118.63 138.31,118.92 137.85,118.92 v1(137.68,118.75)
  BOTTOM w0.114: v1(137.68,118.75) 137.68,118.18 137.58,118.08 137.34,118.08 137.24,118.18 U35.J6
USB3_RXN1_R: length 10.6
  TOP w0.114: CN13.5 12.92,28.55 13.02,28.65 13.39,28.65 13.96,29.22 14.68,29.22 16.15,30.69 18.95,30.69 U21.6 19.13,30.69 19.86,30.69 20.69,29.85 20.91,29.85 21.26,29.51 R355.1
