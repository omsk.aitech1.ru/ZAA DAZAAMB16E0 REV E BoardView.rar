# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N21854718: length 3.4
  BOTTOM w0.305: v1(195.8,53.76) PC227.2 196.69,53.76 197.45,54.51 PR260.2 197.67,54.76 198.08,55.16 PR275.1
N21854764: length 1.8
  BOTTOM w0.381: v1(205.05,54.77) PR112.2 205.03,55.59 PR114.2
N21854773: length 9.9
  IN1 w0.305: v1(204.76,56.38) 203.87,55.49 202.88,55.49 202.37,54.99 v1(202.37,54.93)
  BOTTOM w0.305: PR105.1 PC200.1 205.56,57.55 PR106.2 204.56,57.14 204.76,56.94 v1(204.76,56.38) ; PR113.2 200.01,55.47 200.62,54.86 v1(201.07,54.86) 201.41,54.86 PR115.1 202.37,55.36 v1(202.37,54.93)
N21854780:
  vias: v1(204.27,63.16)
N21854821: length 2.5
  TOP w0.762: PR89.2 198.61,74.55 PC188.1 v1(198.47,73.47)
N21854867: length 2.3
  BOTTOM w0.381: v1(192.52,60.44) PR118.1 193.56,60.5 PC199.2
N21854979: length 2.9
  TOP w0.762: PR91.2 189.51,71.62 PC183.1 v1(190.97,73)
N21854999:
  vias: v1(195.36,63.43)
N21855085: length 3.1
  BOTTOM w0.381: PR105.2 206.96,56.81 v1(207.77,57.62) 208.51,58.36 PQ18.3
N21874303: length 9.5
  TOP w0.381: PR140.1 69,107.38 70.18,106.2 PR141.2 70.18,105.54 70.44,105.28 v1(71.02,105.28) 71.02,104.26 PQ8.2 71.81,104.16 72.07,104.41 PQ7.2 72.95,105.07 71.94,106.09 PQ6.3
N21874329: length 2.5
  TOP w0.381: PQ7.3 74.99,104.16 v1(75.22,104.39) 75.55,104.73 PR139.2
N22203161: length 1.6
  TOP w0.127: v1(128.92,39.81) R10873.2 C1252.2
N22210005: length 3.2
  TOP w0.127: TP154.1 124.18,40.58 v1(124.18,41.52)
  BOTTOM w0.127: JDIM1.162 124.97,42.01 124.49,41.52 v1(124.18,41.52)
N22210006: length 8.6
  TOP w0.127: TP153.1 131.7,51.07 127.82,51.07 v1(125.91,52.98)
  BOTTOM w0.127: JDIM1.165 125.72,52.79 v1(125.91,52.98)
N22221753: length 20.1
  TOP w0.254: R11170.1 154.96,54.82 151.36,51.23 151.36,49.55 v1(151.39,49.52) 151.82,49.09 v1(151.82,48.94)
  TOP w0.508: R11133.1 148.26,52.91 148.44,52.73 v1(148.64,52.73) 148.28,52.37 C1267.1 148.28,52 147.77,51.48 C1265.1
  IN2 w0.254: v1(151.82,48.94) 149.64,48.94 148.64,49.94 v1(148.64,52.73)
  BOTTOM w0.254: JDIM1.255 148.22,52.56 148.4,52.73 v1(148.64,52.73)
N22317134: length 5.2
  BOTTOM w0.127: CN2019.27 173.96,21.86 173.53,22.3 172.81,22.3 172.28,22.83 D4002.1 172.01,23.51 R11107.1 v1(171.1,22.7)
N22444593: length 34.4
  BOTTOM w0.127: SW4.4 SW4.3 213.85,90.42 214.42,89.85 217.8,89.85 218.66,88.99 R11282.2 219.19,88.99 220.94,87.24 220.94,83.92 220.02,83 v1(220.02,79.83) 220.02,67.1 219.44,66.52 218.99,66.52 218.68,66.82 Q40.3
N22485913: length 2.5
  BOTTOM w0.127: TP4360.1 169.83,70.58 168.95,71.46 U44.30
N22485947: length 2
  BOTTOM w0.127: TP4361.1 170.08,71.96 U44.29
N22521878: length 7.4
  BOTTOM w0.127: 173.46,106.83 173.97,106.83 174.28,106.52 v1(174.71,106.52) 174.96,106.52 175.66,107.22 C4200.1 R4201.1 176.54,108.21 177.19,107.56 178.19,107.56 Q4200.2
N22521888: length 5.2
  BOTTOM w0.127: v1(176.54,109.7) 176.11,110.12 C4201.1 R4203.1 174.39,109.7 172.62,109.7 172.45,109.52 Q4201.2
N22523419: length 3.7
  TOP w0.127: R4000.2 R4002.1 165.26,110.03 165.45,109.83 Q4001.3 167.33,109.83 v1(167.42,109.93)
N22523424: length 4.4
  TOP w0.127: R4002.2 165.74,111.28 165.85,111.39 C4019.1 167.26,111.39 C4013.2 167.62,111.03 168.16,111.03 v1(168.18,111.02) 168.33,110.87 Q4000.2
N22570409: length 3.7
  BOTTOM w0.127: U45.66 170.71,29.4 170.54,29.23 v1(170.54,28.3) 170.54,27.79 C798.2 R774.1
N22570473: length 7
  BOTTOM w0.127: EC52.2 183.67,48.37 183.26,47.96 183.16,47.96 R460.1 182.63,45.83 C801.1 182.95,44.88 182.58,44.88 v1(182.16,44.46) 181.58,43.88 U45.118
N22570527: length 4.4
  BOTTOM w0.127: R190.1 C796.1 172.04,44.44 v1(172.22,44.27) 172.5,43.99 173,43.99 173,43.99 173.36,43.99 173.39,43.96 173.46,43.96 173.58,43.84 U45.98
N22570909: length 4.3
  BOTTOM w0.127: U45.128 185.58,43.68 185.73,43.83 v1(187.33,43.83) 187.9,43.83 C797.1 R349.1
N22571742: length 1.2
  BOTTOM w0.127: R373.1 191.34,36.98 C490.2
N22571917: length 2.6
  BOTTOM w0.127: C778.1 189.4,37.89 189.18,37.66 189.16,37.65 188.51,37 U45.12
N22668004: length 3.2
  BOTTOM w0.508: PQ6066.3 158.96,57.77 v1(158.96,56.8) 158.42,56.25 PR6298.2
N22678439: length 54.3
  TOP w0.127: R11140.2 v1(160.18,71.39)
  IN1 w0.14: v1(160.18,71.39) 159.74,71.83 159.74,73.72 160.01,73.99 160.39,73.99 160.71,74.31 160.71,75.99 160.13,76.57 160.01,76.57 159.28,77.31 158.61,77.31 155.43,80.49 155.43,84.55 152.51,87.47 152.51,91.03 151.31,92.22 151.31,96.54 148.6,99.26 137.93,99.26 134.5,102.69 134.5,104.85 134.2,105.15 v2(134.01,105.15)
  BOTTOM w0.127: v2(134.01,105.15) 133.65,105.5 U35.AR13
N22746710: length 11.7
  TOP w0.508: R11142.1 C4728.1 C4727.1 154.99,62.66 R11134.1 154.03,63.39 v1(153.88,63.55) 153.3,64.13 149.49,64.13 v1(148.64,64.98)
  BOTTOM w0.254: JDIM2.255 148.22,64.77 148.44,64.98 v1(148.64,64.98)
N23131721: length 4.1
  BOTTOM w0.076: 141.07,117.86 140.71,118.21 U35.L1
  BOTTOM w0.127: 141.07,117.86 141.9,117.86 142.17,118.13 C793.2
N23160970: length 3
  BOTTOM w0.127: Q4300.6 193.11,106.29 192.39,106.29 192.28,106.19 192.28,105.91 192.76,105.44 R4328.1 R4329.2
N23160985: length 7.6
  BOTTOM w0.127: v1(195.33,105.81) 195.33,105.87 194.74,106.45 R4336.2 194.21,106.84 194.21,107.54 193.84,107.91 192.41,107.91 192.08,107.58 Q4300.3 190.25,107.58 189.83,107.16 R4335.1
N23162333: length 1.6
  TOP w0.127: v1(186.39,124.05) 185.65,124.78 TP4309.1
  BOTTOM w0.102: 186.34,124.1 v1(186.39,124.05)
  BOTTOM w0.127: 186.34,124.1 186,124.44 U3002.N8
N23162335: length 1.4
  TOP w0.127: TP4308.1 184.74,123.23 v1(184.74,124.05)
  BOTTOM w0.102: v1(184.74,124.05) 185.13,123.66 U3002.P7
N23162337: length 2.9
  TOP w0.127: TP4306.1 185.48,120.92 185.02,121.38 185.02,121.88 v1(185.53,122.39)
  BOTTOM w0.102: v1(185.53,122.39) 185.13,121.99 U3002.P5
N23162339: length 1.8
  TOP w0.127: TP4304.1 187.32,123.07 v1(188.02,122.37)
  BOTTOM w0.102: U3002.L6 187.63,122.76 v1(188.02,122.37)
N23162341: length 5.6
  BOTTOM w0.102: U3002.M3 186.95,120.34 187.24,120.05 187.24,118.96
  BOTTOM w0.127: 187.24,116.48 186.39,115.63 TP4302.1
  BOTTOM w0.14: 187.24,118.96 187.24,116.48
N23457928: length 6.9
  TOP w0.127: R709.2 43.8,78.62 43.88,78.55 44.8,78.55 45.69,77.65 R715.1 R713.1 v1(46.97,79.29) 46.97,79.98 Q39.3
N23457985: length 18.1
  BOTTOM w0.508: U42.7 31.47,82.4 31.43,82.44 ; C364.2 36.12,88.4 v1(34.73,88.4) U42.1 31.92,88.4 31.43,87.9 31.43,85.36 ; U42.10 31.8,79.4 31.43,79.78 31.43,82.44 ; 31.43,85.36 31.46,85.4 U42.4 ; 31.43,85.36 31.43,82.44
N23458009: length 7.4
  TOP w0.127: Q24.2 49.13,65.96 49.44,65.64 C368.2 49.47,65.04 49.97,65.04 v1(50.5,65.58) 50.73,65.81 50.73,69.23 50.68,69.29 R259.2
N23458593: length 2
  TOP w0.127: U15.32 38.5,68.79 v1(38.16,68.45) R11259.1
N23458605: length 7.8
  TOP w0.127: U15.30 37.7,68.98 37.46,68.75 37.46,68.36 37.17,68.06 37.17,65.93 36.53,65.3 v1(36.33,65.3) 36.25,65.22 C4821.2 R11260.2 R11261.2
N23458824: length 4.9
  TOP w0.127: U15.41 41.55,72.06 42.09,71.52 42.87,71.52 C4603.1 43.56,70.84 44.96,70.84 TP4333.1
N23458866: length 2.5
  TOP w0.127: U15.37 41.55,70.46 42.22,69.79 TP4334.1 42.37,69.62 42.97,69.62 C4604.1
N23458888: length 7.8
  TOP w0.127: TP4335.1 47.15,69.82 46.39,70.58 43.31,70.58 43.14,70.76 42.91,70.76 42.44,71.23 42,71.23 41.57,71.66 U15.40
N23458910: length 7.4
  TOP w0.127: U15.43 42.27,72.86 42.53,72.61 42.53,71.93 42.68,71.77 46.41,71.77 46.44,71.8 TP44.1
N23458912: length 7.2
  TOP w0.127: TP4336.1 46.49,69.79 45.95,70.33 43.16,70.33 43.01,70.48 42.73,70.48 42.55,70.3 42.09,70.3 41.53,70.86 U15.38
N23510743: length 4.9
  TOP w0.102: 136.23,116.68 135.39,116.68 v2(135.06,116.35)
  TOP w0.114: TP4390.1 136.73,116.78 136.63,116.68 136.23,116.68
  BOTTOM w0.079: U35.N11 134.83,116.58 v2(135.06,116.35)
N23517766: length 2.4
  TOP w0.127: R11187.1 26.09,71.77 26.09,71.51 v1(25.78,71.2) 25.68,71.1 25.2,71.1 25.08,70.98 U13.9
N23517875: length 4.8
  TOP w0.127: U13.12 23.88,70.93 23.82,70.99 23.82,72.4 23.55,72.66 22.28,72.66 v1(22.03,72.41) 21.9,72.55 R11286.1
N23517877: length 1.7
  TOP w0.127: TP4376.1 23.48,71.85 U13.13
N23523086: length 6.8
  TOP w0.127: v1(111.56,127.35) 111.54,127.38 111.46,127.38 111.05,127.78 111.05,128.42 110.65,128.82 TP4395.1
  BOTTOM w0.114: U35.A50 112.51,125.31 112.2,125.62 112.2,126.38 111.99,126.59 111.99,126.87 111.56,127.3 v1(111.56,127.35)
N23523088: length 7.3
  TOP w0.127: TP4394.1 110.04,128.42 110.04,128.42 110.16,128.54 110.55,128.54 110.8,128.29 110.8,127.4 110.92,127.29 110.93,127.27 110.93,127.27 111.49,126.72 111.54,126.72 v1(111.56,126.69)
  BOTTOM w0.076: 112.27,124.02 112.22,123.97 112.22,123.41 112.51,123.13 U35.B50
  BOTTOM w0.114: 112.27,124.02 112.27,125.24 111.98,125.53 111.98,126.27 v1(111.56,126.69)
N23523090: length 10.7
  TOP w0.127: v1(111.56,125.37) 112.07,125.88 112.07,130.96 111.69,131.34 111.44,131.34 TP4392.1
  BOTTOM w0.076: U35.D51 112.1,122.24 112.1,122.45 112.27,122.63 112.27,122.85 112.02,123.11 112.02,124.94 111.89,125.06
  BOTTOM w0.114: v1(111.56,125.37) 111.56,125.39 111.89,125.06
N23523092: length 10.2
  TOP w0.127: v1(111.56,124.71) 111.56,124.73 112.32,125.5 112.32,131.08 111.82,131.59 TP4393.1
  BOTTOM w0.076: 111.82,124.48 111.82,122.87 U35.C51
  BOTTOM w0.114: v1(111.56,124.71) 111.56,124.73 111.82,124.48
N23587811: length 2.6
  TOP w0.305: PR6294.1 61.04,53.49 v1(60.7,53.82)
  BOTTOM w0.178: PU10.5 60.47,54.05 v1(60.7,53.82) 61.04,53.49 PC112.1
N23587813: length 2.8
  TOP w0.305: PR6293.2 61.06,55.57 v1(60.69,55.2)
  BOTTOM w0.178: PC107.1 61.06,55.57 v1(60.69,55.2) 60.35,54.85 PU10.3
N23587852: length 5.2
  TOP w0.203: PU6010.7 52.81,41.77 v1(53.22,42.18) 53.42,42.39 PR6284.2
  TOP w0.381: PR6297.1 PR6283.1 54.44,43.04 PR6284.2
N23587899:
  vias: v1(50.09,43.2)
N23587941: length 2.5
  TOP w0.127: PR6289.2 v1(62.91,50.02)
  TOP w0.762: PC6222.1 PR6289.2
N23588169: length 4.7
  TOP w0.178: PU20.3 37.96,94.53 37.9,94.48 PC214.1 38.17,94.06 38.39,93.85 38.39,92.15 38.09,91.85 PR6299.2
N23588226: length 5.4
  TOP w0.178: PU20.4 38.36,95.24 39.07,94.53 PC180.1 39.77,94.08 v1(39.91,93.95) 39.91,92.71 PR6300.2
N23588230: length 2
  TOP w0.178: PU20.12 37.96,98.87 PC210.1 v1(38.95,99.15)
N23588246: length 2.3
  BOTTOM w0.127: PC6221.1 v1(63.37,25.52)
  BOTTOM w0.762: PC6221.1 64.77,26.46 PR6288.2
N23588298:
  vias: v1(49.76,34.23)
N23588466: length 9.1
  TOP w0.254: PR6290.1 40,53.14 39.29,53.85 38.68,53.85 38.41,54.12 PQ6057.3 37.45,54.33 v1(36.18,54.33) 35.57,54.33 34.47,53.23 33.97,53.23 PQ6058.2
N23588559: length 2.7
  TOP w0.203: v1(65.77,21.05) 65.14,21.05 PC88.1
  BOTTOM w0.178: PR6282.2 66.2,20.62 v1(65.77,21.05) 65.54,20.82 PU11.4
N23588563: length 1.6
  BOTTOM w0.178: PU11.12 62.06,21.22 61.8,21.48 61.33,21.48 PC175.1
N23588565: length 1.4
  BOTTOM w0.178: PC98.1 61.98,20.34 62.06,20.42 PU11.10
N23588601: length 2.7
  TOP w0.203: v1(65.72,20.21) 65.59,20.09 PC87.1
  BOTTOM w0.178: PU11.5 65.51,20.42 v1(65.72,20.21) 65.84,20.21 66.4,19.65 PR6291.1
N23588609: length 3.6
  BOTTOM w0.127: v1(66.66,23.29) 66.34,22.97 PR6285.2
  BOTTOM w0.178: PU11.3 65.25,21.22 65.61,21.58 PC84.1
  BOTTOM w0.381: PC84.1 PR6285.2
N23588692: length 2.4
  TOP w0.305: v1(60.69,54.5) 60.64,54.55 PR6292.2
  BOTTOM w0.178: PU10.4 60.64,54.45 v1(60.69,54.5) 60.71,54.5 60.76,54.55 PC111.1
N23588706: length 1.5
  BOTTOM w0.178: PU10.12 56.71,54.85 56.67,54.88 PC177.1
N23588708: length 1.6
  BOTTOM w0.178: PU10.10 57.22,54.05 56.99,53.82 56.47,53.82 56.42,53.87 PC176.1
N24001694: length 9.7
  BOTTOM w0.508: R119.2 v1(226.35,140.09) 226.5,139.94 226.5,135.4 224.85,133.75 223.07,133.75
N24137237: length 6.7
  BOTTOM w0.127: v1(199.47,25.6) C529.2 199.72,26.4 199.93,26.61 199.93,27.71 200.11,27.88 200.11,30.48 200.63,31 U23.39
N24137249: length 3.9
  BOTTOM w0.127: C528.2 200.44,27.48 201.05,28.09 v1(201.05,28.24) 201.05,29.56 200.71,29.9 200.71,30.08 200.83,30.2 U23.37
N24137264: length 2.4
  BOTTOM w0.127: U23.34 203,28.72 202.42,28.14 202.42,27.53 202.29,27.4 C530.1
N24137266: length 3.6
  BOTTOM w0.102: v1(210.62,31.11) 210.6,31.11 209.58,32.13 C519.1
  BOTTOM w0.127: U23.19 209.39,32.2 C519.1
N24137310: length 1.7
  BOTTOM w0.102: U23.48 200.72,34.6
  BOTTOM w0.127: TP34.1 200.46,35.5 200.46,34.82 200.68,34.6 200.72,34.6
N24137536: length 3.7
  TOP w0.127: v1(204.07,35.81) 204.16,35.72 C481.1 204.93,36.24 204.48,36.7 v1(204.48,36.88)
  BOTTOM w0.127: U23.7 204.6,36.75 v1(204.48,36.88)
N24137654: length 4.5
  BOTTOM w0.127: v1(207.87,40.29) R352.2 209.18,40.29 209.33,40.44 D10.1 D9.1
N24137694: length 4.2
  BOTTOM w0.127: U23.35 202.6,28.7 202.19,28.29 201.76,28.29 200.95,27.48 200.95,26.61 200.73,26.4 C528.1
N24137751: length 5
  TOP w0.178: R388.2 210.91,30.36 210.52,29.97 v1(210.37,29.97)
  TOP w0.203: R388.2 210.19,30.88 209.81,31.26 v1(209.81,31.29)
  BOTTOM w0.203: v1(209.81,31.29) 209.71,31.39 209.3,31.39 208.89,31.8 U23.20
N24462443: length 17.2
  TOP w0.127: v1(148.75,118.13) v1(148.75,119.45) 148.94,119.64 149.09,119.64 149.1,119.65 R571.2
  IN1 w0.076: 138.85,117.11 138.6,116.87 137.53,116.87 137.5,116.84 136.83,116.84 136.62,116.62 136.24,116.62 v2(135.86,116.24)
  IN1 w0.14: v1(148.75,118.13) 148.22,117.6 142.65,117.6 142.17,117.11 138.85,117.11
  BOTTOM w0.127: U35.N9 136.01,116.8 135.86,116.64 v2(135.86,116.24)
N24842468: length 5.1
  TOP w0.127: v1(14.81,42.41) 15.14,41.99 D31.1 16.27,41.25 17,41.98 17.58,41.98 17.96,42.36 R316.1
N24842470: length 2.5
  TOP w0.127: R317.1 18.98,41.52 19.21,41.29 D30.1
N24842747: length 2.2
  TOP w0.127: U18.4 19.23,51.63 v1(19.41,51.81) 19.41,52.94 R11273.1
N25027006: length 2.5
  TOP w0.127: R11210.1 31.68,114.83 v1(31.22,115.29) 31.02,115.29 30.41,115.89 U9.30
N25057492: length 2.5
  TOP w0.127: R11269.1 14.05,85.16 v1(13.65,85.57) 12.74,86.47 U40.4
N25057545: length 2.4
  TOP w0.127: R11272.1 9.02,85.53 v1(9.02,86.13) 9.02,86.46 9.24,86.67 U37.4
N25088929: length 8.9
  TOP w0.305: PC11.1 136.47,168.29 137.06,168.87 PC16.2 ; v1(135.69,169.49) 135.31,169.49 135.11,169.29 v1(135.11,169.06) 135.11,168.61 PR187.1 135.36,168.34 135.36,167.39 PR191.2 135.45,167.36 135.85,167.36 135.89,167.31 PC12.1
  TOP w0.381: PR187.1 135.82,168.35 135.88,168.29 PC11.1
  BOTTOM w0.305: v1(135.69,169.49) 135.95,169.49 136.53,170.07 137.3,170.07 PR194.2
N25088945: length 8.1
  TOP w0.254: PR33.1 149.23,176.09 149.66,176.52 149.66,177.48 PC25.2
  TOP w0.305: PC27.1 145.75,179.32 v1(145.95,179.12) 145.95,177.75 PR201.2 146.6,177.5 147.03,177.93 PC26.2 PR31.1 149.26,177.93 PC25.2
N25088989: length 2
  BOTTOM w0.305: PR224.1 136.88,163.98 PR235.2 136.85,162.99 PR236.2
N25089005: length 1.6
  TOP w0.381: PR44.2 142.22,184.08 PC41.1
N25089057: length 2.8
  BOTTOM w0.305: PR225.1 126.45,161.89 PR227.2 PR226.2 v1(124.7,162.85)
N25089075: length 1.9
  TOP w0.381: PR216.2 142.94,183.21 v1(143.29,183.56) PC139.1
N25089155: length 48.3
  TOP w0.381: v1(139.27,184.07) 138.96,183.75 PR218.1
  IN2 w0.203: v1(146.87,154.07) 146.74,154.2 146.74,161.16 152.05,166.47 152.05,183.69 150.3,185.44 143.36,185.44 141.2,183.28 140.06,183.28 v1(139.27,184.07)
  BOTTOM w0.254: PR242.1 146.97,153.88 146.97,153.97 v1(146.87,154.07)
N25089173: length 1.9
  BOTTOM w0.381: PC40.1 137.64,183.68 PR48.1 v1(136.79,184.53)
N25089218: length 38.7
  IN2 w0.203: v1(116.08,151.28) 115.63,151.73 115.63,153.82 118.15,156.34 118.15,159.91 118.61,160.37 118.61,160.74 120.4,162.53 123.07,162.53 124.58,164.04 128.79,164.04 130.9,166.15 130.9,167.7 133.09,169.88 134.66,169.88 135.26,170.48 137.11,170.48 137.81,171.18 138.64,171.18 139.02,171.56 v1(139.02,172.05)
  BOTTOM w0.203: v1(116.08,151.28) 116.07,151.29 PR241.2
  BOTTOM w0.305: PR193.1 v1(139.02,172.05)
N25089263: length 1.8
  TOP w0.305: PR21.2 142.13,169.81 v1(142.12,169.82) 142.13,169.83 PC19.2
N25125081: length 1
  BOTTOM w0.305: PC129.1 136.74,170.56 PR195.2
N25125123: length 1
  TOP w0.305: PC15.1 139.02,169.65 PR23.2
N25125126: length 1
  TOP w0.305: PC16.1 137.6,169.7 137.6,170.37 PR24.2
N25125152: length 1.3
  TOP w0.305: PR34.2 148.05,176.32 147.67,176.7 147.67,176.71 147.23,177.15 PC26.1
N25125190: length 37.2
  TOP w0.305: PR205.1 147.53,180.08 v1(147.5,180.06)
  IN1 w0.203: v1(147.5,180.06) 147.28,180.06 144.68,177.46 144.68,174.04 145.19,173.53 145.19,171.77 143.76,170.34 143.76,168.82 142.93,167.99 142.93,167.1 140.06,164.23 137.47,164.23 133.58,160.34 133.58,152.52 133.79,152.32 133.79,152.29 v1(133.84,152.24)
  BOTTOM w0.203: PR243.1 134.23,151.85 v1(133.84,152.24)
N25125219: length 1.2
  TOP w0.305: PC34.1 146.66,182.51 146.78,182.64 PR41.1
N25125233: length 2.5
  TOP w0.127: PC135.1 146.18,175.67 146.89,174.96 v1(146.89,174.64)
  TOP w0.254: PC135.1 145.89,175.75 145.7,175.94 PR199.2
N25125243: length 1.4
  TOP w0.305: PR36.2 145.13,177.05 144.32,177.85 PC28.1
N25125246: length 9.3
  TOP w0.305: v1(146.13,185.59) 145.81,185.27 PR51.1 PC46.2 144.28,185.85 144.37,185.94 PR50.1 144.02,186.41 v1(143.69,186.74) 143.58,186.62 PC44.1
  BOTTOM w0.305: PC42.2 142.42,185.24 143.69,186.51 v1(143.69,186.74)
  BOTTOM w0.381: PC42.2 142.2,185.19 141.84,184.83 141.84,183.7 PR217.2
N25125286: length 1.9
  BOTTOM w0.381: PR45.2 PC42.1 v1(143.15,184.41)
N25127185: length 42.4
  TOP w0.381: v1(148.67,180.06) 148.67,180.85 PR215.2
  IN2 w0.203: v1(135.21,150.64) 135.06,150.79 135.06,159.53 141.38,165.86 142.96,165.86 146.54,169.44 146.54,172.89 147.96,174.31 147.96,177.9 148.67,178.61 v1(148.67,180.06)
  BOTTOM w0.254: v1(135.21,150.64) 135.26,150.59 135.24,150.57 135.26,150.54 138.16,150.54 138.59,150.97 PL4.3
N25127186: length 41.5
  TOP w0.305: v1(147.71,178.46) 148.26,179.01 PR214.2
  IN2 w0.203: v1(147.71,178.46) 147.55,178.31 147.55,174.42 146.18,173.04 146.18,169.59 142.8,166.21 141.08,166.21 134.68,159.81 134.68,150.34 135.06,149.96 v1(135.16,149.96)
  BOTTOM w0.254: PL4.4 138.59,149.55 138.11,150.03 135.24,150.03 v1(135.16,149.96)
N25127202:
  vias: v1(140.34,155.02)
N25127220: length 37.4
  IN2 w0.203: v1(138.46,168.4) 138,168.85 136.51,168.85 133.71,166.06 132.09,166.06 129.22,163.19 126.57,163.19 123.73,160.34 123.73,152.24 v1(123.12,151.63)
  BOTTOM w0.254: v1(123.12,151.63) 122.92,151.43 120.55,151.43 119.64,152.34 PL2.3
  BOTTOM w0.305: PR19.2 140.33,166.49 v1(138.82,166.49) 138.26,166.49 137.68,167.07 PR20.2 137.68,167.62 v1(138.46,168.4)
N25127225: length 39
  IN2 w0.203: v1(142.8,168.7) 142.7,168.7 142.68,168.73 142.53,168.73 141.87,168.07 139.83,168.07 137.39,165.63 135.95,165.63 135.11,164.79 132.62,164.79 129.7,161.87 126.9,161.87 125,159.96 125,151.81 v1(125.46,151.35)
  BOTTOM w0.254: PL3.3 128.73,151.96 127.95,151.18 125.63,151.18 v1(125.46,151.35)
  BOTTOM w0.381: PR190.2 142.32,168.22 v1(142.8,168.7) 143.38,168.13 PR189.2 143.57,167.66 v1(143.08,167.18)
N25127236: length 41.7
  IN1 w0.305: v1(142.4,172.03) 142.4,171.6 141.23,170.43 139.51,170.43 138.64,169.55 138.5,169.55 v1(137.24,168.29)
  IN2 w0.203: v1(137.24,168.29) 137.24,168.24 137.22,168.27 136.45,168.27 133.86,165.68 132.39,165.68 129.47,162.76 126.65,162.76 124.09,160.19 124.09,151.84 123.15,150.9 v1(123.09,150.9)
  BOTTOM w0.254: v1(123.09,150.9) 120.63,150.9 119.64,149.91 PL2.4
  BOTTOM w0.305: v1(141.42,173.63) 141.65,173.63 PR18.1 142.39,172.09 142.42,172.05 v1(142.4,172.03) ; v1(137.24,168.29) 137.29,168.29 137.81,168.81 PR17.2
N25127258: length 40.9
  IN2 w0.203: v1(125.41,150.69) 124.64,151.45 124.64,160.12 126.78,162.25 129.55,162.25 132.47,165.17 134.98,165.17 135.87,166.06 137.29,166.06 139.73,168.5 141.64,168.5 v1(142.75,169.62)
  BOTTOM w0.254: PL3.4 128.73,150.29 128.33,150.69 v1(125.41,150.69)
  BOTTOM w0.305: PR182.2 141.65,170.09 142.16,170.6 PR188.1 ; PR182.2 v1(141.65,169.08) ; PR182.2 142.42,169.95 v1(142.75,169.62)
N25127284:
  vias: v1(123.91,164.46)
N25127289:
  vias: v1(131.86,164.03)
N25127305: length 1.9
  BOTTOM w0.254: PR237.2 138.47,162.35 v1(138.46,161.94) PU8.1
N25127307: length 2.1
  BOTTOM w0.229: 138.97,161.74 PU8.2
  BOTTOM w0.254: 138.97,161.74 139.74,162.52 PR238.2
N25127323:
  vias: v1(141.06,165.03)
N25127350: length 2.2
  BOTTOM w0.229: 119.39,161.57 PU13.2
  BOTTOM w0.254: PR229.2 120.24,162.42 119.39,161.57
N25127352: length 2
  BOTTOM w0.254: PU13.1 118.89,161.81 v1(119.08,162) 119.3,162.21 PR228.2
N25127366: length 2.7
  BOTTOM w0.254: PU7.1 128.58,161.33 128.45,161.46 127.64,161.46 v1(127.43,161.68) PR233.2
N25127378: length 2
  BOTTOM w0.229: PU7.2 129.08,161.67
  BOTTOM w0.254: 129.08,161.67 v1(128.63,162.12) 128.44,162.31 PR234.2
N25128804: length 2.3
  BOTTOM w0.254: PU9.1 150.52,161.46 150.25,161.72 149.81,161.72 v1(149.59,161.94) 149.69,162.05 PR239.2
N25128814: length 57.4
  IN2 w0.203: v1(147.28,148.86) 147.38,148.97 147.38,154.27 147.08,154.57 147.08,160.92 153.07,166.9 153.07,183.43 150.7,185.8 142.93,185.8 142.4,185.26 141.42,185.26 v1(140.68,186)
  BOTTOM w0.254: v1(147.28,148.86) 147.33,148.91 150.32,148.91 150.76,149.35 PL5.3
  BOTTOM w0.381: PR222.2 140.59,186.09 v1(140.68,186)
N25128815: length 60
  IN2 w0.203: v1(147.25,148.15) 147.35,148.15 147.78,148.58 147.78,154.4 147.43,154.76 147.43,160.75 153.42,166.75 153.42,183.79 150.98,186.23 141.51,186.23 v1(141.33,186.05)
  BOTTOM w0.254: PL5.4 150.76,147.77 150.12,148.41 147.5,148.41 v1(147.25,148.15)
  BOTTOM w0.381: v1(141.33,186.05) 141.33,186.18 140.46,187.05 v1(140.37,187.05) 140,187.42 PR221.2
N25128837:
  vias: v1(152.08,153.46)
N25128839:
  vias: v1(152.1,165.04)
N25128864: length 1.8
  BOTTOM w0.229: PU9.2 151.02,161.84 v1(150.94,161.91) 150.76,162.1 PR240.2
N26437429:
  vias: v1(165.56,50.9)
N26437442:
  vias: v1(171.15,50.16)
N26437455: length 2.2
  BOTTOM w0.508: PU16.1 169.18,46.6 PC240.2 169.18,45.38 169.22,45.34 169.22,44.82 169.18,44.77 PR271.1
N26437457: length 212.9
  TOP w0.127: v1(46.92,62.94) 47.19,62.67 PR304.1 ; v1(48.09,29) 48.09,28.16 50.37,25.88 v1(50.37,24.94) v1(50.37,21.74)
  IN1 w0.14: v1(50.37,21.74) 50.37,20.92 51.28,20.02 57.05,20.02 57.4,20.37 61.55,20.37 61.58,20.34 61.98,20.34 65.06,23.41 79.89,23.41 87.55,31.08 105.56,31.08 107.15,29.48 110.21,29.48 110.78,28.91 113.7,28.91 114.61,29.81 123.96,29.81 126.9,26.87 146.13,26.87 154.22,34.95 155.28,34.95 156.01,35.68 157.33,35.68 158.76,37.1 158.79,37.1 158.82,37.13 161.36,37.13 163.28,35.21 166.75,35.21 167.11,35.57 167.64,35.57 169.89,37.82 169.89,43.01 168.54,44.37 167.8,44.37 v1(166.96,45.21)
  IN2 w0.14: v1(46.92,62.94) 46.32,62.34 42.59,62.34 40.95,60.7 38.77,60.7 37.33,59.25 32.21,59.25 29.91,56.95 29.91,46.41 31.26,45.07 36.9,45.07 46.69,35.28 46.69,29.54 47.23,29 v1(48.09,29)
  BOTTOM w0.127: v1(166.96,45.21) 167.43,44.74 PR307.2 167.93,44.52 168.08,44.67 PR271.2
N26437471:
  vias: v1(169.55,50.34)
N26437496: length 2.2
  BOTTOM w0.508: PR306.2 168.05,51.19 v1(168.05,50.16) PU16.5
N26460910: length 2.4
  TOP w0.127: PR98.2 v1(63.84,82.99)
  TOP w0.762: PC270.1 PR98.2
N26460931:
  vias: v1(69.87,76.78)
N26462467: length 4.5
  TOP w0.203: 39.99,55.62 40.2,55.62 40.45,55.87 40.45,55.91 40.58,56.04 41.53,56.04 41.85,56.36 PU21.4
  TOP w0.305: PC218.1 39.99,55.97 39.68,56.28 PR269.2
N26462475:
  vias: v1(46.26,59.82)
N26462659: length 3.4
  TOP w0.203: PU21.3 42.12,56.76 v1(41.93,56.96) 40.59,58.29 PR281.1
N26462709: length 2.5
  TOP w0.127: v1(61.16,60.5) PR90.2
  TOP w0.762: PC197.1 59.66,59.56 PR90.2
N26464581:
  vias: v1(220.21,174.22)
N26464602:
  vias: v1(213.97,172.79)
N27001711: length 2.4
  TOP w0.127: U13.10 24.68,71.54 v1(24.54,71.68) 24.54,71.73 24.82,72.02 R11188.1
N27001714: length 4.5
  TOP w0.127: R11285.1 23.02,73.26 v1(23.64,73.26) 24.26,73.26 R11287.1 24.36,72.59 24.08,72.3 24.08,71.22 24.28,71.02 U13.11
N27008720: length 9.2
  TOP w0.076: 139.4,108.94 139.09,108.94 138.79,109.24 137.47,109.24 v2(137.09,108.86)
  TOP w0.127: TP4377.1 143.67,106.06 141.92,106.06 140.65,107.33 140.65,108.1 139.81,108.94 139.4,108.94
  BOTTOM w0.127: v2(137.09,108.86) 137.43,109.2 U35.AH7
N27008723: length 8.1
  TOP w0.076: v2(136.45,108.86) 137,109.4 138.86,109.4 139.1,109.16 139.44,109.16
  TOP w0.127: TP4378.1 141.53,107.72 140.09,109.16 139.44,109.16
  BOTTOM w0.127: v2(136.45,108.86) 136.45,108.99 136.78,109.32 U35.AH8
N27585563: length 1.1
  TOP w0.127: v1(114.08,29.74) 114.5,29.74 R11298.2
N27585646: length 3.6
  BOTTOM w0.508: R2870.2 C3008.2 C3007.2 R2868.2
N27585648: length 1.5
  BOTTOM w0.203: U1006.9 113.65,22.93 113.59,22.88 R2868.1
N27585717: length 1.7
  BOTTOM w0.127: U1006.8 113.76,22.53 R2872.1
N27586193: length 2.6
  BOTTOM w0.127: CN95.5 110.25,17.5 v1(110.55,17.8) 110.67,17.93 R11293.1
N27586196: length 2.5
  BOTTOM w0.127: R11294.1 109.53,17.82 109.75,17.6 CN95.6
N27586199: length 2.8
  BOTTOM w0.127: CN95.7 109.25,17.32 108.39,18.18 R11295.1
N27586202: length 3
  BOTTOM w0.127: R11296.1 108.75,17.05 CN95.8
N27699592: length 7.7
  TOP w0.127: v1(118.88,34.25) 118.44,34.69 C4822.2 117.49,34.08 117.61,33.96 Q76.2 117.61,32.43 117.76,32.28 117.76,31.1 116.85,30.2 R11297.2 R11298.1
N81560469: length 11
  IN1 w0.102: 213.82,149.63 213.8,149.6 213.8,148.65 v2(213.4,148.25)
  IN1 w0.14: 213.82,149.63 213.82,150.79 213.26,151.35 213.26,153.46 212.5,154.22 211.87,154.22 210.98,153.33 v1(210.34,153.33)
  BOTTOM w0.127: v1(210.34,153.33) 211.42,153.33 R1333.2 ; v2(213.4,148.25) U4.J13
N81561297: length 5.9
  TOP w0.127: v1(166.38,161.87) 166.38,161.77 165.55,160.94 R1510.2 v1(165.55,160.16)
  BOTTOM w0.102: U7.J13 169.48,161.39 169.04,160.95 168.72,160.95 168.68,160.92 168.4,160.92 168.28,160.8 167.93,160.8
  BOTTOM w0.127: v1(166.38,161.87) 167.44,160.8 167.93,160.8
N81564024: length 7.9
  IN1 w0.14: v1(213.04,113.3) 213.04,116.86 212.65,117.24 212.65,117.67 v2(213.38,118.4)
  BOTTOM w0.127: v1(211.5,112.8) R1335.2 212.54,112.8 v1(213.04,113.3) ; U3.J13 v2(213.38,118.4)
N81564072: length 11.5
  IN1 w0.102: v2(198.92,161.81) 199.3,162.2 200.03,162.2 200.13,162.3
  IN1 w0.14: v1(204.53,160.29) 205.31,161.08 205.31,162.94 204.76,163.49 201.32,163.49 200.13,162.3
  BOTTOM w0.127: v1(204.53,160.29) 204.65,160.42 R1415.2 ; v2(198.92,161.81) 198.55,161.45 U5.J13
N215331000: length 7.3
  TOP w0.127: v1(123.64,66.5) 122.87,67.27 TP157.1
  BOTTOM w0.127: JDIM2.165 125.72,64.98 124.2,66.5 v1(123.64,66.5)
N215331770: length 9.2
  TOP w0.127: TP158.1 131.37,52.6 130.74,51.96 127.69,51.96 v1(125.91,53.74)
  BOTTOM w0.127: v1(125.91,53.74) 125.41,53.74 124.97,54.17 JDIM2.162
N275857383: length 1.5
  BOTTOM w0.127: TP4396.1 117.74,22.93 U1006.4
N275857384: length 2.5
  BOTTOM w0.127: U1006.5 116.87,22.53 117.79,21.61 TP4399.1
N281253841:
  vias: v1(119.43,155.74)
N281258110:
  vias: v1(127.21,155)

## Copper pours and planes (outline as drawn)
3V_LR on TOP (solid shape): 29.75,114.12 30.99,114.12 31.1,114.02 31.1,113.38 31.02,113.3 29.55,113.3 28.99,112.75 28.99,111.88 28.91,111.81 28.23,111.81 28.1,111.93 28.1,114.73 28.23,114.85 29.01,114.85
3V_LR on IN1 (solid shape): outline of 226 points within 26.32,113.28 33.38,125.34
+1.2VSUS on TOP (solid shape): 69.61,66.95 69.61,58.54 68.09,58.54 67.75,58.2 67.06,58.2 66.98,58.28 66.98,58.89 66.95,58.89 66.95,60.02 67.09,60.17 67.09,67.69 67.43,68.03 68.53,68.03
+1.2VSUS on TOP (solid shape): 44.47,59.72 44.47,58.85 44.44,58.85 44.44,57.87 44.24,57.87 44.24,58.85 44.23,58.85 44.23,58.98 43.8,59.41 42.8,59.41 42.75,59.47 42.75,60.27 42.82,60.35 43.84,60.35
+1.2VSUS on TOP (solid shape): outline of 24703 points within 73.97,37.56 146.51,107.31
+1.2VSUS on BOTTOM (solid shape): 70.45,68.72 73.06,68.72 73.17,68.61 73.17,66.55 73.46,66.26 77.73,66.26 78.52,65.48 78.52,61.59 78.06,61.13 78.05,61.13 76.56,59.65 74.57,59.65 73.9,60.31 72.65,60.31 72.64,60.32 71.61,60.32 69.02,57.73 67.77,57.73 67.19,58.31 67.19,67.7 67.68,68.19 67.68,68.88 67.76,68.96 70.21,68.96
+1.2VSUS on IN1 (solid shape): 44.73,59.78 44.73,59.06 44.73,59.05 44.73,58.83 44.88,58.69 44.47,58.28 44,58.28 43.74,58.54 43.74,59.12 43.74,59.14 43.74,59.62 44.01,59.89 44.62,59.89
+1.5V on TOP (solid shape): 134.09,33.9 134.09,32.96 133.97,32.84 130.79,32.84 130.56,33.07 130.56,33.83 130.79,34.06 133.94,34.06
+1.5V on TOP (solid shape): 34.91,50.36 34.91,46.1 34.6,45.79 32.84,45.79 32.49,46.15 32.49,50.26 32.7,50.46 34.8,50.46
+1.5V on TOP (solid shape): 203.76,189.35 203.76,187.98 204.53,187.22 204.53,186.96 204.15,186.58 203.38,186.58 203.13,186.84 203.13,189.38 203.21,189.45 203.66,189.45
+1.5V on TOP (solid shape): 155.79,74.43 155.84,74.42 156.03,74.42 156.25,74.21 156.22,74.04 156.27,73.87 156.27,73.64 156.26,73.63 156.23,73.56 156.22,73.5 156.22,73.45 156.11,73.35 154.36,73.35 154.26,73.45 154.26,74.37 154.34,74.44 155.74,74.44
+1.5V on TOP (solid shape): 91.09,41.88 91.09,41.86 91.09,41.85 91.2,41.53 91.52,41.42 91.53,41.43 91.55,41.42 95.13,37.84 95.13,37 95.05,36.93 93.88,36.93 90.02,40.79 90.02,40.81 89.13,41.69 89.13,42.51 89.19,42.56 90.4,42.56
+1.5V on TOP (solid shape): 212.4,37.15 212.76,37.15 212.96,36.95 212.96,36.24 212.65,35.94 211.84,35.94 209.48,38.3 206.43,38.3 206.22,38.08 205.58,38.08 205.14,37.64 200.16,37.64 198.3,35.78 198.3,29.97 198.66,29.61 198.66,28.67 198.51,28.52 197.85,28.52 197.75,28.62 197.75,29.1 197.16,29.69 197.16,31.22 197.16,31.23 197.19,31.36 197.16,31.49 197.16,31.5 197.16,36.29 199.7,38.83 203.32,38.83 203.51,38.78 203.7,38.83 204.27,38.83 204.52,38.73 204.77,38.82 204.79,38.83 204.86,38.83 205.47,39.44 210.11,39.44
+1.5V on BOTTOM (solid shape): 134.83,33.29 134.83,22.24 134.63,22.04 132.75,22.04 132.26,22.52 132.26,33.4 132.67,33.8 134.32,33.8
+1.5V on BOTTOM (solid shape): 204.78,187.09 204.78,185.44 204.65,185.31 203.64,185.31 203.51,185.44 203.51,186.07 203.13,186.46 203.13,187.6 203.38,187.85 204.02,187.85
+1.5V on BOTTOM (solid shape): 198.3,30.63 198.3,29.53 198.25,29.48 198.25,28.62 198.15,28.52 197.85,28.52 197.67,28.7 197.67,29.64 197.49,29.81 197.49,30.7 197.54,30.75 198.18,30.75
+1.5V on BOTTOM (solid shape): 200.22,47.61 200.22,47.31 200.48,47.05 200.78,47.05 200.82,47.01 200.82,47 200.98,46.81 201.22,46.74 202.23,46.74 202.37,46.77 202.5,46.83 202.74,46.83 203,46.74 203.27,46.82 203.28,46.83 203.36,46.83 203.87,47.34 204.42,47.34 204.46,47.33 204.47,47.29 204.47,47.19 204.77,46.89 204.77,46.09 203.89,45.21 201.58,45.21 201.3,45.49 199.27,45.49 198.94,45.82 198.91,45.82 198.81,45.92 198.81,47.59 198.96,47.75 200.08,47.75
+1.5V on BOTTOM (solid shape): outline of 96 points within 206.48,35.63 216.87,48.13
+1.5V on SVCC (solid shape): outline of 87 points within 132.52,22.25 213.42,80.46
+1.5V on IN1 (solid shape): 135.06,33.9 135.06,32.91 134.98,32.84 132.01,32.84 131.86,32.99 131.86,33.9 132.01,34.06 134.91,34.06
+1.5V on IN1 (solid shape): 157.97,74.59 157.97,73.43 157.61,73.07 155.73,73.07 155.53,73.27 155.53,74.47 155.76,74.7 157.87,74.7
+1.5V on IN1 (solid shape): 205.9,187.42 205.9,185.92 205.59,185.62 203.97,185.62 203.13,186.46 203.13,187.6 203.38,187.85 205.47,187.85
+1.5V on IN1 (solid shape): 214.06,66.11 214.17,66.1 214.27,66.11 215.27,66.11 215.68,65.7 215.68,64.05 215.19,63.57 212.58,63.57 212.45,63.7 212.45,66.03 212.53,66.11
+1.5V on IN1 (solid shape): 208.13,47.62 208.13,46.04 207.88,45.79 203.84,45.79 203.66,45.97 203.66,47.26 203.84,47.44 204.97,47.44 205.01,47.43 205.02,47.4 205.51,47.04 205.92,47.49 205.92,47.51 206.25,47.85 207.91,47.85
+1.5V on IN2 (solid shape): outline of 283 points within 33.51,46.81 59.47,57.54
+1.5V on IN2 (solid shape): outline of 491 points within 83.01,40.98 90.79,51.71
+1.05V_GFX on TOP (solid shape): 213.52,165.83 213.52,161.46 212.55,160.49 212.55,158.21 212.38,158.03 209.74,158.03 209.66,158.11 209.66,158.13 207.47,160.32 207.47,162 207.35,162.12 207.35,165.78 207.68,166.11 213.24,166.11
+1.05V_GFX on TOP (solid shape): outline of 150 points within 168.33,120.67 175.06,123.84
+1.05V_GFX on TOP (solid shape): outline of 482 points within 169.16,128.74 180.63,141.23
+1.05V_GFX on BOTTOM (solid shape): 207.02,156.33 207.02,155.14 206.99,155.11 206.28,155.11 206.18,155.21 206.18,156.23 206.33,156.38 206.97,156.38
+1.05V_GFX on BOTTOM (solid shape): 203.4,173.89 203.4,170.47 207.71,166.16 214.28,166.16 214.66,165.78 214.66,161.13 214.13,160.6 208.19,160.6 207.88,160.91 207.88,165.21 202.91,170.17 202.91,173.88 203.03,173.99 203.3,173.99
+1.05V_GFX on BOTTOM (solid shape): outline of 495 points within 169.09,128.25 175.88,141.4
+1.05V_GFX on IN1 (solid shape): outline of 4465 points within 154.41,118.21 212.49,173.79
+1.5VA on BOTTOM (solid shape): 201.76,31.47 201.76,31.36 201.71,31.31 200.72,31.31 200.6,31.2 200.55,31.2 199.92,30.56 199.92,30.51 199.9,30.5 199.9,28.9 199.8,28.8 198.51,28.8 198.43,28.87 198.43,29.33 198.53,29.43 198.53,30.6 198.68,30.75 199.88,30.75 200.62,31.49 201.73,31.49
+1.8V_S5 on TOP (solid shape): 151.19,108.6 151.19,107.84 151.3,107.73 151.44,107.59 152.46,107.59 152.71,107.84 152.71,108.22 152.84,108.35 153.24,108.35 153.32,108.27 153.32,107.18 152.48,106.34 152.48,106.08 152.46,106.06 152.46,105.05 151.85,104.44 150.93,104.44 150.81,104.57 150.81,107.21 150.55,107.46 150.55,108.22 150.3,108.48 149.54,108.48 149.31,108.71 149.32,108.71 149.32,109.66 149.41,109.75 150.04,109.75
+1.8V_S5 on TOP (solid shape): outline of 232 points within 152.74,74.23 161.27,100.2
+1.8V_S5 on BOTTOM (solid shape): 160.39,75.43 160.41,75.43 160.42,75.42 160.54,75.29 160.56,75.28 160.56,75.26 160.56,74.41 160.56,74.39 160.54,74.38 160.47,74.3 160.46,74.29 160.44,74.29 159.69,74.29 159.59,74.29 159.57,74.29 159.55,74.27 159.18,73.9 159.16,73.89 159.14,73.88 157.84,73.88 157.82,73.89 157.79,73.92 157.79,74.75 157.79,74.77 157.81,74.79 157.93,74.91 157.94,74.92 157.96,74.92 158.81,74.92 158.83,74.93 158.85,74.94 158.93,75.02 158.99,75.07 159.05,75.14 159.33,75.42 159.34,75.43 159.36,75.43
+1.8V_S5 on BOTTOM (solid shape): outline of 105 points within 148.6,102.47 153.38,106.02
+1.8V_S5 on IN1 (solid shape): 152.63,105.73 152.63,101.04 154.12,99.55 154.12,98.56 153.9,98.34 152.47,98.34 150.81,100 150.81,105.66 151.1,105.96 152.41,105.96
+1.35V_GFX on TOP (solid shape): outline of 25691 points within 161.91,110.38 224.21,171.6
+1.35V_GFX on BOTTOM (solid shape): 214.92,154.53 214.92,154.02 214.81,153.92 214.26,153.92 214.13,154.05 214.13,154.38 213.8,154.71 213.8,155.04 213.9,155.14 214.31,155.14
+1.35V_GFX on BOTTOM (solid shape): 227.13,123.84 227.13,122.32 226.69,121.88 224.4,121.88 223.96,121.43 221.16,121.43 220.78,121.81 218.75,121.81 218.24,122.32 218.24,123.08 218.75,123.59 222.05,123.59 222.81,124.35 226.62,124.35
+1.35V_GFX on BOTTOM (solid shape): 197.67,111.53 197.67,111.32 198.08,110.92 198.08,110.61 197.92,110.46 197.59,110.46 197.12,110.93 197.07,111.01 197,111.07 196.99,111.09 196.98,111.11 196.98,111.55 197.08,111.65 197.54,111.65
+1.35V_GFX on BOTTOM (solid shape): 222.62,179.28 222.62,178.93 222.68,178.87 223.15,178.87 223.48,178.55 223.48,178.27 223.35,178.14 223.06,178.14 222.79,178.42 222.23,178.42 222.13,178.51 222.13,179.13 221.79,179.47 220.8,179.47 220.75,179.52 220.75,179.91 220.81,179.97 221.93,179.97
+1.35V_GFX on BOTTOM (solid shape): 223.13,165.97 223.1,165.94 223.1,161.21 222.87,160.98 221.02,160.98 220.77,160.73 220.77,157.28 220.77,157.27 220.77,156.71 220.84,156.64 220.84,155.55 220.75,155.46 219.98,155.46 219.01,156.43 219.01,156.45 218.37,157.09 216.01,157.09 215.3,157.8 215.3,165.96 215.65,166.31 222.79,166.31
+1.35V_GFX on BOTTOM (solid shape): 170.42,160.85 170.44,160.85 170.6,160.68 170.79,160.63 170.81,160.63 170.83,160.62 170.9,160.54 170.91,160.53 170.98,160.39 171.12,160.32 171.13,160.31 171.24,160.21 171.24,160.19 171.34,159.94 171.6,159.85 171.67,159.82 171.7,159.76 171.77,159.61 171.91,159.52 171.92,159.52 172.03,159.41 172.03,159.41 171.87,159.25 171.86,159.24 171.77,159.17 171.71,159.07 171.71,159.06 171.56,158.91 171.52,158.91 171.47,158.92 171.46,158.96 171.4,159.16 171.23,159.27 171.17,159.3 171.15,159.37 171.03,159.65 170.74,159.73 170.72,159.72 170.7,159.73 170.66,159.77 170.66,159.79 170.6,159.97 170.44,160.06 170.38,160.1 170.36,160.17 170.26,160.43 170,160.53 169.97,160.54 169.85,160.66 169.83,160.71 169.84,160.81 169.93,160.85
+1.35V_GFX on BOTTOM (solid shape): outline of 303 points within 173.96,139.41 188.04,141.06
+1.35V_GFX on BOTTOM (solid shape): outline of 180 points within 188.59,124.27 191.08,138.07
+1.35V_GFX on BOTTOM (solid shape): outline of 1244 points within 164.95,152.57 173.13,167.33
+1.35V_GFX on IN1 (solid shape): outline of 147 points within 177.55,138.48 191.33,141.66
+1.35V_GFX on IN1 (solid shape): outline of 983 points within 188.55,123.72 192.21,139.13
+1.35V_GFX on IN1 (solid shape): outline of 1523 points within 170.47,163.04 201.28,169.51
+1.35V_GFX on IN1 (solid shape): outline of 1708 points within 213.95,116.73 219.94,150.49
+1.35V_GFX on IN2 (solid shape): 226.13,175.77 226.13,171.23 222.67,167.77 222.67,165.81 222.54,165.68 222.31,165.68 222.17,165.82 222.17,167.86 225.74,171.42 225.74,175.57 223.19,178.11 223.08,178.11 222.91,178.28 222.91,178.55 223.01,178.65 223.25,178.65
+1.35V_GFX on IN2 (solid shape): outline of 106 points within 188.21,136.08 191.47,141.37
+1.35V_GFX on IN2 (solid shape): outline of 535 points within 177.65,139.82 185.32,142.82
+1.35V_GFX on IN2 (solid shape): outline of 9248 points within 163.25,110.43 220.71,169.01
+1V_S5 on TOP (solid shape): 76.69,99.05 76.69,98.14 76,97.45 76,95.7 75.75,95.45 73.87,95.45 73.56,95.75 73.56,98.22 74.56,99.21 76.54,99.21
+1V_S5 on TOP (solid shape): 60.39,92.97 62.27,92.97 62.37,92.87 63.62,92.87 63.92,92.57 63.92,89.88 63.52,89.48 60.08,89.48 59.81,89.75 59.81,92.83 59.97,92.98 60.38,92.98
+1V_S5 on TOP (solid shape): outline of 2041 points within 128.09,109.96 144.84,127.93
+1V_S5 on BOTTOM (solid shape): 147.88,117.11 147.88,116.86 147.78,116.76 147.76,116.74 147.73,116.75 147.69,116.76 147.65,116.76 147.35,116.76 147.31,116.76 147.25,116.73 146.87,116.73 146.81,116.76 146.77,116.76 146.46,116.76 146.42,116.76 146.36,116.73 146.23,116.73 145.86,116.36 145.57,116.36 145.25,116.03 144.27,116.03 144.2,116.1 144.2,116.35 144.3,116.45 144.77,116.45 145,116.45 145,117.41 146.06,117.41 146.14,117.48 147.52,117.48
+1V_S5 on BOTTOM (solid shape): outline of 120 points within 59.74,86.15 76.76,99.08
+1V_S5 on SVCC (solid shape): outline of 810 points within 56.95,32.53 164.78,124.73
+1V_S5 on IN1 (solid shape): outline of 2168 points within 125.3,109.2 144.65,128.98
+1V_S5 on IN2 (solid shape): outline of 870 points within 126.84,108.84 134.6,117.87
+1V_SUS on TOP (solid shape): 77.78,106.37 77.78,104.74 79.05,103.47 79.05,99.13 78.09,98.17 77.1,98.17 77.04,98.22 77.04,103.86 76.87,104.03 76.87,104.18 76.88,104.2 76.94,104.42 76.87,104.64 76.87,106.34 76.94,106.42 77.73,106.42
+1V_SUS on BOTTOM (solid shape): 79.15,101.01 79.15,98.62 79.05,98.52 77.63,98.52 76.51,99.64 76.51,101.09 76.64,101.21 78.95,101.21
+1V_SUS on BOTTOM (solid shape): 135.31,130.5 135.31,129.86 135.24,129.79 134.32,129.79 134.22,129.69 134.22,129.51 134.02,129.31 133.86,129.31 133.69,129.48 133.69,130.35 134.09,130.75 135.06,130.75
+1V_VCCST on BOTTOM (solid shape): 133.28,129.74 133.28,129.46 133.12,129.3 133.12,128.9 133.1,128.9 132.78,128.58 132.43,128.58 132.26,128.42 132.26,126.82 131.6,126.16 130.84,125.4 130.72,125.36 130.63,125.45 130.63,126.15 131.76,127.27 131.76,129.03 132.64,129.92 133.1,129.92
+1V_VCCST on IN1 (solid shape): outline of 175 points within 93.27,129.18 104.73,137.56
+2.5V_SUS on TOP (solid shape): 153.57,61.64 153.57,54.9 150.23,51.56 150.23,48.98 149.41,48.15 148.34,48.15 148.1,48.39 148.1,50.02 148.62,50.54 149.81,50.54 149.81,52.23 150.15,52.57 150.15,52.6 151.72,54.17 151.72,54.34 151.86,54.49 151.97,54.76 151.86,55.03 151.72,55.17 151.72,59.94 151.19,60.47 148.22,60.47 148.1,60.59 148.02,60.59 147.88,60.73 147.5,60.73 147.38,60.85 147.38,62.25 148.01,62.88 152.33,62.88
+2.5V_SUS on BOTTOM (solid shape): 171.54,47.56 171.54,47.23 171.4,47.08 170.94,47.08 170.41,46.55 169.93,46.55 169.78,46.69 169.78,47.13 169.88,47.22 170.38,47.22 170.81,47.64 171.47,47.64
+2.5V_SUS on BOTTOM (solid shape): outline of 683 points within 148.52,43.89 163.51,64.54
+3V on TOP (solid shape): 26.78,62.86 26.78,60.52 26.57,60.32 26.17,60.32 25.66,60.83 25.66,62.91 25.74,62.99 26.65,62.99
+3V on TOP (solid shape): 149.99,188.84 149.99,188.06 149.87,187.93 145.47,187.93 145.37,188.03 145.37,188.82 145.5,188.95 149.89,188.95
+3V on TOP (solid shape): 156.29,78.05 156.29,75.3 156.19,75.2 155.61,75.2 155.45,75.05 155.45,74.85 155.28,74.67 154.46,74.67 154.36,74.77 154.36,77.54 154.03,77.87 151.01,77.87 150.65,78.23 150.65,79.42 150.86,79.62 154.72,79.62
+3V on TOP (solid shape): 54.01,53.41 57.23,53.41 57.41,53.23 57.41,51.63 57.16,51.38 54.92,51.38 54.64,51.1 52.76,51.1 52.51,50.85 51.24,50.85 50.88,51.2 50.88,53.38 51.19,53.69 53.73,53.69
+3V on TOP (solid shape): 135.79,182.09 135.79,181.15 135.54,180.89 134.93,180.89 134.85,180.82 134.85,180.8 134.59,180.54 134.59,180.05 134.36,179.82 133.05,179.82 132.87,180 132.87,181.79 132.93,181.84 133.6,181.98 134.25,182.2 134.26,182.2 135.68,182.2
+3V on TOP (solid shape): 157.67,118.64 157.79,118.6 157.92,118.58 157.96,118.58 157.99,118.56 157.99,118.54 158.05,118.37 158.15,118.23 158.27,118.11 158.27,116.88 158.18,116.79 157.9,116.79 157.6,117.09 157.6,117.66 157.54,117.72 157.54,118.51 157.66,118.64
+3V on TOP (solid shape): 19.84,46.12 19.84,45.33 20.28,44.9 22.03,44.9 22.21,44.72 22.21,43.56 22,43.35 19.64,43.35 19.44,43.56 19.44,43.94 19.72,44.22 19.72,44.41 19.76,44.66 19.63,44.89 19.62,44.91 19.61,44.93 19.61,46.12 19.64,46.15 19.82,46.15
+3V on TOP (solid shape): 17.86,46.07 17.86,45.97 17.85,45.96 17.81,45.85 17.79,45.73 17.79,44.68 17.79,44.67 17.78,44.65 17.66,44.44 17.68,44.17 17.66,44.15 17.43,43.91 17.43,43.53 17.3,43.4 16.06,43.4 15.86,43.61 15.86,44.62 16.01,44.77 17.23,44.77 17.61,45.16 17.61,46.1 17.66,46.15 17.79,46.15
+3V on TOP (solid shape): 25.2,56.51 25.2,55.16 25.06,55.02 24.94,55.02 24.86,54.93 23.58,54.93 22.79,54.15 22.79,51.45 21.75,50.41 20.63,50.41 20.59,50.45 20.59,51.25 20.58,51.25 20.58,51.51 21.72,52.65 21.72,52.69 21.73,52.7 21.76,52.76 21.77,52.83 21.77,53.11 21.76,53.18 21.73,53.24 21.72,53.25 21.72,53.28 21.57,53.44 21.16,53.44 21.11,53.49 21.11,53.99 20.96,54.15 19.06,54.15 18.9,53.99 18.9,53.66 18.75,53.51 16.26,53.51 16.06,53.72 16.06,54.78 16.41,55.14 20.88,55.14 21.27,55.52 21.27,56.36 21.55,56.64 25.08,56.64
+3V on TOP (solid shape): 118.83,170.1 118.83,169.13 118.83,168.98 119.03,168.78 121.98,168.78 122.13,168.63 122.13,168.24 121.75,167.86 120.17,167.86 120.14,167.88 120.12,167.91 119.74,168.27 119.36,167.91 119.36,167.89 119.33,167.86 118.79,167.86 118.56,168.1 118.47,168.1 118.27,168.29 118.27,169.49 118.02,169.74 117.94,169.74 117.94,169.74 116.67,169.74 116.26,169.34 116.26,169.29 116.06,169.09 116.06,168.94 115.96,168.84 114.97,168.84 114.9,168.77 113.8,168.77 112.22,167.2 112.22,165.76 109.81,163.34 109.33,163.34 109.23,163.44 109.23,164.28 110.72,165.78 110.72,167.05 110.84,167.55 110.88,168.06 110.94,168.18 112.65,169.89 114.44,169.89 114.44,169.89 116.07,169.89 116.3,170.12 116.67,170.12 116.85,170.31 118.62,170.31
+3V on TOP (solid shape): 157.94,93.47 157.94,92.57 157.88,92.48 157.77,92.51 157.1,92.25 157.77,91.99 157.88,92.01 157.94,91.92 157.94,82.01 156.84,80.91 154.53,80.91 154.49,80.87 152.54,80.87 151.24,82.17 151.24,85.52 155.15,89.43 155.15,90.16 155.15,90.18 155.16,90.19 155.28,90.49 155.16,90.8 155.15,90.81 155.15,90.83 155.15,91.27 155.15,91.28 155.1,91.68 154.74,91.87 154.46,91.87 154.07,91.49 153.88,91.49 153.7,91.66 153.7,92.15 153.96,92.4 154.92,92.4 155.15,92.63 155.15,92.69 155.15,92.7 155.18,92.86 155.15,93.01 155.15,93.03 155.14,93.05 154.97,93.23 154.74,93.3 153.99,93.3 153.89,93.28 153.79,93.25 153.78,93.24 153.74,93.25 153.65,93.34 153.65,93.95 153.88,94.18 154.23,94.18 154.46,93.95 154.5,93.91 154.57,93.85 154.59,93.84 154.77,93.8 154.95,93.84 154.96,93.85 155,93.85 155.15,94 155.15,94.51 154.8,94.86 154.77,94.96 154.84,95.03 155.01,95.67 154.37,95.5 154.3,95.43 154.2,95.45 154.03,95.63 153.75,95.63 153.65,95.73 153.65,97.02 153.75,97.12 154.29,97.12
+3V on TOP (solid shape): outline of 402 points within 188.17,53.06 220.48,65.5
+3V on BOTTOM (solid shape): 184.03,181.15 184.03,179.67 183.8,179.45 181.7,179.45 181.34,179.81 181.34,180.99 181.64,181.3 183.88,181.3
+3V on BOTTOM (solid shape): 66.07,115.44 66.07,114.07 65.87,113.86 64.85,113.86 64.75,113.96 64.75,115.34 64.95,115.54 65.97,115.54
+3V on BOTTOM (solid shape): 203.57,192.18 203.57,191.02 203.89,190.7 203.89,189.66 203.79,189.55 203.36,189.55 203.26,189.66 202.16,189.66 202.02,189.8 202.02,192.37 203.38,192.37
+3V on BOTTOM (solid shape): 201.35,43.02 201.35,42.19 201.28,42.12 201.28,40.74 201.21,40.67 200.21,40.67 200.21,40.66 200.19,40.62 200.16,40.61 199.85,40.61 199.65,40.81 199.65,43.1 199.88,43.33 201.05,43.33
+3V on BOTTOM (solid shape): 181.26,88.13 181.26,85.95 180.96,85.64 180.19,85.64 180.16,85.66 180.14,85.69 180.14,85.7 179.08,85.7 179.03,85.74 177.73,85.74 176.08,84.09 173.9,84.09 173.8,84.2 173.8,85.63 176.02,87.84 178.05,87.84 178.57,88.36 181.03,88.36
+3V on BOTTOM (solid shape): 58.12,53.69 58.12,53.55 57.38,53.55 57.31,53.55 57.31,53.35 58.12,53.35 58.12,53.21 57.56,52.65 57.56,51.68 57.52,51.68 57.21,51.38 54.41,51.38 54.36,51.43 54.36,53.23 54.53,53.4 54.59,53.45 54.62,53.46 56.39,53.46 56.44,53.51 56.5,53.55 56.54,53.61 57.08,53.61 57.23,53.75 58.06,53.75
+3V on BOTTOM (solid shape): 191.5,43.1 191.5,41.12 191.37,40.99 190.3,40.99 190.2,41.09 190.2,42.18 190.22,42.21 190.24,42.21 190.55,42.52 190.37,42.92 190.32,42.98 190.33,43.05 190.34,43.1 190.35,43.15 190.35,43.24 190.35,43.25 191.34,43.25
+3V on BOTTOM (solid shape): 135.49,181.83 135.49,180.82 135.44,180.73 135.34,180.73 134.91,180.72 134.76,180.32 134.74,180.24 134.66,180.2 134.22,180.2 134.09,180.33 134.09,181.05 133.99,181.15 133.31,181.15 133.13,181.33 133.13,181.71 133.43,182.01 133.43,182.03 133.62,182.22 135.11,182.22
+3V on BOTTOM (solid shape): 127.41,181.48 127.41,180.99 126.94,180.52 126.66,180.52 125.53,181.66 125.53,181.67 125.42,181.9 125.19,182.01 125.18,182.01 125.08,182.11 124.34,182.11 113.99,171.76 114,171.75 114,171.17 114.99,170.17 114.99,169.31 113.09,167.41 112.58,167.41 112.57,167.42 112.16,167.42 111.94,167.2 111.94,167.2 110.57,165.83 110.57,165.83 110.5,165.75 110.5,164.13 110.29,163.93 109.99,163.93 109.94,163.93 109.78,163.77 109.78,163.73 109.73,163.67 109.73,162.22 109.78,162.17 109.78,162.07 110.09,161.77 110.09,161.13 110.02,161.06 110.02,160.38 109.78,160.14 108.44,160.14 108.24,159.94 108.24,158.85 108.39,158.69 109.73,158.69 109.78,158.64 109.78,157.6 109.53,157.35 109.53,156.92 109.45,156.84 106.71,156.84 106.38,157.17 106.38,158.44 108.37,162.99 112.04,170.4 113.06,172.31 114.19,174.16 115.2,175.63 116.4,177.21 117.69,178.71 119.86,180.92 121.91,182.7 124.09,184.32 124.57,184.32
+3V on BOTTOM (solid shape): outline of 85 points within 157.41,105.1 159.23,108.57
+3V on BOTTOM (solid shape): outline of 100 points within 146.41,186.33 153.68,188.72
+3V on BOTTOM (solid shape): 173.87,101.7 174.16,101.7 174.17,101.69 174.3,101.67 174.43,101.69 174.44,101.7 174.53,101.7 175.11,101.11 175.11,100.2 175.1,100.17 175.06,100.15 172.85,100.15 172.82,100.17 172.8,100.2 172.42,100.58 172.04,100.2 172.04,100.18 172.01,100.15 162.56,100.15 162.48,100.2 162.47,100.3 162.13,100.86 161.8,100.3 161.79,100.2 161.71,100.15 160.38,100.15 160.31,100.18 160.28,100.25 160.11,100.54 159.78,100.58 159.69,100.6 159.65,100.68 159.65,101.32 160.1,101.77 168.43,101.77 168.68,101.52 169.3,101.52 169.47,101.34 170.85,101.34 171.41,101.9 173.67,101.9
+3V on BOTTOM (solid shape): outline of 2349 points within 16.01,40.53 26.98,74.31
+3V on IN1 (solid shape): 221.97,66.47 221.97,65.9 221.97,65.82 221.98,65.67 221.99,65.51 222.02,65.36 222.05,65.21 222.09,65.06 222.14,64.91 222.19,64.77 222.25,64.62 222.32,64.49 222.36,64.42 222.36,63.7 222.18,63.52 219.88,63.52 219.75,63.65 219.75,65.51 219.75,65.51 219.75,65.63 220.19,65.63 220.19,65.57 220.19,65.52 220.21,65.46 220.23,65.41 220.26,65.37 220.3,65.32 220.34,65.29 220.39,65.26 220.44,65.23 220.5,65.22 220.55,65.21 220.61,65.21 220.66,65.22 220.72,65.23 220.77,65.26 220.82,65.29 220.86,65.32 220.9,65.37 220.93,65.41 220.95,65.46 220.97,65.52 220.97,65.57 220.97,65.63 220.97,65.69 220.95,65.74 220.93,65.79 220.9,65.84 220.86,65.88 220.82,65.92 220.77,65.95 220.72,65.97 220.66,65.99 220.61,66 220.55,66 220.5,65.99 220.44,65.97 220.39,65.95 220.34,65.92 220.3,65.88 220.26,65.84 220.23,65.79 220.21,65.74 220.19,65.69 220.19,65.63 219.75,65.63 219.75,65.68 220.59,66.53 221.91,66.53
+3V on IN1 (solid shape): outline of 97 points within 184.54,41.5 202.06,58.87
+3V on IN1 (solid shape): outline of 198 points within 150.49,107.51 160.1,127.12
+3V on IN1 (solid shape): outline of 238 points within 173.58,86.13 179.1,101.59
+3V on IN1 (solid shape): outline of 367 points within 177.93,177.29 203.87,191.87
+3V on IN1 (solid shape): outline of 616 points within 153.32,87.8 161.88,105.68
+3V on IN1 (solid shape): outline of 2052 points within 26.18,55.72 151.85,188.77
+3V on IN1 (solid shape): outline of 3353 points within 50.79,36.39 157.71,85.19
+3V on IN2 (solid shape): outline of 258 points within 124.77,179.67 134.3,184.12
+3V on IN2 (solid shape): outline of 766 points within 30.56,42.36 52.76,57.98
+3V3_SATA_N1 on BOTTOM (solid shape): outline of 316 points within 156.32,88.97 180.9,106.04
+3V3_SD_SW on TOP (solid shape): 35.31,74.98 35.31,74.81 35.3,74.78 35.26,74.76 34.31,74.76 34.29,74.75 33.71,74.75 33.56,74.9 33.56,75.18 33.71,75.33 34.96,75.33
+3V3_TPM on BOTTOM (solid shape): 164.27,70.02 164.27,68.6 164.85,68.02 165.77,68.02 165.84,67.94 165.84,67.13 165.74,67.03 165.55,67.03 165.21,67.03 164.93,66.75 162.87,66.75 162.74,66.87 162.74,67.89 163.28,68.42 163.28,70 163.38,70.1 164.19,70.1
+3V3_TPM on SVCC (solid shape): 164.39,74.08 164.39,71.78 164.37,71.65 164.39,71.51 164.39,71.07 164.37,70.94 164.39,70.8 164.39,67.94 164.04,67.58 163.48,67.58 163.25,67.82 163.25,71.39 163.23,71.49 163.18,71.57 161.86,72.9 161.86,73.7 162.47,74.31 164.16,74.31
