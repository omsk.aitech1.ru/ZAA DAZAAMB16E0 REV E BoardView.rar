# Allegro board Quanta ZAA.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V3_TPM_VSB on BOTTOM (solid shape): 168.43,69.92 168.43,65.81 168.35,65.72 168.35,64.7 168.28,64.64 167.57,64.64 167.42,64.79 167.42,64.8 167.44,64.83 167.44,68.22 167.42,68.24 167.42,69.08 167.45,69.11 167.47,69.11 167.47,70.07 167.54,70.15 168.2,70.15
+3V_DMIC on TOP (solid shape): 80.87,89.92 80.87,88.91 80.7,88.74 79.66,88.74 79.47,88.93 79.47,89.94 79.62,90.09 80.7,90.09
+3V_DMIC on BOTTOM (solid shape): 81.77,90.09 81.77,87.75 81.46,87.45 80.8,87.45 80.55,87.7 79.53,89.26 79.53,89.93 79.92,90.32 81.54,90.32
+3V_DMIC on BOTTOM (solid shape): 173.51,84.76 173.51,84.19 173.03,83.71 170.31,83.71 169.83,83.23 168.67,83.23 168.59,83.31 168.59,84.14 169.28,84.84 169.97,84.84 169.98,84.86 173.41,84.86
+3V_EC on BOTTOM (solid shape): 189.92,42.29 189.92,39.77 189.77,39.62 189.77,38.6 189.59,38.42 189.21,38.42 189.06,38.27 189.06,38.24 189.04,38.19 189.04,38.14 189.03,37.8 189.02,37.78 188.55,37.31 186.52,37.31 186.49,37.33 186.49,37.43 186.51,37.47 186.54,37.48 187.23,37.48 187.28,37.48 187.34,37.5 187.98,37.5 188.04,37.55 188.05,37.57 188.07,37.57 188.11,37.57 188.11,37.63 188.12,37.64 188.12,38.94 188.19,39.04 188.3,39 188.96,39.35 188.22,39.26 188.22,39.24 188.19,39.21 188.17,39.21 188.13,39.22 188.12,39.26 188.12,39.52 188.86,40.25 188.86,42.26 188.96,42.36 189.85,42.36
+3V_GFX on TOP (solid shape): 188.98,125.09 188.98,124.56 189.16,124.38 189.9,124.38 190,124.28 190,124.02 189.82,123.84 189.31,123.84 189.19,123.72 187.97,123.72 187.76,123.92 187.76,124.14 188.3,124.68 188.3,125.09 188.43,125.22 188.85,125.22
+3V_GFX on TOP (solid shape): 176.64,128.31 176.64,127.93 176.66,127.91 176.66,127.67 176.58,127.59 176.57,127.59 176.47,127.55 176.41,127.47 176.36,127.46 176.31,127.47 176.23,127.56 176.11,127.6 175.83,127.6 175.67,127.53 175.6,127.37 175.6,127.33 175.52,127.25 175.2,127.25 175.2,127.26 175.2,127.35 175.14,127.5 174.98,127.56 174.88,127.57 174.83,127.58 174.08,127.58 174.08,127.22 174.07,127.19 174.03,127.17 173.82,127.17 173.79,127.15 172.01,127.15 171.76,126.89 171.76,126.82 171.71,126.77 171.71,126.71 171.51,126.51 171.13,126.51 171,126.64 171,126.65 171.35,127 171.37,127 171.72,127.24 171.7,127.67 171.7,127.7 171.71,127.73 171.89,127.91 172.08,127.91 172.09,127.91 172.21,127.89 172.32,127.91 172.33,127.91 173.66,127.91 173.67,127.91 173.95,127.91 174.15,128.1 174.15,128.1 174.19,128.14 175.73,128.14 175.74,128.15 175.75,128.16 175.91,128.25 176,128.41 176.02,128.44 176.51,128.44
+3V_GFX on BOTTOM (solid shape): 198.51,108.83 198.51,107.21 198.35,107.06 197.08,107.06 196.93,107.21 196.93,107.97 196.37,108.53 196.37,108.88 196.63,109.14 198.2,109.14
+3V_GFX on BOTTOM (solid shape): 175.64,127.91 175.64,127.3 175.53,127.2 174.58,127.2 174.42,127.37 173.51,127.37 173.13,127.75 173.13,127.93 173.26,128.05 173.51,128.05 173.66,127.9 173.97,127.9 174.16,128.09 174.69,128.09 174.72,128.11 175.43,128.11
+3V_GFX on BOTTOM (solid shape): 189.48,124.51 189.48,124.38 189.2,124.1 189.2,123.92 189.15,123.87 189.12,123.85 189.05,123.77 188.77,123.77 188.74,123.78 188.73,123.79 188.48,123.93 188.23,123.79 188.21,123.78 188.19,123.77 187.92,123.77 187.89,123.78 187.88,123.79 187.84,123.84 187.76,123.91 187.76,124.12 187.92,124.27 187.92,124.28 187.99,124.35 187.99,124.86 188.22,125.09 188.89,125.09
+3V_GFX on IN2 (solid shape): outline of 3172 points within 173.44,104.82 198.58,140.3
+3V_LAN on TOP (solid shape): 47.81,67.96 47.81,66.82 47.05,66.06 47.05,65.3 46.97,65.22 45.12,65.22 45.03,65.31 45.03,66.67 45.12,66.76 45.93,66.76 46.28,67.11 46.3,67.11 46.3,68 46.39,68.09 47.68,68.09
+3V_LDO_EC on TOP (solid shape): 177.37,56.81 177.37,54.86 177.25,54.73 175.88,54.73 175.8,54.81 175.8,56.84 175.98,57.02 177.17,57.02
+3V_LDO_EC on BOTTOM (solid shape): 189.69,48.88 189.69,47.06 189.57,46.93 188.19,46.93 188.04,47.09 188.04,47.83 188.32,48.11 188.32,48.27 188.33,48.33 188.32,48.39 188.32,48.64 188.78,49.09 189.48,49.09
+3V_LDO_EC on IN1 (solid shape): outline of 526 points within 176.54,48.24 192.94,57.17
+3V_MAIN on TOP (solid shape): 188.03,125.16 188.03,124.73 187.55,124.25 187.55,123.95 187.4,123.8 187,123.8 186.84,123.95 186.84,124.16 186.24,124.77 186.24,125.15 186.34,125.25 187.94,125.25
+3V_MAIN on BOTTOM (solid shape): 185.35,108.49 186.62,108.49 186.65,108.52 186.92,108.52 187.37,108.07 187.37,107.46 187.24,107.33 186.98,107.33 186.87,107.44 186.87,107.99 186.66,108.2 186.62,108.2 186.62,108.21 186.25,108.21 186.12,108.26 185.99,108.27 184.69,108.27 184.63,108.21 183.28,108.21 183.25,108.23 183.23,108.26 183.23,108.44 183.25,108.48 183.28,108.49 183.69,108.49 183.82,108.44 183.95,108.43 184.53,108.43 184.68,108.45 184.83,108.52 185.33,108.52
+3V_PCH_ME on TOP (solid shape): 178.62,56.56 178.62,53.33 178.73,53.22 180.13,53.22 180.32,53.03 180.32,52.22 180.19,52.09 177.76,52.09 177.55,52.29 177.55,56.53 177.7,56.69 178.49,56.69
+3V_S5 on TOP (solid shape): 177.37,54.12 177.37,52.62 177.12,52.37 175.29,52.37 175.11,52.55 175.11,54.12 175.29,54.3 177.2,54.3
+3V_S5 on TOP (solid shape): 182.45,35.5 182.45,35.12 182.3,34.97 181.26,34.97 180.73,35.5 179.91,35.5 179.76,35.66 179.76,36.09 179.84,36.16 181.79,36.16
+3V_S5 on TOP (solid shape): 48.4,64.71 48.4,63.77 48.1,63.47 46.89,63.47 46.71,63.3 45.89,63.3 45.82,63.37 45.82,64.83 45.97,64.98 47.04,64.98 47.42,65.36 47.75,65.36
+3V_S5 on TOP (solid shape): 33.39,104.28 34.19,104.28 34.28,104.2 34.28,103.86 34.15,103.73 34.05,103.73 33.48,103.16 33.48,101.29 33.24,101.05 31.28,101.05 31.12,101.22 31.12,101.79 31.23,101.9 32.15,101.9 32.39,102.13 32.39,103.04 31.85,103.58 29.4,103.58 29.17,103.81 29.17,104.22 29.23,104.29 33.38,104.29
+3V_S5 on TOP (solid shape): 151.7,113.52 154.04,113.52 154.26,113.75 160.68,113.75 161.65,112.78 161.65,110.03 161.5,109.87 159.7,109.87 159.09,110.48 159.09,111.48 158.17,112.39 157.31,112.39 157.25,112.45 151.53,112.45 151.53,112.45 150.53,112.45 150.53,112.44 150.49,112.44 150.17,112.11 150.17,111.29 150.02,111.14 149.06,111.14 148.98,111.21 148.98,112.98 149.15,113.15 149.19,113.15 149.19,114.1 149.28,114.19 151.03,114.19
+3V_S5 on TOP (solid shape): 31.38,112.82 31.54,112.82 31.63,112.8 31.72,112.8 31.74,112.79 31.86,112.67 31.86,112.14 31.8,112.08 31.78,112.08 31.71,112.07 31.65,112.04 31.64,112.03 31.42,112.03 31.4,112.04 31.34,112.07 31.28,112.08 31,112.08 30.93,112.07 30.87,112.04 30.86,112.03 30.71,112.03 30.44,111.75 29.6,111.75 29.47,111.88 29.47,112.92 29.62,113.08 31.12,113.08
+3V_S5 on TOP (solid shape): 52.74,58.31 52.76,58.31 52.78,58.3 53.49,57.59 56.86,57.59 57.09,57.36 57.1,57.35 57.11,57.33 57.11,55.46 57.1,55.44 57.09,55.43 57.07,55.41 57.05,55.4 57.03,55.39 54.66,55.39 54.6,55.4 54.51,55.4 54.49,55.41 54.29,55.47 54.09,55.41 54.06,55.4 53.79,55.4 53.77,55.4 53.75,55.39 53.14,54.78 53.13,54.77 53.11,54.77 50.39,54.77 50.37,54.77 50.35,54.78 50.02,55.11 50.01,55.13 50.01,55.14 50.01,58.01 50.01,58.03 50.02,58.04 50.28,58.3 50.29,58.31 50.31,58.31
+3V_S5 on TOP (solid shape): outline of 159 points within 140.65,113.68 150.53,117.75
+3V_S5 on TOP (solid shape): 166.72,73.51 166.75,73.43 166.55,73.08 166.66,72.78 166.69,72.71 166.57,72.38 166.67,72.12 166.7,72.05 166.67,71.98 166.57,71.64 166.79,71.36 166.8,71.36 166.83,71.31 166.83,71.14 166.8,71.12 166.57,70.77 166.8,70.42 166.83,70.41 166.83,69.37 166.44,68.98 163.81,68.98 163.78,68.96 163.61,68.96 163,68.35 162.49,68.35 161.35,69.49 161.35,72.21 161.58,72.44 163.51,72.44 163.96,71.98 164.33,71.98 164.41,71.93 164.41,71.83 164.37,71.58 164.49,71.37 164.52,71.29 164.49,71.22 164.75,70.55 165.01,71.22 164.98,71.29 165.01,71.37 165.13,71.62 165.05,71.89 165.04,71.91 165.04,71.96 165.08,71.98 165.13,71.98 165.36,72.21 165.36,73.48 165.51,73.63 166.6,73.63
+3V_S5 on TOP (solid shape): outline of 1006 points within 118.47,12.77 191.94,23.31
+3V_S5 on BOTTOM (solid shape): 54.29,104.36 54.29,103.12 54.13,102.97 50.6,102.97 50.32,103.25 50.32,104.24 50.63,104.54 54.11,104.54
+3V_S5 on BOTTOM (solid shape): 191.67,40.4 191.67,38.31 191.58,38.22 190.71,38.22 190.58,38.35 190.58,39.26 190.18,39.67 190.18,40.61 190.25,40.69 191.38,40.69
+3V_S5 on BOTTOM (solid shape): 195.99,34.94 195.99,33.22 195.87,33.09 195.41,33.09 195.33,33.17 195.33,33.98 194.72,34.59 194.72,34.92 194.85,35.05 195.89,35.05
+3V_S5 on BOTTOM (solid shape): 158.74,35.34 158.74,34.71 158.42,34.39 158.42,33.25 158.11,33.25 158.11,34.32 157.96,34.47 157.48,34.95 157.48,35.35 157.62,35.49 158.59,35.49
+3V_S5 on BOTTOM (solid shape): 84.41,124.28 84.41,122.57 84.47,122.51 84.47,122.35 84.59,122.23 84.59,122.14 84.44,121.99 83.42,121.99 83.27,122.14 83.27,122.45 83.95,123.13 83.95,124.25 84.03,124.33 84.36,124.33
+3V_S5 on BOTTOM (solid shape): 49.57,64.9 49.57,63.93 52,61.51 52,54.93 51.77,54.71 50.32,54.71 49.99,55.03 49.99,58.29 49.98,58.3 49.98,60.4 47.24,63.14 47.21,63.18 47.18,63.21 47.18,65.25 47.28,65.35 49.13,65.35
+3V_S5 on BOTTOM (solid shape): 57.77,57.3 57.77,56.2 58.15,55.82 58.15,55.63 58.07,55.55 57.31,55.55 57.31,55.35 58.11,55.35 58.15,55.31 58.15,55.21 58.08,55.15 57.38,55.15 57.27,55.15 56.95,55.47 54.59,55.47 54.39,55.67 54.39,57.27 54.54,57.42 54.57,57.42 54.72,57.58 57.49,57.58
+3V_S5 on BOTTOM (solid shape): 39.27,113.99 39.27,112.92 39.07,112.72 37.63,112.72 36.59,111.68 30.46,111.68 30.31,111.83 30.31,112.59 30.56,112.85 31.49,112.85 31.68,112.8 31.87,112.85 32.19,112.85 32.21,112.84 32.23,112.82 32.57,112.62 32.91,112.82 32.91,112.83 32.94,112.85 33.05,112.85 34.58,114.37 38.89,114.37
+3V_S5 on BOTTOM (solid shape): outline of 667 points within 162.77,47.77 189.39,66.41
+3V_S5 on SVCC (solid shape): outline of 89 points within 44.89,14.24 122.23,58.44
+3V_S5 on IN1 (solid shape): 54.97,104.29 54.97,103.19 54.74,102.97 51.47,102.97 51.36,103.07 51.36,104.26 51.64,104.54 54.72,104.54
+3V_S5 on IN1 (solid shape): 153.14,118.18 153.14,116.4 152.48,115.74 152.47,115.73 152.38,115.66 152.31,115.57 152.28,115.54 152.27,115.39 152.28,115.28 152.28,114.86 152.23,114.81 152.22,114.81 151.89,114.44 152.18,114.04 152.2,114.04 152.28,113.95 152.28,112.54 151.97,112.24 149.87,112.24 149.61,112.49 149.61,115.51 149.54,115.59 149.54,116.21 150.2,116.87 150.79,116.87 152.34,118.42 152.9,118.42
+3V_S5 on IN1 (solid shape): outline of 264 points within 46.74,63.8 52.81,79.34
+3V_S5 on IN1 (solid shape): outline of 562 points within 157,59.96 169.47,112.16
+3V_S5 on IN1 (solid shape): outline of 679 points within 184.99,12.92 195.41,48.98
+3V_WLAN on BOTTOM (solid shape): 206.05,190.14 206.05,187.96 206.05,187.94 206.04,187.92 205.93,187.74 205.94,187.53 205.95,187.52 205.94,187.49 205.8,187.34 204.78,187.34 204.15,187.98 203.33,187.98 203.33,187.98 202.32,187.98 202.24,188.06 202.24,189.38 202.34,189.48 203.21,189.48 203.33,189.35 204.2,189.35 204.69,189.85 204.69,190.33 204.76,190.39 205.8,190.39
+3VPCU on TOP (solid shape): 80.88,13.86 80.88,10.1 80.68,9.9 79.38,9.9 79.25,10.03 79.25,13.76 79.46,13.96 80.78,13.96
+3VPCU on TOP (solid shape): 79.61,43.58 79.61,42.23 79.51,42.13 78.75,42.13 78.29,42.59 78.29,42.97 77.12,44.14 77.12,45.23 77.3,45.41 77.78,45.41
+3VPCU on TOP (solid shape): 51.04,49.07 51.04,48.85 49.84,47.64 48.57,47.64 48.52,47.7 48.52,48.84 48.61,48.94 48.88,48.94 48.89,48.93 49.58,48.93 49.9,49.25 50.86,49.25
+3VPCU on TOP (solid shape): 50.2,70.13 50.2,69.06 50.45,68.81 50.45,67.36 50.32,67.23 48.42,67.23 48.24,67.41 48.24,68.29 48.31,68.46 48.3,68.65 48.29,68.68 48.42,68.81 48.42,69.53 48.52,69.79 48.46,70.05 48.44,70.08 48.61,70.25 50.08,70.25
+3VPCU on TOP (solid shape): 163.05,54.88 163.05,54.33 162.95,54.22 161.37,54.22 157.33,54.22 157.31,54.2 157.29,54.2 157.06,54.09 156.95,53.86 156.95,53.84 156.66,53.55 156.63,53.55 156.18,53.11 155.48,53.11 155.28,52.9 155.14,52.9 152.14,49.9 152.14,49.77 152.13,49.75 151.82,49.75 151.62,49.96 151.62,51.07 155.58,55.04 155.6,55.04 155.83,55.15 155.93,55.37 155.94,55.39 156.04,55.49 162.44,55.49
+3VPCU on TOP (solid shape): outline of 140 points within 203.09,179.47 209.39,192.76
+3VPCU on TOP (solid shape): outline of 81 points within 50.5,11.48 60.48,23.06
+3VPCU on TOP (solid shape): outline of 537 points within 161.17,73.93 179.63,103.98
+3VPCU on BOTTOM (solid shape): 207.61,192.45 207.61,191.18 207.36,190.93 205.96,190.93 205.78,191.12 205.78,192.49 205.91,192.62 207.43,192.62
+3VPCU on BOTTOM (solid shape): 163.12,54.81 163.12,54.3 163.11,54.26 163.07,54.25 160.62,54.25 160.62,54.25 160.03,54.25 159.98,54.3 159.98,55.19 160.1,55.32 161.68,55.32 161.85,55.49 162.44,55.49
+3VPCU on BOTTOM (solid shape): 208.87,181.91 208.87,179.6 210.29,178.18 210.29,176.22 210.17,176.09 208.3,176.09 208.26,176.11 208.24,176.14 208.24,177.15 208.05,177.15 208.05,176.14 208.03,176.11 208,176.09 207.8,176.09 207.76,176.11 207.75,176.14 207.75,177.15 207.73,177.16 207.73,178.99 207.37,179.34 203.89,179.34 203.08,180.16 203.08,182.15 203.87,182.94 207.84,182.94
+3VPCU on BOTTOM (solid shape): 50.81,67.46 50.81,65.98 53.6,63.19 53.6,62.94 53.59,62.92 53.59,58.15 53.6,58.13 53.6,58.11 54.06,57.65 54.06,55.42 54.05,55.4 54.04,55.38 53.9,55.1 54.02,54.82 54.06,54.78 54.06,54.06 54.01,53.87 54.06,53.68 54.06,50.44 51.59,47.98 50.07,47.98 49.94,48.1 49.94,49.17 50.12,49.35 51.14,49.35 52.89,51.1 52.89,52.88 52.2,53.56 52.2,62.66 48.85,66.01 48.85,67.2 49.59,67.94 50.32,67.94
+3VPCU on BOTTOM (solid shape): outline of 100 points within 59.42,44.42 74.3,57.96
+3VPCU on SVCC (solid shape): 166.22,81.91 166.22,61.6 161.8,58.62 164.78,54.2 164.78,53.39 163,53.39 160.53,55.85 160.53,60.29 160.94,60.7 161.44,60.74 161.48,61.23 163.18,62.93 163.23,63.02 163.25,63.12 163.25,66.89 163.43,67.08 164.14,67.08 164.24,67.09 164.32,67.15 164.83,67.66 164.88,67.74 164.9,67.84 164.9,70.59 165.13,70.94 164.9,71.29 164.9,71.3 165.13,71.65 164.9,72 164.9,74.82 164.88,74.92 164.83,75 163.89,75.94 163.89,81.07 164.83,82.01 164.86,82.05 164.88,82.09 165.03,82.24 165.89,82.24
+3VPCU on IN1 (solid shape): 179.58,103.78 179.58,102.38 179.66,102.31 179.66,101.54 179.43,101.32 178.97,101.32 178.62,101.67 178.62,101.7 178.59,101.7 178.14,102.15 178.14,103.83 178.47,104.16 179.2,104.16
+3VPCU on IN1 (solid shape): outline of 1071 points within 203.26,100.27 225.96,182.65
+3VPCU on IN1 (solid shape): outline of 1850 points within 77.12,40.5 152.79,51.63
+3VPCU on IN2 (solid shape): 180.52,103.83 180.52,102.74 180.3,102.51 179.27,102.51 178.14,103.64 178.14,104.26 178.44,104.57 179.79,104.57
+3VPCU on IN2 (solid shape): 208.77,101.42 208.77,100.25 208.62,100.1 205.92,100.1 205.77,100.25 205.77,101.49 205.88,101.6 208.59,101.6
+3VPCU on IN2 (solid shape): outline of 388 points within 49.51,42.97 78.8,55.37
+3VPCU_EC on TOP (solid shape): 174.62,40.76 174.81,40.71 175,40.76 176.16,40.76 176.34,40.58 179.66,40.58 179.89,40.36 180.3,40.36 180.66,40.72 181.3,40.72 181.46,40.56 181.46,39.93 180.54,39.01 178.61,39.01 178.58,39.02 178.56,39.01 177.51,39.01 177.47,39.04 177.46,39.05 177.31,39.23 177.09,39.29 177.06,39.3 176.25,39.3 176.24,39.33 176,39.57 175.66,39.53 175.59,39.53 175.45,39.67 174.93,39.67 174.92,39.67 174.24,39.67 174.23,39.67 173.95,39.67 173.8,39.53 173.75,39.5 173.68,39.51 173.62,39.54 173.61,39.55 173.29,39.67 173.01,39.48 172.87,39.48 172.84,39.47 172.8,39.48 172.39,39.33 172.39,38.88 172.42,38.85 172.45,38.78 172.42,38.71 172.36,38.61 172.32,38.5 172.33,38.34 172.41,38.2 172.44,38.17 172.14,37.87 172.14,35.74 168.86,32.46 167.9,32.46 167.8,32.56 167.8,33.52 167.95,33.67 168.4,33.67 170.82,36.1 170.82,38.93 170.12,39.63 170.12,39.99 170.9,40.76
+3VPCU_EC on TOP (solid shape): outline of 508 points within 177.96,24.61 193,49.19
+3VPCU_EC on BOTTOM (solid shape): 188.2,48.44 188.2,48.16 187.86,47.83 187.86,46.54 187.7,46.38 187.7,45.77 187.68,45.73 187.65,45.71 186.72,45.71 186.59,45.84 186.59,48.32 186.86,48.59 188.05,48.59
+3VPCU_EC on BOTTOM (solid shape): 185.4,45.31 185.4,44.95 184.38,43.94 183.01,43.94 182.89,43.81 182.88,43.8 182.88,42.33 182.86,42.31 182.71,42.31 182.68,42.34 182.68,44.37 183,44.69 183.02,44.69 183.04,44.7 183.42,44.7 183.67,44.95 183.67,45.38 183.8,45.51 185.2,45.51
+3VPCU_EC on BOTTOM (solid shape): 170.62,39.92 170.78,39.92 170.78,39.9 172.27,39.9 172.29,39.87 172.29,39.72 172.27,39.7 170.78,39.7 170.78,39.69 170.69,39.69 170.41,39.42 170.25,39.42 170.25,39.41 170.06,39.41 170,39.35 170,38.75 169.98,38.65 170,38.55 170,37.6 167.86,35.46 167.29,35.46 166.94,35.12 166.94,34.78 166.88,34.71 166.47,34.71 166.43,34.75 166.43,35.43 167.04,36.04 167.44,36.04 169.45,38.05 169.45,39.79 169.74,40.08 170.47,40.08
+3VPCU_EC on BOTTOM (solid shape): 178.83,28.11 178.87,28.1 178.88,28.06 178.88,26.6 178.91,26.6 178.95,26.56 178.95,26.47 179.04,26.47 179.41,26.11 179.41,25.5 179.43,25.47 179.44,25.45 179.44,25.43 179.45,25.25 179.54,25.1 179.55,25.08 179.56,25.06 179.56,24.81 179.43,24.68 178.57,24.68 178.36,24.89 178.36,26.26 178.58,26.47 178.61,26.47 178.61,26.5 178.67,26.56 178.67,26.6 178.68,26.6 178.68,28.1 178.7,28.11
+3VPCU_EC on IN1 (solid shape): 184.71,45.03 184.71,42.09 182.41,39.79 182.41,39.73 181.36,38.68 180.42,38.68 180.17,38.93 180.17,39.85 180.78,40.47 180.78,40.69 181.06,40.97 181.45,40.97 181.45,40.91 181.46,40.86 181.47,40.8 181.5,40.75 181.53,40.7 181.57,40.66 181.61,40.62 181.66,40.59 181.71,40.57 181.76,40.55 181.82,40.55 181.87,40.55 181.93,40.55 181.98,40.57 182.03,40.59 182.08,40.62 182.12,40.66 182.16,40.7 182.19,40.75 182.21,40.8 182.23,40.86 182.24,40.91 182.24,40.97 182.23,41.02 182.21,41.08 182.19,41.13 182.16,41.18 182.12,41.22 182.08,41.26 182.03,41.29 181.98,41.31 181.93,41.32 181.87,41.33 181.82,41.33 181.76,41.32 181.71,41.31 181.66,41.29 181.61,41.26 181.57,41.22 181.53,41.18 181.5,41.13 181.47,41.08 181.46,41.02 181.45,40.97 181.06,40.97 182.89,42.79 182.89,44.72 183.24,45.08 184.66,45.08
+3VPCU_EC on IN2 (solid shape): outline of 90 points within 179.63,43.38 184.23,45.92
+3VPCU_ECPLL on BOTTOM (solid shape): 187.53,45.36 187.53,44.34 187.4,44.21 187.31,44.22 187.22,44.2 187.09,44.13 187,44.03 187,44.03 185.65,44.03 185.45,44.01 185.36,43.93 185.35,43.93 185.35,43.91 185.27,43.83 185.27,42.34 185.25,42.31 185.1,42.31 185.08,42.33 185.08,43.8 185.07,43.8 185.07,44.07 185.79,44.8 185.79,44.81 185.86,44.88 185.86,45.41 185.96,45.51 187.38,45.51
+5V on TOP (solid shape): 20.58,58.54 20.58,56.69 20.4,56.51 19.13,56.51 18.85,56.79 18.85,58.57 18.98,58.69 20.43,58.69
+5V on TOP (solid shape): 116.85,173.53 116.94,173.48 116.95,173.39 117.17,172.89 117.66,173.12 117.74,173.18 117.83,173.16 117.93,173.06 119.05,173.06 119.24,173.09 119.41,173.18 119.44,173.19 119.47,173.18 119.95,173.07 120.34,173.38 120.41,173.43 120.5,173.4 120.73,173.17 120.73,172.74 120.12,172.13 119.11,172.13 119.11,172.13 115.8,172.13 115.7,172.13 115.21,171.64 115.21,170.29 115.12,170.2 113.77,170.2 113.65,170.33 113.65,172.54 114.64,173.53
+5V on BOTTOM (solid shape): 212.73,43.81 213.36,43.81 213.39,43.78 213.39,43.77 214.44,43.77 214.56,43.66 214.56,42.29 214.26,41.98 209.61,41.98 209.48,42.11 209.48,44.01 209.63,44.17 212.38,44.17
+5V on BOTTOM (solid shape): 14.81,87.8 14.81,87.52 14.64,87.35 14.64,85.99 13.89,85.25 12.89,85.25 12.73,85.4 12.73,86.12 12.45,86.39 10.87,86.39 10.75,86.51 10.75,87.11 10.87,87.23 11.72,87.23 12.24,87.75 14.1,87.75 14.31,87.95 14.66,87.95
+5V on BOTTOM (solid shape): 221,45.17 221.02,45.17 221.04,45.16 221.09,45.1 221.09,43.33 221.46,42.96 222.17,42.96 222.34,42.79 222.34,41.88 222.15,41.69 220.66,41.69 219.59,42.75 219.59,45.05 219.69,45.16 219.71,45.17 219.73,45.17
+5V on BOTTOM (solid shape): 202.6,24.94 202.6,23.91 203.09,23.41 206,23.41 206.24,23.17 206.24,20.52 206.14,20.41 205.2,20.41 205.2,20.42 204.32,20.42 204.24,20.5 204.24,21.21 204.31,21.27 205.39,21.27 205.49,21.38 205.49,22.33 205.36,22.46 202.73,22.46 202.34,22.07 200.27,22.07 200.06,22.28 200.06,24.61 200.31,24.86 200.98,24.86 201.11,24.99 202.55,24.99
+5V on BOTTOM (solid shape): 227.44,101.84 227.44,101.16 227.42,101.13 227.12,101 227.01,100.73 227.01,100.61 226.37,99.97 221.09,99.97 220.97,100.1 220.11,100.1 219.92,100.28 219.92,101.65 220.17,101.9 222.88,101.9 222.9,101.9 222.91,101.89 223,101.8 224.22,101.8 224.26,101.77 224.45,101.77 224.99,102.31 226.97,102.31
+5V on BOTTOM (solid shape): outline of 93 points within 220.53,126.54 231.27,147.21
+5V on BOTTOM (solid shape): outline of 156 points within 55.25,13.51 63.02,20.12
+5V on SVCC (solid shape): outline of 88 points within 173.01,9.37 232.01,129.05
+5V on IN1 (solid shape): 67.99,117.73 67.99,115.85 67.77,115.63 63.96,115.63 63.62,115.96 63.62,117.63 63.87,117.88 67.84,117.88
+5V on IN1 (solid shape): 221.53,146.16 221.53,143.21 221.42,143.1 220.53,143.1 220.35,143.28 220.35,146.1 220.53,146.27 221.42,146.27
+5V on IN1 (solid shape): 14.94,87.8 14.94,87.24 14.94,87.24 14.9,87.07 14.94,86.91 14.94,86.9 14.94,86.53 14.71,86.3 12.04,86.3 11.98,86.33 11.91,86.34 11.66,86.58 11.66,87.24 11.89,87.47 11.91,87.48 12.07,87.57 12.17,87.74 12.17,87.75 12.33,87.9 14.84,87.9
+5V on IN1 (solid shape): outline of 276 points within 118.83,172.18 137.67,181.5
+5V on IN1 (solid shape): outline of 397 points within 17.46,55.93 20.81,72.84
+5V on IN1 (solid shape): outline of 426 points within 26.27,63.7 40.95,84.93
+5V on IN1 (solid shape): outline of 1433 points within 192.61,22.47 222.4,47.31
+5V on IN1 (solid shape): outline of 2139 points within 54.24,9.06 181.06,26.86
+5V on IN2 (solid shape): outline of 88 points within 18.47,59.71 27.49,65.91
+5V_HDD on BOTTOM (solid shape): 230.61,53.39 230.61,50.27 230.27,49.93 230.25,49.89 230.22,49.87 230.11,49.87 228.84,48.61 228.84,47.55 225.89,44.6 223.25,44.6 222.48,45.36 221.52,45.36 221.38,45.5 219.63,45.5 219.54,45.58 219.54,47.12 219.84,47.42 222.46,47.42 222.99,47.95 225.55,47.95 226.52,48.91 226.52,50.08 229.93,53.49 230.51,53.49
+5V_KB on BOTTOM (solid shape): 225.35,143.77 226.1,143.02 226.12,142.98 226.12,140.87 225.9,140.64 225.86,140.63 225.12,140.63 225.08,140.61 224.48,140.61 224.1,140.97 224.06,140.99 223.21,140.99 222.83,141.36 222.81,141.39 222.81,142.24 222.83,142.27 223.34,142.78 223.96,142.78 223.96,142.73 223.97,142.67 223.99,142.62 224.01,142.57 224.05,142.52 224.08,142.48 224.13,142.45 224.18,142.42 224.23,142.4 224.28,142.39 224.34,142.39 224.39,142.39 224.45,142.4 224.5,142.42 224.55,142.45 224.59,142.48 224.63,142.52 224.67,142.57 224.69,142.62 224.71,142.67 224.72,142.73 224.72,142.78 224.71,142.84 224.7,142.89 224.68,142.94 224.65,142.99 224.61,143.03 224.57,143.07 224.53,143.1 224.48,143.12 224.42,143.14 224.37,143.15 224.31,143.15 224.26,143.14 224.2,143.12 224.15,143.1 224.11,143.07 224.06,143.03 224.03,142.99 224,142.94 223.98,142.89 223.96,142.84 223.96,142.78 223.34,142.78 224.32,143.77 224.36,143.78 225.33,143.78
+5V_ODD on BOTTOM (solid shape): outline of 104 points within 222.07,102.06 226.8,106
+5V_PVDD on BOTTOM (solid shape): 199.17,38.35 199.17,36.32 199.76,35.72 199.76,34.87 199.79,34.84 199.79,34.81 200.69,33.91 200.8,33.91 200.8,33.91 201.76,33.91 201.78,33.88 201.78,33.73 201.76,33.7 200.62,33.7 199.63,34.7 198.63,34.7 198.63,34.69 198.43,34.49 198.43,31.47 198.61,31.29 199.85,31.29 200.49,31.93 200.78,31.93 200.8,31.91 201.78,31.91 201.78,31.9 201.78,31.72 201.76,31.7 200.8,31.7 200.8,31.7 200.59,31.7 199.89,31 197.86,31 197.62,31.24 197.62,38.25 197.85,38.48 199.04,38.48
+5V_S5 on TOP (solid shape): 176.43,11.91 176.43,9.47 176.16,9.19 171.41,9.19 171.1,9.49 171.1,11.88 171.51,12.29 176.05,12.29
+5V_S5 on TOP (solid shape): 21.39,39.85 21.39,38.7 21.34,38.65 20.66,38.65 20.2,39.11 18.47,39.11 18.34,39.24 18.34,40.13 18.47,40.25 20.99,40.25
+5V_S5 on TOP (solid shape): 135.24,13.43 135.24,12.57 134.88,12.21 134.73,12.21 134.24,11.72 134.24,11.72 134.14,11.62 134.14,11.1 133.85,10.81 131.55,10.81 131.43,10.93 131.43,11.32 131.63,11.65 131.43,11.99 131.43,12.85 132.29,13.71 134.96,13.71
+5V_S5 on BOTTOM (solid shape): 216.36,32.96 216.36,31.01 216.44,30.93 216.44,30.55 216.29,30.4 215.47,30.4 214.15,31.72 214.15,32.84 214.46,33.14 216.19,33.14
+5V_S5 on BOTTOM (solid shape): 62.24,23.72 62.82,23.72 63.02,23.51 63.02,21.92 62.26,21.92 62.18,21.92 62.18,21.72 62.91,21.72 63.02,21.72 63.02,21.58 62.96,21.52 62.09,21.52 61.75,21.86 60.22,21.86 60.21,21.9 60.02,22.1 59.75,22.13 59.49,21.89 59.54,21.53 59.55,21.52 59.55,21.44 59.06,20.95 55.38,20.95 54.9,21.43 54.9,23.67 55.1,23.87 59.42,23.87 59.67,24.12 61.83,24.12
+5V_S5 on SVCC (solid shape): 106.36,21.5 106.36,16.15 106.37,16.05 106.43,15.97 108.59,13.81 108.67,13.75 108.77,13.74 131.65,13.74 133.53,11.85 133.53,10.92 133.3,10.69 129.32,10.69 129.19,10.82 129.11,10.87 129.01,10.89 107.27,10.89 103.56,14.6 103.54,18.91 103.56,20.08 103.54,20.19 103.48,20.27 100.93,22.8 100.84,22.86 100.74,22.88 78.39,22.85 78.29,22.83 78.21,22.77 73.05,17.6 72.76,17.48 72.65,17.2 72.47,17.02 72.39,16.96 72.34,16.89 71.86,16.4 57.6,16.4 57.53,16.41 57.46,16.4 55.28,16.4 54.67,17.02 54.67,22.93 55.25,23.51 57.1,23.51 57.84,22.77 57.84,21.62 57.86,21.52 57.92,21.43 59.34,20.01 59.42,19.95 59.52,19.93 63.33,19.93 63.68,19.7 64.03,19.93 65.46,19.93 65.72,19.83 65.97,19.93 69.37,19.93 69.47,19.95 69.55,20.01 75.19,25.65 102.19,25.67
+5V_S5 on IN1 (solid shape): 203.08,11.37 203.08,9.1 202.76,8.78 199.37,8.78 199.07,9.09 199.07,11.3 199.35,11.59 202.86,11.59
+5V_S5 on IN1 (solid shape): 217.06,32.24 217.06,29.14 216.86,28.94 214.29,28.94 214.08,29.15 214.08,32.41 214.61,32.94 216.36,32.94
+5V_S5 on IN1 (solid shape): outline of 257 points within 18.45,30.98 28.21,40.25
+5V_S5 on IN2 (solid shape): 217.23,32.2 217.23,29.19 216.93,28.9 214.19,28.9 214,29.09 214,32.43 214.71,33.14 216.29,33.14
+5V_S5 on IN2 (solid shape): outline of 194 points within 173.39,9.24 203.43,20.05
+5V_S5 on IN2 (solid shape): outline of 594 points within 27.21,21.58 57.23,34.89
+5V_S5_V2 on TOP (solid shape): 36.57,110.11 36.57,107.85 37,107.42 37,104.71 38.03,103.68 38.03,100.68 37.67,100.32 37.67,98.4 37.66,98.4 37.66,97.67 37.55,97.56 37.46,97.56 37.46,98.32 37.46,98.4 37.26,98.4 37.26,97.67 37.26,97.56 37.11,97.56 36.94,97.72 36.19,97.72 36,97.91 34.98,97.91 34.58,98.32 34.3,98.32 34.27,98.29 34.09,98.29 33.97,98.42 33.97,100.28 34.18,100.5 34.18,101.33 34.51,101.65 34.62,101.65 34.63,101.65 35.15,101.92 34.78,102.38 34.73,102.43 34.73,103.27 34.75,103.29 34.75,104.18 35.24,104.67 35.24,107.33 34.85,107.72 33.8,107.72 33.77,107.75 33.17,107.75 33.08,107.84 33.08,107.96 33.77,107.96 33.77,108.25 33.08,108.25 33.08,108.46 33.77,108.46 33.77,108.75 33.08,108.75 33.08,108.96 33.77,108.96 33.77,109.25 33.08,109.25 33.08,109.37 33.17,109.46 33.77,109.46 33.77,109.46 33.8,109.49 34.85,109.49 35.63,110.27 36.42,110.27
+5V_S5_V2 on IN1 (solid shape): 37.24,104.57 37.24,102.36 37.12,102.23 35.13,102.23 34.17,103.19 34.17,104.39 34.55,104.77 37.04,104.77
+5VA on BOTTOM (solid shape): 206.74,27.55 206.74,24.18 207.39,23.52 208.62,23.52 208.76,23.38 208.76,23 208.91,22.85 209.61,22.85 209.73,22.73 209.73,21.79 209.61,21.67 209.02,21.67 208.9,21.8 208.9,22.29 208.81,22.37 208.69,22.37 208.65,22.39 208.62,22.39 208.61,22.4 208.3,22.4 208.29,22.39 208.26,22.39 208.22,22.37 206.5,22.37 206.4,22.47 206.4,23.29 206.1,23.59 203.45,23.59 203.33,23.71 203.33,25.5 203.46,25.62 205.4,25.62 205.41,25.62 205.54,25.6 205.67,25.62 205.68,25.62 205.98,25.62 206.03,25.67 206.03,27.48 206.15,27.6 206.69,27.6
+5VODD on BOTTOM (solid shape): outline of 161 points within 225.93,102.67 234.52,111.02
+5VPCU on TOP (solid shape): 31.88,37.74 31.88,29.97 30.49,28.57 30.49,28.54 30.08,28.14 28.66,28.14 27.09,26.57 27.04,26.53 27,26.48 26.35,25.83 25.71,25.83 25.1,26.44 25.1,27.22 25.57,27.69 25.98,27.69 26.21,27.93 26.22,27.93 26.37,28.03 26.47,28.18 26.48,28.19 28.68,30.4 28.68,32.56 29.39,33.27 29.39,37.74 29.65,37.99 31.63,37.99
+5VPCU on TOP (solid shape): 37.65,96.24 37.65,94.66 37.37,94.38 37.37,93.19 36.84,92.65 36.84,90.88 36.18,90.22 34.8,90.22 34.14,90.88 34.14,93.47 35.06,94.38 35.06,95.04 35.54,95.52 35.54,96.06 35.73,96.25 36.64,96.25 36.66,96.27 37.13,96.27 37.13,96.27 37.23,96.27 37.26,96.24 37.26,95.52 37.26,95.44 37.46,95.44 37.46,96.17 37.46,96.25 37.5,96.29 37.6,96.29
+5VPCU on TOP (solid shape): 20.49,29.43 20.51,29.41 20.73,29.41 20.88,29.27 20.89,29.24 20.89,29.11 20.96,29.11 21,29.09 21.01,29.06 21.01,28.59 20.94,28.52 20.33,28.52 20.21,28.4 20.21,28.39 20.15,28.33 19.9,28.11 19.92,27.77 19.92,27.63 19.85,27.56 18.95,27.56 18.88,27.63 18.88,28.65 19.08,28.85 19.08,29.88 19.16,29.97 19.96,29.97
+5VPCU on BOTTOM (solid shape): outline of 1929 points within 19.11,9.7 76.71,38.6
+5VPCU on SVCC (solid shape): 52.67,15.89 53.04,15.62 53.41,15.89 53.74,15.89 54.1,15.64 54.46,15.89 54.83,15.89 55.2,15.64 55.56,15.89 57.17,15.89 57.53,15.65 57.89,15.89 58.26,15.89 58.62,15.63 58.98,15.89 59.34,15.89 59.72,15.56 60.09,15.89 71.83,15.89 72.32,15.41 72.32,13.77 72.22,13.51 72.32,13.25 72.32,13.08 69.67,10.43 51.44,10.43 50.58,11.3 50.58,14.95 51.52,15.89
+5VPCU on IN1 (solid shape): outline of 2189 points within 20.28,25.78 36.18,92.3
+A3VPCU on BOTTOM (solid shape): 170.78,32.7 172.28,32.7 172.29,32.68 172.29,32.55 172.28,32.51 172.24,32.5 170.78,32.5 170.76,32.48 170.74,32.48 170.69,32.43 170.65,32.43 170.65,32.39 170.21,31.95 168.48,31.95 168.28,32.15 168.28,32.46 168.41,32.58 170.49,32.58 170.62,32.71 170.78,32.71
+VCCCORE on TOP (solid shape): outline of 1819 points within 112.82,106.9 144.58,148.94
+VCCCORE on BOTTOM (solid shape): outline of 264 points within 117.88,106.84 122.76,109.82
+VCCCORE on BOTTOM (solid shape): outline of 609 points within 116.01,117.32 123.7,122.2
+VCCCORE on BOTTOM (solid shape): outline of 328 points within 117.95,121.25 146.54,149.91
+VCCCORE on SVCC (solid shape): 131.69,149.37 132.04,149.14 132.38,149.37 141.45,149.37 142.17,148.65 142.17,139.42 139.17,136.42 133.79,136.42 133.6,136.38 133.43,136.27 129.42,132.26 128.97,132.19 128.9,131.74 123.78,126.62 123.67,126.45 123.63,126.25 123.63,120.91 123.54,120.67 123.63,120.43 123.63,118.16 123.62,118.06 123.63,117.97 123.63,109.2 122.91,108.48 116.47,108.48 115.82,109.13 115.82,109.31 115.75,109.47 115.75,112.79 115.72,112.99 115.61,113.16 112.96,115.8 112.96,131.13 117.49,135.66 117.53,135.66 118.71,135.66 123.14,136.36 124.14,140.74 124.14,142.26 124.13,142.3 125.77,143.93 125.88,144.1 125.91,144.3 125.91,148.65 126.63,149.37
+VCCCORE on IN1 (solid shape): outline of 1201 points within 110.89,106.89 122.37,118.8
+VCCEOPIO on TOP (solid shape): 80.68,102.66 80.68,101 80.49,100.8 79.62,100.8 79.36,101.06 79.36,102.62 79.48,102.74 80.6,102.74
+VCCEOPIO on BOTTOM (solid shape): 72.07,98.32 72.07,96.79 71.56,96.29 69.4,96.29 69.27,96.41 69.27,98.06 69.91,98.7 71.68,98.7
+VCCEOPIO on BOTTOM (solid shape): 106.73,111.26 106.77,111.24 106.79,111.21 106.79,109.84 107.42,109.84 107.52,109.75 107.52,109.75 107.52,109.34 107.28,109.1 106.68,109.1 106.66,109.11 106.65,109.13 106.4,109.31 106.06,109.2 106.03,109.21 105.63,109.61 105.63,110.1 105.67,110.14 105.67,110.37 105.63,110.4 105.63,110.88 105.76,111 106.01,111 106.27,111.26
+VCCEOPIO on IN1 (solid shape): outline of 2641 points within 69.63,96.31 109.24,114.98
+VCCGT on TOP (solid shape): outline of 6570 points within 90.99,99.33 114.99,150.01
+VCCGT on BOTTOM (solid shape): 87.33,133.9 87.33,128.52 87.23,128.42 86.2,128.42 86.19,128.42 85.95,128.42 85.95,128.42 83.62,128.42 83.29,128.09 83.29,127.25 82.58,126.54 82.58,123.31 82.38,123.11 80.7,123.11 80.5,123.31 80.5,131.24 80.75,131.49 86.59,134.11 87.13,134.11
+VCCGT on BOTTOM (solid shape): 106.53,119.71 106.59,119.69 106.66,119.67 106.7,119.67 106.77,119.68 106.81,119.64 106.82,119.62 107.03,119.44 107.28,119.55 107.29,119.57 107.39,119.63 107.45,119.61 107.5,119.55 107.45,119.48 107.29,119.37 107.26,119.17 107.22,119.06 107.11,119.02 107.06,119.03 107.02,119.02 106.9,119.06 106.87,119.17 106.59,119.49 106.35,119.14 106.23,119.02 106.15,119.03 106.07,119.02 106.04,119.01 105.99,119.04 105.98,119.05 105.89,119.17 105.77,119.24 105.71,119.29 105.71,119.37 105.78,119.45 106.07,119.45 106.08,119.45 106.29,119.48 106.4,119.65 106.4,119.67 106.45,119.72 106.52,119.72
+VCCGT on BOTTOM (solid shape): outline of 232 points within 110.61,136.3 134.6,150.72
+VCCGT on BOTTOM (solid shape): outline of 701 points within 106.92,107.07 117.11,109.9
+VCCGT on BOTTOM (solid shape): outline of 1201 points within 88.55,111.86 115.79,118.97
+VCCGT on SVCC (solid shape): 124.9,148.65 124.9,144.5 123.42,143.02 121.86,143.02 117.47,142.03 116.77,137.59 116.77,136.37 114.7,134.3 114.19,134.27 114.16,133.77 112.09,131.7 111.98,131.53 111.94,131.33 111.94,121.1 111.72,120.76 111.94,120.42 111.94,120.38 111.65,120.02 111.94,119.66 111.94,115.6 111.98,115.4 112.09,115.23 114.74,112.59 114.74,111.79 114.5,111.43 114.74,111.08 114.74,109.2 114.02,108.48 107.58,108.48 106.65,109.41 106.79,109.72 106.61,110.02 106.61,110.05 106.76,110.36 106.61,110.66 106.61,111.01 106.57,111.21 106.46,111.38 104.18,113.66 104.01,113.77 103.81,113.81 101.31,113.81 101.21,113.83 101.1,113.81 100.6,113.81 100.5,113.83 100.39,113.81 78.37,113.81 77.65,114.53 77.65,130.61 90.73,137.09 100.87,147.59 104.52,147.59 104.72,147.63 104.89,147.74 106.49,149.35 113.34,149.35 113.42,149.35 113.5,149.37 124.18,149.37
+VCCGT on IN1 (solid shape): 111.83,118.52 111.83,113.19 110.99,112.35 108,112.35 107.16,113.19 107.16,119 107.66,119.51 110.84,119.51
+VCCHDA on TOP (solid shape): 154,77.07 154,73.39 153.94,73.34 153.13,73.34 152.79,73.68 152.79,75.58 152.58,75.79 151.87,75.79 151.75,75.66 151.75,75.28 151.67,75.2 150.99,75.2 150.89,75.23 150.81,75.24 150.61,75.24 150.5,75.36 150.5,77.49 150.65,77.64 153.42,77.64
+VCCHDA on IN1 (solid shape): outline of 434 points within 126.95,103.04 130.06,108.88
+VCCIO on TOP (solid shape): 116.52,110.46 116.57,110.38 116.64,110.3 116.64,109.57 116.52,109.45 115.94,109.45 115.76,109.64 114.87,109.64 114.72,109.79 114.72,110.17 114.85,110.3 115.5,110.3 115.77,110.58 116.4,110.58
+VCCIO on TOP (solid shape): 79.88,95.93 79.88,93.96 79.41,93.49 76,93.49 75.93,93.57 75.93,94.97 76.08,95.12 76.09,95.12 76.31,95.33 76.31,95.91 76.55,96.15 77.92,96.15 77.93,96.15 78.27,96.15 78.37,96.25 78.37,96.6 78.52,96.74 79.06,96.74
+VCCIO on TOP (solid shape): 125.84,109.66 125.84,109.25 125.78,109.19 125.75,109.2 125.59,109.23 125.43,109.19 125.42,109.18 125.39,109.18 125.19,108.98 125.19,108.51 124.81,108.14 124.81,107.66 124,106.85 123.98,106.85 123.91,106.84 123.84,106.82 123.2,106.82 123.15,106.83 123.04,106.95 123.04,107.53 123.34,107.84 123.34,107.98 123.35,108.07 123.34,108.16 123.34,108.56 124.28,109.5 124.28,109.66 124.38,109.75 125.75,109.75
+VCCIO on TOP (solid shape): 135.79,127.55 135.82,127.55 136.51,127.55 136.76,127.3 136.76,125.9 136.58,125.73 135.81,125.73 135.67,125.87 135.67,126.43 135.77,126.85 135.41,127.1 135.39,127.1 135.09,127.4 134.77,127.4 133.99,127.16 134.76,126.87 134.77,126.89 134.88,126.89 135.03,126.74 135.03,126.72 135.06,126.56 135.16,126.43 135.16,125.73 133.72,125.73 133.65,125.8 133.65,126.72 133.5,126.72 133.21,127 133.21,127.9 133.42,128.11 135.23,128.11
+VCCIO on BOTTOM (solid shape): 80.35,96.9 80.35,95.53 77.7,92.88 77.04,92.88 76.92,93.01 76.92,96.53 77.41,97.02 80.23,97.02
+VCCIO on BOTTOM (solid shape): 125.15,109.11 125.15,108.58 124.59,108.02 124.59,107.35 124.21,106.97 123.72,106.97 123.52,107.06 123.33,106.97 122.94,106.97 122.81,107.1 122.81,107.26 122.86,107.33 122.89,107.41 122.89,107.42 123.15,107.68 123.21,107.72 123.28,107.79 123.32,107.9 123.3,108.02 123.3,108.03 123.3,108.43 123.58,108.71 123.63,108.76 123.63,108.92 123.65,108.95 123.74,109.1 123.76,109.23 123.78,109.31 123.86,109.34 124.92,109.34
+VCCIO on BOTTOM (solid shape): outline of 104 points within 84.23,114.57 89.67,116.99
+VCCIO on IN1 (solid shape): outline of 906 points within 121.13,106.89 133.86,128.54
+VCCIO on IN2 (solid shape): outline of 3399 points within 76.54,94.05 125.66,118
+VCCOPC on TOP (solid shape): 89.18,115.99 89.18,114.39 89.05,114.26 85.69,114.26 85.55,114.4 85.55,115.91 85.7,116.06 89.12,116.06
+VCCOPC on BOTTOM (solid shape): 77.18,104.11 77.18,103.5 77.33,103.35 77.33,103.11 77.01,102.79 76.36,102.79 76.17,102.98 76.17,103.15 76.67,103.64 76.67,104.03 76.68,104.05 76.7,104.06 76.77,104.09 76.83,104.14 76.91,104.23 77.07,104.23
+VCCOPC on BOTTOM (solid shape): 106.78,116.39 106.78,113.21 105.94,112.38 105.78,112.38 105.69,112.46 105.69,112.61 106.27,113.19 106.27,114.05 106.12,114.2 105.79,114.2 105.69,114.3 105.69,114.43 105.8,114.53 105.96,114.53 106.27,114.85 106.27,115.83 106.06,116.03 105.79,116.03 105.7,116.12 105.7,116.28 105.83,116.41 106.75,116.41
+VCCOPC on IN1 (solid shape): outline of 1779 points within 70.06,102.59 107.02,122.45
+VCCOPC_SW on BOTTOM (solid shape): 59.26,88.46 59.26,85.44 59.06,85.24 55.3,85.24 54.01,83.94 54.01,83.93 53.98,83.93 53.98,83.21 54.01,83.19 54.01,82.44 53.96,82.39 53.73,82.39 53.7,82.42 53.7,83.19 53.73,83.21 53.73,83.93 53.72,83.93 53.22,84.42 53.22,88.16 53.78,88.72 59.01,88.72
+VCCOPC_VBST on BOTTOM (solid shape): 56.33,84.99 56.33,84.19 56.29,84.14 55.12,84.14 54.51,83.54 54.51,83.26 54.49,83.23 54.23,83.23 54.23,83.94 54.39,83.94 55.45,85.01 56.32,85.01
+VCCPDSW_3P3 on IN2 (solid shape): outline of 545 points within 130.46,103.14 145.83,113.41
+VCCPGPPA on IN1 (solid shape): outline of 320 points within 132.9,108.17 139.58,109.51
+VCCPLL on BOTTOM (solid shape): 135.44,129.32 135.44,128.9 134.84,128.3 134.84,127.14 134.56,126.87 134.2,126.87 134.11,126.96 134.11,127.36 133.86,127.61 133.37,127.61 133.25,127.72 133.25,128.14 133.41,128.29 133.91,128.29 134.23,128.61 134.23,129.29 134.37,129.43 134.37,129.45 135.31,129.45
+VCCPLL on BOTTOM (solid shape): 129.64,118.34 129.64,117.98 129.4,117.74 129.08,117.74 129.07,117.74 128.75,117.74 128.72,117.7 128.7,117.69 128.6,117.63 128.54,117.54 128.53,117.53 128.34,117.34 128.32,117.33 126.99,117.33 126.87,117.45 126.87,117.81 127.15,118.09 127.98,118.09 128.17,118.28 128.31,118.28 128.56,118.53 129.45,118.53
+VCCPRIM_1P0 on BOTTOM (solid shape): 144.67,117.28 144.67,116.7 144.58,116.61 144.07,116.61 143.95,116.48 143.95,116.25 143.09,115.4 140.4,115.4 140.31,115.48 140.31,115.64 140.39,115.73 141.05,115.73 142.57,117.24 143.66,117.24 143.79,117.37 144.58,117.37
+VCCPRIM_3P3 on IN1 (solid shape): outline of 441 points within 129.51,111.22 139.2,115.32
+VCCPRTC on TOP (solid shape): 133.56,101.37 133.56,99.12 132.45,98.02 132.45,98 132.39,97.94 132.39,90.55 129.52,87.68 129.5,87.68 129.09,87.27 129.09,86.5 129.08,86.49 129.08,77.31 129.09,77.29 129.09,75.76 129.27,75.58 129.27,74.76 129.24,74.73 127.61,74.73 127.49,74.85 127.49,87.75 131.27,91.54 131.27,94.53 131.22,94.58 131.22,96.12 131.23,96.13 131.25,96.26 131.23,96.39 131.22,96.4 131.22,98.8 132.09,99.66 132.09,101.44 132.14,101.49 133.43,101.49
+VCCPRTCPRIM_3P3 on IN2 (solid shape): outline of 876 points within 130.79,98.81 141.59,110.76
+VCCSA on TOP (solid shape): outline of 1615 points within 124.3,108.59 154.49,148.86
+VCCSA on BOTTOM (solid shape): 156.11,147.87 156.11,143.63 154.7,142.22 148.14,142.22 148.1,142.24 148.09,142.27 148.09,143.2 147.79,143.5 147.43,143.5 147.39,143.52 147.38,143.56 147.38,147.34 148.01,147.97 149.99,147.97 150.45,147.52 150.45,145.54 150.48,145.51 150.48,145.27 151.04,145.27 151.04,147 151.03,147 151.03,147.87 151.31,148.15 155.84,148.15
+VCCSA on BOTTOM (solid shape): 127.44,109.63 127.44,109.2 127.41,109.16 127.4,109.15 127.29,109.02 127.24,108.86 127.26,108.85 127.26,108.83 127.36,108.6 127.59,108.5 127.61,108.5 127.75,108.35 127.8,108.35 127.83,108.33 127.83,108.27 127.79,108.19 127.7,108.17 127.49,108.13 127.39,107.95 127.32,107.87 127.21,107.89 126.9,108.21 126.59,108.21 126.33,107.95 126.21,107.95 125.78,108.38 125.67,108.38 125.63,108.39 125.62,108.42 125.62,108.44 125.63,108.47 125.67,108.5 125.68,108.5 125.88,108.62 125.96,108.85 125.8,109.15 125.46,109.17 125.36,109.18 125.32,109.27 125.32,109.71 125.44,109.84 127.23,109.84
+VCCSA on BOTTOM (solid shape): outline of 257 points within 123.42,117.31 127.72,120.21
+VCCSA on SVCC (solid shape): 159.19,148.65 159.19,146.38 159.16,146.25 159.19,146.11 159.19,145.72 159.16,145.59 159.19,145.45 159.19,145.06 159.16,144.93 159.19,144.79 159.19,132.06 152.88,125.75 144.21,125.75 144.01,125.71 143.84,125.6 140.82,122.58 137.93,122.58 137.83,122.56 137.75,122.5 137.16,121.92 137.11,121.83 137.09,121.73 137.09,118.9 137.09,118.84 137.11,118.79 137.09,118.71 137.09,118.63 137.09,117.63 136.77,117.27 137.09,116.9 137.09,113.51 136.76,113.14 137.09,112.77 137.09,111.24 136.73,110.88 137.09,110.51 137.09,109.45 136.12,108.48 125.36,108.48 125.24,108.6 125.13,108.92 124.82,109.02 124.64,109.2 124.64,121.34 124.68,121.51 124.64,121.67 124.64,126.05 134,135.4 139.37,135.4 139.57,135.44 139.74,135.55 141.52,137.34 142.06,137.34 142.06,137.88 143.04,138.85 143.15,139.02 143.19,139.22 143.19,143.71 143.21,143.86 143.19,144.01 143.19,148.65 143.9,149.37 158.47,149.37
+VCCSA on IN1 (solid shape): outline of 358 points within 123.45,108.66 127.83,119.92
+VCCSTG on TOP (solid shape): outline of 318 points within 127.97,119.21 135.15,126.63
+VDDQ on TOP (solid shape): 41.48,57.07 41.48,56.64 41.15,56.31 40.4,56.31 40.3,56.41 40.3,57.73 40.36,57.79 40.76,57.79
+VDDQC on TOP (solid shape): 117.29,109.27 117.29,108.82 117.25,108.78 117.25,107.78 117.37,107.66 117.52,107.66 117.82,107.36 117.82,107.05 117.72,106.95 117.44,106.95 116.96,107.44 116.95,107.44 116.92,107.46 116.79,107.46 116.62,107.64 116.62,108.03 116.28,108.36 115.74,108.36 115.65,108.46 115.65,108.79 116.18,109.33 116.58,109.33 116.58,109.33 116.66,109.33 116.73,109.39 117.17,109.39
+VIN_VCCGT on TOP (solid shape): 125.46,160.7 125.46,159.35 125.25,159.15 118.88,159.15 118.78,159.25 118.78,160.45 118.95,160.62 121.27,160.62 122.13,161.49 124.67,161.49
+VIN_VCCGT on TOP (solid shape): 135.44,161.01 135.44,159 135.31,158.87 132.24,158.87 132.01,159.1 128.91,159.1 128.9,159.09 128.57,159.09 128.48,159.18 128.48,160.55 128.53,160.6 130.92,160.6 131.68,161.36 135.08,161.36
+VIN_VCCGT on BOTTOM (solid shape): 125.17,160.99 125.17,160.97 125.17,160.9 125.26,160.82 125.29,160.78 125.44,160.63 125.44,159.34 125.25,159.15 118.83,159.15 118.79,159.17 118.78,159.2 118.78,159.53 118.67,159.63 118.6,159.63 118.6,159.64 118.06,159.64 118.04,159.66 118.04,159.85 118.05,159.88 118.09,159.9 118.61,159.9 118.78,160.07 118.78,160.57 118.79,160.61 118.83,160.62 121.27,160.62 122.15,161.51 124.64,161.51
+VIN_VCCGT on BOTTOM (solid shape): 135.57,161.31 135.57,160.45 135.55,160.43 135.55,159.06 135.39,158.9 132.24,158.9 132.04,159.1 128.5,159.1 128.47,159.11 128.45,159.15 128.45,159.51 128.35,159.61 127.77,159.61 127.73,159.62 127.72,159.66 127.72,159.81 127.73,159.84 127.77,159.86 128.29,159.86 128.29,159.86 128.38,159.86 128.45,159.94 128.45,160.55 128.47,160.58 128.5,160.6 130.89,160.6 131.86,161.56 135.31,161.56
+VIN_VCCGT on IN1 (solid shape): outline of 291 points within 118.6,158.95 132.91,164.13
AVCC33 on TOP (solid shape): 26.35,66.97 26.35,64.84 26.34,64.82 26.33,64.8 26.22,64.49 26.37,64.18 26.55,64 26.55,63.34 26.47,63.27 25.66,63.27 25.65,63.27 25.65,66.25 25.62,66.42 25.54,66.58 25.53,66.59 25.53,66.62 25.28,66.87 25.28,67 25.29,67.03 25.33,67.05 26.27,67.05
DVDD_IO on TOP (solid shape): 207.4,37.81 207.4,36.95 207.07,36.57 207.41,36.2 207.44,36.18 207.45,36.14 207.45,35.73 207.07,35.35 205.39,35.35 205.3,35.4 205.29,35.49 205.31,35.53 205.31,35.58 205.31,35.86 205.27,35.99 205.16,36.07 205.14,36.08 205.12,36.1 205.12,36.29 205.11,36.31 205.11,37.33 205.61,37.83 206.65,37.83 206.81,37.99 207.22,37.99
GND on TOP (solid shape): 88.18,8.05 84.18,8.05 84.18,40.23 88.18,40.23
GND on TOP (solid shape): 27.72,114.57 27.72,112.54 27.57,112.39 27.26,112.39 26.24,113.41 26.24,114.6 26.4,114.75 27.54,114.75
GND on TOP (solid shape): 66.72,67.87 66.72,66.03 66.5,65.82 64.69,65.82 64.36,66.15 64.36,67.73 64.55,67.92 66.66,67.92
GND on TOP (solid shape): 96.93,119.81 96.93,119.04 96.86,118.97 93.27,118.97 93.1,119.15 93.1,120.37 93.22,120.49 96.25,120.49
GND on TOP (solid shape): 113.01,139.82 113.01,133.29 112.71,132.99 111.39,132.99 111.11,133.27 111.11,139.87 111.28,140.05 112.78,140.05
GND on TOP (solid shape): 130.99,141.04 130.99,139.92 130.79,139.72 126.45,139.72 126.22,139.95 126.22,141.12 126.44,141.35 130.69,141.35
GND on TOP (solid shape): 140.95,131.36 140.95,130.63 140.11,129.79 136.61,129.79 135.46,130.93 135.46,131.34 135.57,131.44 140.87,131.44
GND on TOP (solid shape): 145.95,43.86 145.95,39.64 145.62,39.31 143.95,39.31 143.77,39.49 143.77,43.63 144.23,44.09 145.73,44.09
GND on TOP (solid shape): 148.98,172.08 148.98,170.53 147.48,169.03 146.92,169.03 146.79,169.16 146.79,172.13 146.92,172.26 148.8,172.26
GND on TOP (solid shape): 198.56,192.68 198.56,187.98 198.05,187.47 196.53,187.47 196.4,187.6 196.4,191.41 197.8,192.81 198.43,192.81
GND on TOP (solid shape): 64.95,80.03 64.95,77.74 64.32,77.11 61.52,77.11 61.4,77.24 60.51,77.24 60.38,77.36 60.38,79.39 61.78,80.79 64.19,80.79
GND on TOP (solid shape): 71.89,57.74 71.89,56.27 71.43,55.81 69.16,55.81 69.14,55.79 68.53,55.79 67.86,56.46 67.86,57.86 68.1,58.1 71.53,58.1
GND on TOP (solid shape): 162.49,161.06 162.49,157.35 162.21,157.07 160.48,157.07 160.23,157.32 160.23,161.16 160.58,161.51 162.03,161.51
GND on TOP (solid shape): 195.31,114.24 195.31,110.82 195.24,110.75 193.92,110.75 193.91,110.76 191.93,110.76 191.78,110.92 191.78,114.19 191.93,114.35 195.21,114.35
GND on TOP (solid shape): 156.93,108.25 156.93,107.5 156.84,107.41 156.84,104.85 156.78,104.79 155.34,104.79 155.03,105.11 155.02,105.11 155.02,108.2 155.15,108.33 156.85,108.33
GND on TOP (solid shape): 207.27,35.1 207.27,34.82 206.56,34.11 206.56,30.42 206.43,30.3 204.2,30.3 204.02,30.47 204.02,35.05 204.15,35.17 207.19,35.17
GND on TOP (solid shape): 39.15,110.26 39.15,108.86 40.75,107.26 40.75,104.74 40.39,104.39 37.9,104.39 37.6,104.69 37.6,107.56 36.79,108.38 36.79,110.21 37.06,110.48 38.92,110.48
GND on TOP (solid shape): 58.6,49.22 59.44,49.22 59.67,49.45 60.61,49.45 60.66,49.4 60.66,46.78 60.13,46.25 58.98,46.25 56.37,48.86 56.37,49.37 56.83,49.83 57.99,49.83
GND on TOP (solid shape): 72.85,21.51 72.85,18.64 71.99,17.77 71.99,17.44 71.81,17.27 67.85,17.27 67.49,17.62 67.49,21.58 67.67,21.76 68.31,21.76 68.64,22.09 72.27,22.09
GND on TOP (solid shape): 99.92,115.25 99.92,113.98 99.8,113.85 99.35,113.85 99.06,114.14 97.9,114.14 97.44,114.6 97.44,115.26 97.58,115.39 99.78,115.39
GND on TOP (solid shape): 15.06,92.79 15.06,90.83 14.92,90.69 12.61,90.69 12.49,90.81 12.49,92.76 12.61,92.89 14.96,92.89
GND on TOP (solid shape): 63.41,95.82 63.41,93.22 63.32,93.13 62.84,93.13 62.74,93.23 59.68,93.23 59.42,93.49 59.42,93.85 58.96,94.3 58.96,96.16 59.57,96.77 62.46,96.77
GND on TOP (solid shape): 135.03,149.48 135.03,149.27 134.94,149.17 131.87,149.17 131.77,149.28 131.77,149.81 131.89,149.93 134.58,149.93
GND on TOP (solid shape): 183.95,173.55 183.95,172.1 183.7,171.85 176.38,171.85 176.33,171.9 176.31,171.9 176.28,171.93 176.28,173.07 176.97,173.76 183.75,173.76
GND on TOP (solid shape): 49.77,53.85 49.77,53.33 50.53,52.56 50.53,50.37 49.42,49.26 48.42,49.26 48.31,49.37 48.31,52.95 48.4,53.03 48.75,53.03 49.16,53.44 49.16,53.87 49.25,53.95 49.66,53.95
GND on TOP (solid shape): 61.24,73.41 61.24,71.35 58.67,68.78 57.9,68.78 57.9,68.78 57.46,68.78 57.3,68.95 57.3,70.11 57.62,70.43 57.62,71.44 58.72,72.54 58.72,73.43 58.85,73.56 61.1,73.56
GND on TOP (solid shape): 173.62,120.31 173.62,119.53 173.49,119.4 172.75,119.4 172.04,118.69 172.04,116.1 171.85,115.91 170.38,115.91 170.29,116 170.29,117.44 169.09,118.64 169.09,120.31 169.25,120.47 173.46,120.47
GND on TOP (solid shape): 43.44,50.4 43.44,46.25 43.16,45.97 38.59,45.97 38.33,46.22 38.33,46.91 38.44,47.01 40.6,47.01 40.6,50.07 40.79,50.27 40.98,50.27 40.99,50.28 41.68,50.28 42.17,50.76 43.07,50.76
GND on TOP (solid shape): 100.04,121.47 103.58,121.47 103.7,121.59 104.06,121.59 104.17,121.48 104.17,120.7 104.02,120.54 102.7,120.54 102.45,120.3 99.64,120.3 99.36,120.58 99.36,121.62 99.49,121.75 99.77,121.75
GND on TOP (solid shape): 171.74,83.28 171.74,82.93 171.63,82.82 170.82,82.82 170.81,82.81 170.64,82.81 170.38,82.55 170.38,82.38 169.65,81.66 168.54,81.66 168.28,81.91 168.28,82.21 168.43,82.37 168.59,82.37 169.6,83.38 171.63,83.38
GND on TOP (solid shape): 223.35,171.17 225.38,171.17 225.84,170.71 225.84,167.6 225.58,167.35 224.25,167.35 220.76,170.84 219.97,170.84 219.87,170.94 219.87,172.26 220.15,172.54 221.97,172.54
GND on TOP (solid shape): 19.16,27.31 19.16,26.49 19.28,26.38 20.3,26.38 20.35,26.33 20.35,26.16 20.28,26.1 19.28,26.1 19.16,25.98 19.16,25.66 19.09,25.58 17.41,25.58 17.35,25.65 17.35,27.31 17.43,27.39 19.08,27.39
GND on TOP (solid shape): 103.98,118.2 103.98,117.92 103.83,117.77 103.06,117.77 102.72,118.11 99.54,118.11 99.53,118.11 99.43,118.11 99.07,117.76 98.85,117.76 98.75,117.86 98.75,118.2 99.19,118.65 103.53,118.65
GND on TOP (solid shape): 119.15,124.77 119.15,124.12 119.05,124.02 119.05,124.02 119.05,122.56 118.43,121.94 118.21,121.94 118.1,122.05 118.1,122.36 118.44,122.69 118.44,123.98 118.82,124.36 118.82,124.77 118.9,124.85 119.07,124.85
GND on TOP (solid shape): 24.8,29.05 24.8,26.94 24.52,26.66 22.71,26.66 22.55,26.82 22.55,27.6 22.32,27.82 20.8,27.82 20.69,27.94 20.69,28.29 20.71,28.32 21.34,28.32 21.95,28.93 23.02,28.93 23.14,29.04 23.22,29.04 23.43,29.26 24.59,29.26
GND on TOP (solid shape): 180.78,116.43 180.78,115.61 180.78,115.61 180.78,110.93 180.43,110.58 180.43,110.24 180.35,110.15 180.3,110.1 180.27,110.05 180.25,110.03 180.22,110.03 179.43,110.03 179.25,110.21 179.25,116.58 179.38,116.71 180.5,116.71
GND on TOP (solid shape): 135.01,84.81 135.01,83.08 133.08,81.15 133.08,73.86 132.64,73.43 131.5,73.43 131.4,73.53 131.4,77.19 130.99,77.59 130.99,82.42 131.91,83.33 134.25,83.33 134.55,83.64 134.55,84.86 134.63,84.93 134.88,84.93
GND on TOP (solid shape): 57.03,63.24 57.03,62.2 56.83,62 56.83,60.95 57.03,60.75 58.12,60.75 58.88,59.99 58.88,58.47 58.67,58.25 53.6,58.25 52.56,59.29 52.56,61.48 52.71,61.63 54.66,61.63 56.47,63.44 56.83,63.44
