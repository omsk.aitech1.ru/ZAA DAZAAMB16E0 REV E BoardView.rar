# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCHDA: length 39.3
  IN1 w0.381: v1(150.81,75.46) 149.97,76.3 149.97,83.15 138.23,94.89 138.23,96.41 137.88,96.77 136.4,96.77 134.3,98.88 132.77,98.88 128.48,103.17
  BOTTOM w0.305: U35.AJ19 129.76,108.73 v2(129.76,108.64)
  vias: v1(153.6,76.22)
+VCCIO: length 129.7
  TOP w0.305: v1(149.31,183.1) 149.43,183.23 v1(149.92,183.23) 150.09,183.23 PR174.2
  TOP w0.508: C710.2 83.67,113.44 83.68,113.45 C711.2 83.71,114.47 84.13,114.47 v1(84.51,114.85) 84.51,115.08 83.67,115.92 83.67,119.5 88.3,124.12 v1(92.92,124.12) ; R154.2 118.98,120.33 118.61,119.97 v1(117.57,119.97) ; 136.68,126.66 137.04,127.02 141.13,127.02 142.98,128.87 150.4,128.87 157.87,136.34 157.87,141.75 156.44,143.17 156.44,164.08 155.96,164.56 154.49,164.56 153.01,166.05 150.64,166.05 150.04,166.64 147.55,166.64 v1(146.89,167.3) 146.18,168.02 146.18,168.07 v1(146.16,168.09)
  IN1 w0.508: v1(117.57,119.97) 118.29,119.25 121.47,119.25 121.53,119.18
  BOTTOM w0.305: v1(116.41,109.75) 117.58,108.63 U35.AL42 117.49,107.93 117.12,107.56 U35.AM42
  BOTTOM w0.381: PR200.1 135.27,172.66 137.65,172.66 139.66,174.67 v1(140.67,174.67) 144.61,174.67 ; 144.61,174.67 145.04,174.67 145.26,174.89 147.19,174.89 148.49,176.19 148.49,177.97 149.43,178.91 149.43,182.98 v1(149.31,183.1) ; 144.61,174.67 144.63,174.64 144.63,174.21 145.68,173.17 145.68,168.57 v1(146.16,168.09) ; v1(92.92,124.12) 93.4,124.61 R544.1 94.92,124.72 94.16,125.48 R465.2
  vias: v1(89.39,116.71) v2(123.98,108.59) v2(124.01,107.13) v2(124.87,108.66) v3(77.83,95.12) v3(78.31,94.51) v3(78.67,96.41) v3(78.8,95.65) v3(79.05,94.71) v3(133.53,127.17)
+VCCOPC:
  vias: v1(76.51,103.07) v1(85.96,115.39) v1(87.33,115.24) v1(88.3,115.24) v1(106.52,115.37) v1(106.52,114.71) v1(106.55,114.05) v3(72.32,103.4) v3(73.08,103.4) v3(73.84,103.4) v3(74.1,104.41)
+VCCOPC_3V3: length 3
  BOTTOM w0.254: PU14.10 55.92,83.37 56.04,83.48 v1(56.38,83.48) 56.57,83.29 PC230.2
  BOTTOM w0.381: PR292.1 PC230.2
+VCCOPC_EN: length 2.8
  TOP w0.305: PR136.2 51.31,83.15 v1(51.47,83.31)
  BOTTOM w0.254: v1(51.47,83.31) 51.9,82.87 PU14.5
  BOTTOM w0.305: PR135.2 51.21,83.56 v1(51.47,83.31)
+VCCOPC_LP#: length 2.5
  BOTTOM w0.254: PR288.2 v1(51.42,84.53) 51.59,84.53 51.87,84.25 51.87,83.64 52.14,83.37 PU14.6
+VCCOPC_MODE: length 4.1
  BOTTOM w0.254: PR289.2 52.25,85.49 v1(52.43,85.31) 52.71,85.31 52.97,85.06 52.97,84.32 53.35,83.93 PU14.7
+VCCOPC_SRC: length 56.7
  TOP w0.508: v1(56.19,82.06) 55.68,82.06 55.33,82.42 v1(55.28,82.42) 54.52,82.42 PR344.2
  IN2 w0.508: v1(56.19,82.06) 55.89,82.06 55.17,82.77 55.17,83.54 51.7,87.01 51.7,88.82 49.38,91.13 49.38,97.23 55.3,103.14 71,103.14 73.51,100.63 75.37,100.63 75.83,101.09 75.83,103.68 v1(76.56,104.41)
  BOTTOM w0.254: v1(56.19,82.06) 55.88,82.37 PU14.12
  BOTTOM w0.508: R633.1 R634.1 76.9,104.75 v1(76.56,104.41)
+VCCOPC_SW:
  vias: v1(53.63,84.86)
+VCCOPC_VBST:
  vias: v1(55.02,84.35)
+VCCPDSW_3P3: length 42.2
  TOP w0.508: v1(160.2,78.51) 161.98,78.51 v1(163.27,77.22) 164.64,75.85 164.64,75.55 C314.1 164.64,75.52 164.64,74.96 164.68,74.91 R210.1 R212.1
  IN1 w0.508: v1(160.2,78.51) 159.19,78.51 156.57,81.12 156.57,84.98 153.62,87.94 153.62,95.45 146.76,102.32 145.98,102.32 145.47,102.83 145.47,103.47 v1(145.47,103.47)
  BOTTOM w0.279: U35.AJ17 131.06,109.39 v2(131.06,109.48)
  BOTTOM w0.305: U35.AD17 v2(131.06,111.15) 130.74,111.48 U35.AD18
+VCCPGPPA: length 22.5
  TOP w0.508: C292.1 155.76,110.43 v1(155.68,110.51) 155.94,110.76 155.94,110.98 R198.1
  IN1 w0.381: 139.27,108.43 139.85,108.43 140.44,107.84 142.53,107.84 143.92,106.45 148.75,106.45 149.19,106.89 152.14,106.89 153.6,108.35 154.49,108.35 155.68,109.54 v1(155.68,110.51)
  BOTTOM w0.254: U35.AK15 132.94,108.47 132.94,108.51 v2(133.24,108.81)
+VCCPGPPB: length 27.4
  TOP w0.508: C268.1 154.87,110.38 v1(155,110.51) 155,111.43 R185.1
  IN1 w0.381: v2(133.53,109.87) 133.54,109.86 134.38,109.86 134.4,109.83 138.84,109.83 139.13,109.55 139.83,109.55 140.93,108.45 145.7,108.45 147.15,107 148.57,107 148.98,107.41 151.9,107.41 153.47,108.99 154.23,108.99 155,109.75 v1(155,110.51)
  BOTTOM w0.305: U35.AG15 133.51,109.89 v2(133.53,109.87)
+VCCPGPPC: length 19.4
  TOP w0.381: v2(131.71,112.83) 131.71,112.95 132.18,113.42 133.68,113.42 134.51,112.58 138.6,112.58 139.03,112.15 140.63,112.15 140.87,112.39 142.32,112.39 142.93,111.78 v1(145.9,111.78) 146.11,111.78 146.62,112.3 C230.1 147.02,112.67 148.04,113.68 R182.1
  BOTTOM w0.305: v2(131.71,112.83) U35.Y16
+VCCPGPPD: length 18.1
  TOP w0.381: v2(132.36,112.83) 133.12,112.83 134.51,111.44 140.86,111.44 141.15,111.14 v1(143.9,111.14) 144.07,111.14 144.72,110.5 C265.1 145.48,111.14 146.28,111.14 147.17,112.03 147.82,112.03 R187.1
  BOTTOM w0.305: U35.Y15 v2(132.36,112.83)
+VCCPGPPE: length 24.8
  TOP w0.508: R179.1 151.06,110.94 v1(151.49,110.51) 151.95,110.05 C256.1
  IN1 w0.254: v2(132.38,115.35) 132.38,115.33 133.02,114.69 133.39,114.69 133.83,114.25 133.83,113.76 134.16,113.42 134.73,113.42 134.95,113.64 142.83,113.64 142.91,113.57 142.91,113.56 143.64,112.82 143.64,112.11 144.48,111.27 150.73,111.27 v1(151.49,110.51)
  BOTTOM w0.254: U35.T16 132.33,115.22 132.33,115.31 v2(132.38,115.35)
+VCCPGPPF: length 19.9
  TOP w0.356: R192.1 147.76,109.24 v1(147.4,108.88) 147,108.48 141.53,108.48 140.47,109.54 139.15,109.54 138.97,109.72 134.3,109.72 133.91,109.33 132.99,109.33 132.62,108.96 132.04,108.96 131.76,109.24 131.76,109.6 132.35,110.19 v2(132.35,110.32)
  BOTTOM w0.305: U35.AF16 132.35,110.42 v2(132.35,110.32)
+VCCPGPPG: length 26.9
  TOP w0.508: C270.1 153.98,110.13 154.23,110.38 v1(154.23,110.51) 154.23,111.31 R188.1
  IN1 w0.381: v1(154.23,110.51) 154.23,110.13 153.73,109.62 153.35,109.62 152.33,108.6 148.01,108.6 147.5,109.11 141.46,109.11 139.86,110.71 139.12,110.71 138.75,110.34 134.61,110.34 134.5,110.46 133.03,110.46 132.36,111.13 v2(132.36,111.15)
  BOTTOM w0.305: v2(132.36,111.15) U35.AD15
+VCCPLL: length 16.1
  TOP w0.254: v3(134.42,127.15) 134.98,127.15 v1(135.41,126.72) 135.41,123.82 133.23,121.64 132.72,121.64 132.31,122.04 131.65,122.04 130.77,121.15 130.77,119.5 130.16,118.89 129.09,118.89 127.88,117.68 v3(127.2,117.68)
+VCCPRIM_3P3: length 25.6
  TOP w0.508: v2(129.1,109.48) v1(129.1,110.3) 128.49,110.91 128.49,111.41 129.13,112.04 129.13,114.05 129.58,114.5 v2(129.76,114.5) ; C261.2 152.96,110 v1(153.47,110.51) 153.35,110.51 152.46,111.4 R186.1
  IN1 w0.508: v1(153.47,110.51) 153.35,110.51 152.08,109.24 148.43,109.24 147.48,110.19 143.99,110.19 143.67,110.51 142.04,110.51 141.47,111.08 140.69,111.08 139.92,111.86 139,111.86
  BOTTOM w0.254: U35.AJ21 129.1,109.37 v2(129.1,109.48)
  BOTTOM w0.305: v2(129.76,114.5) U35.V19
+VCCPRTC: length 10.3
  IN1 w0.229: v2(129.46,107.7) 129.61,107.55 129.66,107.55 129.97,107.24 129.97,105.39 129.94,105.36 129.94,104.98 129.99,104.93 129.99,104.32
  IN1 w0.254: v1(132.77,100.57) 132.77,100.63 129.99,103.41 129.99,104.32
  BOTTOM w0.178: v1(132.77,100.57) 132.83,100.63 U35.BB14
  BOTTOM w0.305: v2(129.46,107.7) 129.57,107.7 U35.AK19
  vias: v1(133.38,100.4)
+VCCPRTCPRIM_3P3: length 45.1
  TOP w0.508: v1(160.2,77.77) 161.07,77.77 v1(161.43,77.4) 161.71,77.13 C348.2 161.74,75.43 C349.1 161.74,74.13 162.08,73.78 162.66,73.78 R240.1
  IN1 w0.508: v1(152.58,93.77) 152.36,93.77 151.9,93.31 151.9,92.5 152.97,91.43 152.97,87.67 155.92,84.71 155.92,80.73 158.88,77.77 v1(160.2,77.77)
  IN2 w0.381: 138.87,101.49 141.76,98.6 148.62,98.6 152.58,94.63 v1(152.58,93.77)
  BOTTOM w0.127: U35.AK17 131.1,108.51 v2(131.1,108.66)
+VCCPSPI: length 15.9
  TOP w0.381: v2(132.39,109.49) 133.21,110.32 133.23,110.32 133.31,110.4 133.75,110.4 133.84,110.32 138.56,110.32 138.89,110.65 140.1,110.65 141.68,109.07 144.73,109.07 v1(145.07,109.41) R193.2
  BOTTOM w0.305: U35.AJ16 132.04,109.06 132.39,109.42 v2(132.39,109.49)
+VCCSA: length 61.5
  TOP w0.127: PR51.2 145.27,184.2 144.61,183.53 v1(144.61,182.72)
  IN1 w0.203: v1(144.61,182.72) 144.61,182.67 144.56,182.62 144.56,182.16 145.47,181.25 149.05,181.25 151.34,178.96 151.34,168.17 146.16,162.99 146.16,144.77 148.55,142.39 v1(149.49,142.39)
  BOTTOM w0.127: 124.12,118.76 U35.K28 ; U35.K28 124.76,118.76 ; U35.K28 124.44,119.08 ; 123.84,118.76 U35.K30 ; 127.18,119.37 U35.G23 ; U35.G23 127.18,120.01 ; U35.G23 126.86,119.69 ; 126.41,119.23 U35.J23 ; U35.J23 126.72,119.54 ; U35.J23 127.04,119.23 ; U35.J23 126.72,118.91 ; 127.32,119.23 U35.J22 127.64,119.54 ; U35.J27 125.21,119.23 ; U35.J27 124.89,119.54 ; U35.J27 124.89,118.91 ; U35.J27 124.58,119.23 ; 125.35,119.37 U35.G27 ; U35.G27 125.35,120.01 ; U35.G27 125.67,119.69 ; 127.18,119.08 U35.K23 ; U35.K23 127.18,118.44 ; U35.K23 126.86,118.76 ; U35.G25 126.58,119.69 ; U35.G25 125.95,119.69 ; U35.G25 126.27,119.37 ; 125.03,118.76 U35.K27 125.35,119.08 ; 126.27,118.44 U35.K25 ; U35.K25 126.27,119.08 ; U35.K25 126.58,118.76 ; U35.G28 124.44,119.37
  vias: v1(126.33,112.55) v1(126.33,111.89) v1(126.33,111.23) v1(126.28,109.63) v1(126.28,108.97) v1(141.46,132.53) v1(147.38,141.42) v2(125.14,118.09) v2(125.67,117.76) v2(126.31,117.71) v3(149.05,143.43) v3(149.94,143.43) v3(150.7,143.43) v3(151.16,142.67) v3(151.59,143.43) v3(152,142.67) v3(152.38,143.43)
+VCCSTG: length 1.5
  BOTTOM w0.203: U35.A22 128.15,123.48 128.15,124.18 v1(128.11,124.22)
  BOTTOM w0.305: U35.G20 129.64,119.41 v2(129.47,119.41)
  vias: v1(133.13,125.22)
+VDDQ: length 151.4
  TOP w0.762: v3(50.89,27.52) 54.59,23.82 73.77,23.82 76.41,26.46 76.41,38.27 v3(78.31,40.18) ; R10887.1 v1(127.49,36.85) ; v3(117.86,53.82) 117.86,54.5 v1(116.82,55.54) 116.33,56.04 R10935.1
  IN1 w0.762: v3(41.22,56.79) 43.15,56.79 45.35,54.6 45.35,54.57 45.54,54.38 45.54,52.68 45.35,52.48 45.35,50.27 46.52,49.1 46.52,34.33 47.16,33.68 47.16,31.47 48.25,30.39 48.25,29.95 48.85,29.36 49.59,29.36 50.89,28.05 v3(50.89,27.52)
  BOTTOM w0.762: 120.38,37.41 120.17,37.61 120.17,49.32 119.72,49.78 119.72,52.9 118.8,53.82 v3(117.86,53.82) ; 120.38,37.41 96.27,37.41 94.06,39.62 81.51,39.62 80.96,40.18 v3(78.31,40.18) ; 120.38,37.41 126.93,37.41 v1(127.49,36.85)
+VDDQC: length 11.8
  IN2 w0.381: v2(117.58,107.18) 118.14,107.74 126.96,107.74 127.51,107.18 v2(127.64,107.18)
  BOTTOM w0.305: U35.AL23 127.64,107.19 v2(127.64,107.18)
  BOTTOM w0.381: v2(117.58,107.18) 117.85,107.45 U35.AM40
+VIN_VCCGT:
  vias: v1(124.57,161.03) v1(131.83,159.53) v3(119.39,159.57) v3(119.67,160.29) v3(120.17,159.53) v3(120.43,160.24) v3(121.09,159.53) v3(121.24,160.27) v3(122.94,161.26) v3(122.94,160.5) v3(128.94,159.53) v3(129.22,160.27) v3(129.93,159.53) v3(130.18,160.27) v3(130.94,159.53) v3(131.15,160.29)
AVCC33:
  vias: v1(26.14,66.01)
DVDD_IO: length 1.4
  BOTTOM w0.203: v1(205.4,36.88) U23.9
  vias: v1(206.61,36.44)
GND: length 2678.5
  TOP w0.102: C4749.1 18.84,70.49 v1(19.23,70.1)
  TOP w0.127: v1(15.17,76.85) 14.92,76.6 v1(13.77,76.6) ; v1(18.04,67.63) v1(16.59,69.08) v1(16.59,71.32) 16.59,74.14 v1(16.67,74.21) 16.82,74.37 16.82,75.84 v1(16.66,76) ; v1(8.39,74.26) 10.24,74.26 10.55,73.96 10.55,73.2 11.6,72.15 C336.1 12.12,71.29 v1(12.52,70.9) v1(14.09,69.32) 17,66.42 17,65.96 v1(18.14,64.82) ; v1(8.64,78.48) 11.27,78.48 v1(11.36,78.39) ; v1(21.12,66.33) 21.12,66.12 19.74,64.74 19.2,64.74 R222.2 ; v1(12.12,74.06) 14.86,74.06 v1(15.04,73.88) 15.32,73.6 v1(15.32,70.28) 15.32,69.13 17.99,66.47 v1(17.99,66.19) ; v1(18.14,68.78) 18.09,68.78 17.66,69.21 17.66,70.56 18.37,71.27 v1(18.47,71.27) 18.12,71.62 18.12,72.87 v1(18.47,73.22) v1(18.47,74.82) v1(18.47,76.6) 18.47,76.61 v1(16.69,78.39) C319.1
  TOP w0.178: U9.38 29.61,120.6 U9.19 ; U9.6 v1(32.92,119.4) ; v1(158.72,179.93) 159.11,179.93 159.24,180.06 159.24,180.39 159.12,180.51 PU5.22 ; U9.3 v1(32.66,118.2)
  TOP w0.203: U13.24 21.26,66.95 21.12,66.8 v1(21.12,66.33) ; PU21.1 43.14,57.99 v1(43.04,58.09) ; v2(120.51,102.78) 120.21,102.48 C313.1 ; C308.1 126.15,103.07 126.15,103.07 125.86,102.78 v2(125.49,102.78) ; C198.1 101.34,115.51 v1(101.16,115.33) ; U28.12 29.95,109.35 v1(29.93,109.38) ; PU21.21 45.14,57.16 PU21.14 47.25,57.16 v1(47.7,56.72) ; v1(16.59,45.26) 16.74,45.1 17.05,45.1 17.23,45.29 U18.17 ; C239.1 108.63,103.65 v1(108.41,103.87) ; v1(106.92,100.5) 107.08,100.65 C205.1 ; C311.1 122.14,103.83 v2(122.11,103.86)
  TOP w0.254: v1(171.25,97.28) 171.63,96.9 CN2.10 ; R1323.1 214.19,121.57 v2(214.18,121.56) ; U16.5 131.23,84.98 130.84,85.36 130.84,86.33 133.74,89.22 133.74,91.61 v1(134.37,92.25) ; v1(14.61,89) 14.59,89.02 14.23,89.02 14.04,88.83 U40.1 ; U17.6 85.4,83.12 v1(87.56,85.28) ; U4512.5 168.72,84.83 v1(168.1,85.44) ; v1(204.25,49.75) 203.61,49.12 v1(201.99,49.12) 196.32,49.12 191.47,53.97 187.18,53.97 184.54,56.61 184.54,59.86 181.54,62.86 181.09,62.86 179.57,64.38 175.74,64.38 174.28,62.92 171.24,62.92 170.33,62.01 165.68,62.01 v1(165.61,62.07) 164.85,62.07 164.63,61.85 163.04,61.85 161.66,60.47 159.57,60.47 157.77,62.28 157.77,62.73 155.58,64.92 v1(152.3,64.92) ; v3(115.98,157.07) 115.4,157.07 115.01,156.67 Q3.4 ; CN2.8 170.63,94.8 v1(170.31,94.48) ; U4512.8 170.49,85.98 v1(170.21,86.31) ; 170.5,83.13 U4512.6 171.93,83.12 172.27,83.46 U4512.7 ; v2(118.56,103.9) 118.71,103.74 C312.1 ; CN2.14 173.63,95.15 173.91,94.87 173.91,94.59 174.02,94.48 v1(174.05,94.48) 174.02,94.51 174.02,94.58 173.87,94.43 173.26,94.43 172.63,95.06 CN2.12 ; Q3.1 113.71,152.99 113.54,152.83 113.26,152.83 112.73,153.36 v1(112.73,153.46) ; U4513.3 14.79,116.4 v1(14.71,116.48) ; v1(152.33,67) 152.36,67.03 154.91,67.03 156.62,65.32 156.62,65.28 158.8,63.1 161.73,63.1 162.11,62.72 163.9,62.72 164.61,63.43 169.74,63.43 170.65,64.35 173.69,64.35 174.8,65.46 180.03,65.46 181.11,64.38 182.16,64.38 186.24,60.31 186.24,57.42 188.22,55.44 192.08,55.44 196.35,51.18 205.16,51.18 205.85,50.49 v1(205.85,50.11) ; U17.5 81.21,84.87 81.07,85.02 81.07,87.35 81.21,87.49 81.21,87.5 82,88.29 82.01,88.29 83.94,90.22 87.2,90.22 v1(87.56,89.86) ; v1(87.56,88.84) 84.46,88.84 82.99,87.37 U17.8 ; U22.14 20.75,26.24 v1(20.83,26.16) ; D5.2 134.55,75.51 134.55,77.08 136.02,78.56 136.02,85.23 135.3,85.95 134.2,85.95 133.93,85.67 U16.8
  TOP w0.305: U17.2 84.34,83.97 U17.7 84.76,84.82 85.19,85.24 85.19,85.84 87.03,87.68 v1(87.56,87.68) ; U8.3 184.12,36.61 184.26,36.75 184.26,37.31 ; v2(120.3,120.68) 120.3,120.68 120.05,120.42 C227.1 ; v1(9.2,87.78) 9.73,87.78 9.82,87.86 U37.3 ; v1(146.84,184.02) 146.84,184.16 146.38,184.63 PC33.2 ; R178.2 140.52,112.73 v2(139.35,112.73) ; v1(11.79,87.85) 11.23,87.85 11.12,87.97 U37.1 ; PR250.1 48.38,57.41 47.71,56.73 47.74,56.7 47.7,56.7 47.68,56.72 v1(47.7,56.72) ; U40.3 v1(12.03,88.5) ; v2(123.05,106.48) 122.6,106.93 C297.1 ; C1420.2 215.83,136.8 v2(216.03,137) ; PC21.1 136.81,170.55 136.81,169.67 v1(136.94,169.54) 136.45,169.06 136.41,169.06 PC11.2
  TOP w0.381: PQ3.1 48.75,31.7 49.47,31.7 49.5,31.73 v1(49.48,31.73) ; C1386.2 176.47,166.5 v2(176.38,166.59) ; v1(162.77,76.14) 162.72,76.14 162.49,75.92 C348.1 ; v2(212.6,137.85) 212.6,137.5 212.26,137.17 R1319.2 ; C337.1 13.42,71.7 v1(13.19,71.47) ; v1(29.95,67.58) 29.83,67.71 C4748.1 ; v1(29.98,25.06) 29.57,24.66 C4611.2 ; PC214.2 37.9,92.96 v1(37.5,92.55) ; D27.2 v1(55.2,16.02) ; PC9.2 153.44,168.26 153.68,168.03 PD2.2 155.07,168.91 155.07,168.93 v1(155.25,169.11) ; v1(109.38,56.8) 109.88,57.31 C1317.1 ; C1544.2 206.93,145.78 v2(207,145.85) ; v1(189.8,172.09) 189.83,172.11 C1764.2 ; R1472.2 179.88,161.32 179.55,160.98 v2(179.55,160.99) ; v1(43.26,52.15) 43.26,52.13 43.37,52.25 PC203.2 PC196.2 ; v1(133.84,170.96) 134.2,170.6 PC7.1 PR342.1 ; C322.2 133.31,102.31 v1(132.8,102.81) 132.37,102.38 C352.1 ; v1(183.19,123.1) 182.94,122.85 R4338.2 ; v1(217.13,172.92) 217.67,172.92 PR117.1 ; C250.2 v1(144.96,112.67) C230.2 ; C1275.2 143.86,48 143.49,48 143.49,48 v1(143.31,48) ; R860.1 190.64,140.83 v2(190.61,140.87) ; C1436.2 214.17,117.58 v2(214.18,117.6) ; v2(172.37,156.21) 172.39,156.22 C1435.2 ; PC123.1 158.72,179.59 v1(158.72,179.93) ; C4598.1 v1(36.51,66.24) ; v2(217.38,119.2) 217.36,119.18 C1415.2 ; C1402.1 218.63,142.14 v2(218.6,142.11) ; C265.2 143.94,110.25 v1(143.44,109.75) 143.44,110 143.06,110.38 R778.2 ; v1(157.89,174.7) 158.26,175.06 PC130.1 159.7,175.06 159.96,175.31 PC125.1 160.38,175.42 PR15.1 ; C1439.1 206.17,128.01 v2(206.18,128) ; R364.2 16.58,29.57 v1(16.97,29.97) ; v1(37.19,63.11) 37.22,63.14 R11262.2 ; U38.3 v1(8.97,75.97) ; C1448.1 167.64,167.87 v2(168.23,167.87) ; R4311.1 188.91,112.8 v1(189.01,112.9) ; C1458.2 206.93,141.11 v2(207,141.05) ; v1(43.87,69.11) 43.88,69.12 C4604.2 ; v1(98.76,137.28) 98.76,137.72 C628.2 ; v1(11.87,85.95) C305.2 ; C305.2 C300.1 v1(10.1,85.12) ; C305.2 C304.1 ; v1(126.72,100.48) 126.73,100.49 C327.2 ; C4029.1 189.84,123.33 190.54,124.03 v1(190.63,124.03) ; C168.1 180.12,34.72 v1(180.85,33.98) ; v1(125.24,60.4) 125.3,60.47 125.48,60.47 125.81,60.8 125.81,60.97 125.81,61.34 125.53,61.61 R10927.2 ; C244.1 32.7,70.76 v1(32.26,70.33) 31.81,70.78 C4596.2 ; C291.2 112.68,107.59 112.2,107.1 v2(112.09,107.1) 111.43,107.77 C290.2 ; 139.73,167.3 139.96,167.53 140.36,167.53 PC14.2 ; 139.73,167.3 v1(139.73,167.23) ; 139.73,167.3 138.94,166.52 PR180.2 ; C687.2 99.13,123.09 v1(99.47,123.43) ; C1457.1 206.17,149.07 v2(206.2,149.05) ; v2(219.79,118.4) 219.78,118.39 C1513.1 ; R4309.1 v1(197.29,112.92) ; v1(162.14,106.42) 161.6,105.89 R127.1 ; v1(119.16,166.85) 119.16,167.05 118.43,167.78 C27.1 C16.1 ; v2(195.77,165.81) 195.7,165.75 C19.2 ; C4616.2 32.24,25.55 31.88,25.19 v1(31.88,25.09) ; v1(179.28,48.97) 179.86,49.55 C747.2 ; v1(14.53,52.9) C383.2 14.96,53.6 15.1,53.75 R11277.2 ; C716.2 13.98,81.43 v1(14.38,81.83) ; R11258.2 v1(39.05,64.28) 39.53,64.28 39.69,64.44 C4600.1 ; v1(112.63,41.83) 112.64,41.82 C1309.2 ; PQ40.1 150.53,175.94 150.53,176.93 v1(150.45,177.01) 150.2,177.26 150.2,177.8 PC25.1 ; v2(175.37,159.28) 175.34,159.28 175.33,159.29 C1497.2 ; PR11.1 150.96,181.33 150.73,181.55 v1(150.37,181.55) ; C1418.2 219.9,126.28 v2(219.79,126.4) ; v2(199.91,166.32) 199.97,166.38 C1440.2 ; C1391.2 168.18,161.81 v2(168.19,161.79) ; C4749.1 18.84,70.89 v1(18.47,71.27) ; v1(149.08,168.7) 149.28,168.5 PC8.2 150.42,168.05 PD1.2 ; v2(130.43,107.17) 130.49,107.11 R685.1 ; v2(176.38,155.39) 176.32,155.33 C1377.2 ; C1504.2 206.98,124.94 v2(206.98,125.6) ; C4603.2 v1(44.53,71.29) ; v1(148.9,120.09) 148.78,120.2 R563.1 ; v1(143.31,49.32) 143.33,49.35 C1251.2 143.94,49.35 EC35.2 ; v1(115.45,109.24) 115.45,109.09 114.98,108.61 R11044.2 ; PC103.1 47.83,35.84 v1(48.19,35.48) ; v1(135.13,73.58) 134.85,73.87 C379.2 134.84,74.22 D5.2 ; v1(18.04,67.63) 18.34,67.33 R213.2 ; R4310.1 v1(196.27,112.92) ; v1(15.17,76.85) 15.69,76.85 C320.1 ; v1(17.99,66.19) 18.09,66.29 18.64,66.29 R219.2 ; C754.1 177.8,51.57 177.4,51.18 v1(173.28,51.18) ; PR49.2 142.09,186 141.31,185.21 PC45.1 141.21,184.13 v1(141.15,184.07) ; R4314.1 v1(198.3,112.92) ; v2(179.74,167.97) 179.82,168.05 C1543.1 ; R174.1 v1(145.04,113.94) ; C4785.2 v1(19.35,55.53) C4786.2 ; C284.2 125.34,107.64 v2(125.84,107.15) ; v1(11.36,78.39) C319.1 ; v1(22.54,62.88) C4752.1 C4751.1 ; C348.1 162.49,74.52 C349.2 ; C348.1 163.3,75.46 163.38,75.53 C314.2 ; v2(188.53,161.01) 188.46,160.94 C1549.1 ; R606.1 147.88,107.97 v1(147.5,107.59) 148.14,106.95 R764.1 ; v2(211.78,128.8) 211.25,129.33 R1318.2 ; v1(156.47,172.26) 156.47,172.28 155.81,172.94 PC132.1 ; R156.1 97.46,123.67 v1(97.68,123.45) 97.33,123.09 C686.2 ; R646.1 158.87,73.17 R635.1 159.1,73.19 159.44,73.53 v1(160.2,73.53) ; R4209.1 182.94,118.36 v1(183.09,118.21) ; C804.1 121.46,173.39 v1(121.67,173.6) ; PR250.1 48.49,57.4 PC217.2 ; C1423.2 215.31,121.9 v2(215.38,121.83) ; C555.2 57.6,20.36 v1(58.07,19.88) ; C333.1 v1(12.12,74.06) ; C4204.2 173.74,121.7 v1(173.88,121.55) ; C355.2 v1(37.27,79.27) ; C718.2 v1(14.41,79.39) ; R4315.1 189.92,112.67 v1(190.05,112.8) ; v1(154.92,184.75) 154.92,184.85 154.91,184.86 PR3.1 ; C1414.2 216.73,146.52 v2(216.6,146.65) ; v1(12.81,72.08) 12.74,72.15 C336.1 ; C323.2 124.44,100.25 v1(124.44,100.25) ; D26.2 v1(54.1,16.02) ; C1413.2 191.79,155.46 v2(191.75,155.41) ; v2(190.51,168.4) 190.6,168.3 C1499.2 ; C4606.1 v1(43.63,72.4) 44.09,72.86 Y1.4 ; PR13.1 153.86,178.22 154.29,177.79 v1(154.29,177.72) ; v1(119.64,170.96) 120.03,170.57 C577.1 C578.1 ; v1(188.02,113.15) 187.89,113.02 R4211.1 ; C1498.1 188.25,167.8 v2(188.4,167.94) ; C764.2 220.42,72.15 220.69,72.42 220.69,73.65 v1(219.82,74.52) 219.11,75.23 v1(218.75,75.23) ; v1(130.05,171.77) 130.74,171.77 131.17,172.21 PC6228.2 ; v2(178.8,155.37) 178.85,155.32 178.85,154.78 179.06,154.57 C1398.1 ; PC210.2 39.01,99.93 v1(39.02,99.92) ; v2(209.38,120.8) 209.49,120.9 C1388.2 ; v2(196.55,159.41) 195.89,159.41 C1396.2 ; D24.2 v1(58.62,16.02) ; R598.1 R595.1 149.61,104.92 v1(149.66,104.87) ; C1419.2 211.57,149.27 v2(211.8,149.05) ; v1(206.3,187.65) 205.75,187.65 205.41,187.99 C756.1 C759.1 ; v1(23.76,31.26) 23.75,31.27 C469.1 ; PC135.2 146.17,174.95 PC23.2 ; v1(9.07,81.05) U36.3 v1(11.61,81.05) ; v1(46.77,54.37) 47.53,54.37 PR265.2 ; R4011.2 168.91,126.25 169.27,126.61 v1(169.73,126.61) ; v1(43.67,74.8) 43.38,75.09 C4605.1 ; v2(219.79,128.8) 219.78,128.81 C1421.1 ; C1538.1 188.49,155.46 v2(188.55,155.39) ; v2(206.18,118.4) 206.17,118.38 C1422.1 ; C381.2 v1(77.79,47.63) ; C4115.1 194.03,134.22 v2(193.91,134.11) ; v1(108.97,44.48) 109.2,44.26 C1258.1 ; C714.2 11.1,83.02 10.7,82.62 v1(9.61,82.62) ; v1(149.92,101.83) 149.87,101.87 R759.2 ; D6.2 v1(12.8,53.6) ; v1(21.67,42.31) 21.65,42.34 C4607.2 ; PC41.2 143.26,185.22 PC139.2 143.41,185.25 144.16,184.49 PC46.1 144.28,184.17 143.92,183.81 143.92,183.05 v1(143.62,182.75) ; v1(52.43,71.52) 51.99,71.96 PC113.1 51.62,72.16 51.36,72.41 PQ16.1 ; v1(153.74,105.43) 153.74,105.57 153.48,105.82 R199.1 ; v1(135.13,180.41) 135.18,180.37 PR206.2 135.18,179.59 134.75,179.17 PC35.2 ; v2(219,148.25) 219.02,148.22 C1403.1 ; v2(206.2,138.65) 206.17,138.62 C1438.1 ; v2(199.78,155.39) 200.4,155.39 C1394.1 ; v1(79.56,48.66) 79.69,48.8 C380.2 C382.2 ; C1537.2 172.38,165.76 v2(172.37,165.76) ; C750.2 128.7,100.57 129.1,100.17 129.1,99.85 130.82,98.12 130.82,96.3 v1(130.87,96.26) ; D25.2 v1(59.72,15.95) ; C4599.1 42.12,67.08 v1(42.6,67.56) 42.12,68.04 C363.1 ; PC3.1 153.43,186.58 152.55,186.58 PC6.1 152.51,186.23 152.89,185.85 v1(152.86,185.85) ; C1211.2 191.07,138.74 v2(190.62,138.29) ; v1(105.16,131.41) 104.74,131.84 C818.1 ; v2(215.8,140.25) 215.82,140.27 C1450.2 ; v2(190.95,164.22) 190.3,163.57 R1466.2 ; v1(138.41,170.1) 138.36,170.05 138.36,169.31 138.82,168.84 PC15.2 ; C1266.2 147.65,49.54 147.22,49.12 v1(147.02,49.12) ; v1(18.04,30.2) 18.54,29.7 C483.2 ; C1401.1 168.33,156.24 v2(168.39,156.17) ; v1(20.76,42.31) C386.2 C4609.2 ; R11273.2 19.58,53.75 v1(19.96,53.37) 20.34,53.75 R11276.2 ; v1(13.77,76.6) C724.2 ; R681.1 R678.1 128.14,102.96 v2(127.97,102.78) ; C757.2 v1(39.3,79.27) ; C273.1 v2(120.67,122.22) ; R11114.1 154.38,72.43 154.53,72.58 155.88,72.58 v1(155.89,72.59) 155.89,72.58 R256.2 ; R222.2 18.4,65.25 18.14,64.99 v1(18.14,64.82) ; C794.1 155.68,115.11 156.06,115.49 v1(156.06,115.67) ; PC180.2 v1(39.07,92.6) ; PC28.2 145.1,178.45 144.84,178.71 v1(144.71,178.71) ; C458.2 v1(19.45,35.39)
  TOP w0.508: Q6060.1 147.07,71.95 147.33,71.7 v1(147.94,71.7) 149.76,71.7 Q6059.1 151.14,72.45 R786.2 v1(152.25,71.72) ; v1(34.35,79.9) 34.3,79.85 C365.2 ; v1(68.13,104.9) 68.13,104.72 68.69,104.16 PQ8.1 ; PR82.1 64.58,75.42 64.83,75.66 67.26,75.66 v1(67.99,76.4) ; C176.1 C174.1 133.97,123.17 v2(133.01,122.22) ; C282.1 117.25,119.36 v2(116.67,119.94) ; Q26.2 v1(18.62,59.07) ; v1(28.12,73.21) C758.2 C761.2 ; C318.2 117.58,102.33 v2(118.03,102.78) ; v1(43.62,33.8) 43.14,33.32 PQ11.1 43.07,32.62 PR147.2 ; v1(34.55,26.28) 35.19,26.28 35.58,25.89 C4618.1 ; v1(72.95,9.65) C545.2 ; v1(128.2,41.29) 128.2,40.8 R10873.1 ; v1(116.49,35.43) 116.71,35.21 C4822.1 116.71,34.35 116.29,33.93 Q76.1 ; R145.1 136.4,125.12 v1(136.81,124.71) 136.96,124.86 136.97,124.86 C699.1 ; v1(16.69,113.66) 16.44,113.41 C4819.2 ; C4820.1 14.75,112.93 v1(14.71,112.9) ; v1(71,107.46) 70.9,107.56 PR140.2 ; v2(132.8,127.15) 132.8,127.38 R109.2 ; v1(137.09,166.72) 138.13,167.76 PC10.1 ; v1(56.65,42.74) 55.89,41.98 PR6297.2 ; v1(169.62,107.15) 168.9,107.15 168.24,107.8 Q4001.1 ; C4615.2 v1(43.72,24.53) ; PC122.2 160.45,178.24 v1(159.87,178.81) ; v1(39.68,67.08) 39.54,67.08 39.54,67.07 39.18,67.07 C760.2 ; PC193.2 v1(206.94,102) ; v1(82.1,113.43) C710.1 C711.1 ; HOLE7.3 135.92,190.17 HOLE7.4 ; v1(101.12,130.83) 100.64,131.31 C817.1 ; v1(46.64,22.42) 46.79,22.27 CN4.12 ; C4617.2 34.39,25.43 v1(33.99,25.83) ; C505.2 v1(17.57,17.68) ; C4782.1 47.97,70.77 v1(47.76,70.56) ; PC71.2 v1(36.05,45.74) ; v1(34.47,65.63) 34.47,66.01 34.76,66.3 C4597.1 ; R10877.2 127.82,46.27 127.54,46 v1(127.15,46) ; C4821.1 36.25,63.57 36.71,63.11 v1(37.19,63.11) ; v2(119.48,106.48) 118.76,106.48 C289.1 ; PC109.1 PR158.2 v1(51.76,68.49) 51.78,68.47 PC283.2 ; v1(219.26,66.97) 219.36,66.97 219.99,67.6 C765.2 ; C1447.2 224.94,118.17 v1(224.87,118.1) ; v1(204.65,192.93) 204.28,192.56 C344.1 ; C345.1 v1(205.41,192.92) ; C4106.1 193.11,122.44 v2(193.1,122.42) ; C4727.2 C4728.2 156.55,61.44 158.19,59.79 v1(158.43,59.79) ; C328.2 122.94,101.35 122.94,102.71 v1(123.01,102.78) ; C4613.2 v1(41.18,24.66) ; HOLE7.9 131.22,190.17 HOLE7.8 ; PQ6.1 75.01,107.59 v1(75.11,107.49) ; v3(222.97,159.64) 222.58,159.26 221.4,159.26 PC287.2 ; PC87.2 v1(63.68,20.09) ; v1(67.87,100.6) 68,100.73 PC101.1 ; 39.93,31.52 v1(41,31.52) ; v1(109.38,64.9) 109.69,64.58 C1321.2 ; R10938.2 C1323.2 116.19,58.57 115.8,58.95 v1(115.5,58.95) ; R1438.1 173.03,159.91 172.53,159.41 v2(172.37,159.41) ; C1255.2 126.77,40.95 127.03,41.22 v1(127.03,41.8) C1259.2 ; HOLE7.6 HOLE7.1 HOLE7.2 ; v1(17.57,8.66) C518.1 ; C1262.2 123.9,42.73 v1(122.24,41.07) ; R301.1 v1(76.38,51.2) ; PQ9.1 43.57,115.08 v1(43.92,115.44) ; PC208.2 34.36,97.11 v1(34.32,97.15) 34.22,97.25 PC189.2 ; C191.1 C680.2 145.68,122.91 146.08,123.31 v1(146.59,123.31) ; v1(46.16,76.17) 46.18,76.14 46.18,75.93 46.37,75.74 Y1.2 ; C556.2 D28.1 78.58,11 v1(78.44,10.87) ; PC102.1 v1(48.67,107.59) ; PR10.1 157.84,170.87 157.84,171.75 v1(157.87,171.9) 157.46,172.31 157.44,172.31 157.42,172.33 PC126.2 ; R11188.2 v1(25.46,73.68) 25.19,73.94 R11287.2 ; v1(29.85,20.59) 29.87,20.58 CN4.6 ; C1257.2 149.28,46.99 149.28,45.89 148.9,45.51 v1(148.64,45.51) ; R11043.2 110.72,102.82 v2(110.74,102.83) ; C4754.1 v1(20.28,61.92) ; v1(152.33,74.72) 152.26,74.79 152.26,75.4 C748.1 ; v1(44.89,31.24) 44.76,31.36 PR150.2 ; R11264.1 v1(42.22,79.32) ; v1(119.33,100.48) 119.59,100.74 C326.2 ; R1508.1 C1551.2 R1510.1 v1(162.41,160.93) ; v1(48.07,43.4) 48.61,43.4 49.17,43.97 49.17,44.27 PC61.1 48.54,44.29 PR54.2 ; C548.2 75.49,9.57 75.52,9.54 v1(75.49,9.54) ; PC135.2 146.18,174.49 v1(145.85,174.16) ; v1(21.65,114.19) 21.91,114.46 C4818.1 C4817.2 ; v1(149.76,52.72) 149.53,52.72 149.06,52.25 C1267.2 149.06,51.66 148.97,51.57 C1265.2 ; C354.2 v1(35.49,79.14) ; v1(28.91,110.15) 28.44,110.15 C4765.1 28.47,109.49 v1(28.91,109.49) ; v1(12.27,114.6) 11.89,114.98 C4648.1 ; v1(24.19,53.58) 24.29,53.48 R11064.1 ; C701.1 77.93,97.34 v1(77.72,97.56) 76.92,96.75 C700.1 ; PAD6.1 143.96,84.18 v1(145.32,82.82) ; v1(11.99,115.74) 11.61,116.12 C4768.1 ; v1(37.62,50.92) 38.66,51.96 PQ6057.1 ; v1(165.79,113) 166.3,112.49 C4019.2 ; C4753.2 v1(20.18,73.14) ; v1(145.14,126.84) 145.14,126.54 145.69,125.99 C182.1 ; PQ14.1 v1(45.14,108.1) ; C4113.1 177.51,138.95 v1(177.98,138.47) 178.23,138.72 C4108.1 ; C4614.2 38.77,24.39 v1(38.77,23.97) 38.56,23.77 37.85,23.77 37.37,23.29 CN4.3 ; C1247.2 143.22,52.71 v1(143.44,52.93) ; C817.1 100.38,131.84 100,131.46 C819.1 ; C817.1 C814.1 ; C511.2 v1(20.13,17.68) ; Q4.1 v1(109.94,156.99) ; PC223.2 52.24,93.57 v3(51.98,93.82) ; v1(115.46,66.26) 114.93,66.79 C1313.2 ; v1(138.43,53.22) 138.77,52.89 C1272.2 ; v1(34.52,96.36) 35.06,95.83 PC185.2 ; v1(17.71,23.18) 17.71,23 17.91,22.8 C497.1 ; EC51.1 18.24,109.85 18.78,109.32 v1(19.16,109.32) ; v1(71.05,102.13) 71.3,102.38 PQ7.1 ; v1(188.8,105.94) 189.3,106.43 189.3,106.95 189.54,107.2 C4028.1 ; v1(136.15,52.75) 135.53,52.13 C1246.2 ; v1(69.14,91.84) 69.75,92.45 PQ5.1 ; v1(115.25,60.4) 114.88,60.04 C1264.2 ; v1(127.21,39.36) 127.18,39.39 R10895.2 ; C4041.2 v1(195.41,107.94) ; C1324.2 148.41,59.74 147.94,60.21 C1320.2 147.63,60.05 147.39,59.81 v1(146.97,59.81) ; C1248.2 90.01,50.76 v1(90.66,50.11) ; R130.1 184.32,37.49 v1(184.26,37.43) 184.26,37.31 ; v1(43.8,78.1) 43.17,77.47 C762.2 ; C4037.1 176.11,138.85 176.65,139.39 v1(176.72,139.39) 176.24,139.87 C4040.2 ; C709.2 C708.2 81.22,100.61 80.86,100.25 v1(79.64,100.25) ; C4784.1 C4608.2 15.29,42.94 v1(15.25,42.9) ; v1(118.17,67.05) 117.75,67.05 R10930.2 ; v1(209.78,174.52) 209.91,174.64 PC246.2 ; v1(54.26,116.1) 53.96,115.79 PU4.5 ; C4764.1 11.84,117.11 v1(12.38,116.58) ; v1(211.96,33.97) 211.9,33.91 R394.2 ; C517.1 v1(20.13,9.99) ; v1(179.38,138.58) 179.52,138.58 C965.2 ; v1(135.89,61.68) 135.48,61.68 134.95,62.21 C1308.2 ; C368.1 48.66,65.23 v1(48.14,65.76) ; R10937.2 148.06,56.13 147.83,56.36 R10943.2 146.2,57.47 ; C3001.1 v1(115.78,35.45) ; C1330.2 99.24,53.65 v1(98.81,54.08) ; C546.2 v1(74.22,9.6) ; R720.2 v1(14.56,58.44) ; v1(224.34,142.77) 224.34,143.15 224.43,143.24 C1408.2 ; v1(93.22,50.11) 93.23,50.12 C1263.2 ; C1327.2 116.24,60.98 115.54,61.67 v1(115.25,61.67) ; PC104.1 v1(52.25,116.61) ; v1(145.34,65.04) 145.69,64.7 C1328.2 ; PQ6058.1 v1(33.84,52.09) ; v1(41.97,112.29) 40.7,112.29 40.42,112.57 PQ13.1 ; PC116.1 162.69,184.6 v1(162.87,184.78) 163.12,185.02 PC2.2 PC115.1 ; v1(209.07,37.21) 208.51,36.65 R375.2 ; PR119.2 v1(37.42,45.74) ; C334.1 v1(16.66,76) ; v1(175.59,140.84) 175.56,140.86 C4036.2 ; v1(20.1,21.43) 19.63,21.9 C496.1 ; PR145.2 53.88,106.83 v1(53.96,106.9) PU4.4 ; C551.2 v1(76.76,9.54) ; v1(39.5,38.86) 39.12,39.24 PQ4.1 ; Q17.1 v1(24.06,107.51) ; v1(31.3,23.97) 31.31,23.98 C4612.2 ; C1250.2 127.95,43.89 v1(127.15,44.68) ; HOLE19.1 12,123.57 ; C1331.2 113.89,61.64 v1(113.31,61.64) ; R11200.2 v1(17.68,112.93) ; v1(93.97,54.11) 94.73,54.87 C1312.2 ; C3000.1 v1(113.93,30.37) ; Q15.1 v1(28.28,105.94) ; v1(53.24,116.1) 52.69,115.54 PU4.6 ; v1(23.31,51.4) C4783.1 C413.2 C4787.2 ; R11210.2 v1(31.68,113.18) ; C1334.2 138.14,54.29 v1(138.43,53.99) ; PC88.2 v1(63.66,21.1) ; CN4.13 v1(21.85,18.8) ; HOLE24.6 HOLE24.1 ; C4767.1 v1(19.49,113.56)
  TOP w0.762: PC190.2 183.78,92.86 v3(183.44,93.19)
  IN1 w0.203: v1(149.51,141.65) 148.65,141.65 145.81,144.48 145.81,163.15 150.98,168.32 150.98,178.71 148.85,180.84 145.29,180.84 143.62,182.52 v1(143.62,182.75) ; v3(129.62,170.12) 129.62,170.1 129.09,169.56 126.93,169.56 124.09,166.72 119.28,166.72 v1(119.16,166.85) 119.03,166.72 116.82,166.72 113.65,163.55 113.65,159.94 112.27,158.57 112.27,155.8 112.72,155.35 112.73,155.35 112.76,155.32 113.02,155.32 113.28,155.06 113.28,151.47 109.66,147.85 109.66,144.24 v1(109.45,144.04) ; v1(144.23,150.54) 144.28,150.49 144.89,151.1 144.89,163.52 149.71,168.35 149.71,170.43 149.36,170.78 149.36,172.51 150.15,173.3 150.15,175.15 149.66,175.64 147.96,175.64 146.49,174.16 145.95,174.16 145.93,174.19 145.88,174.19 v1(145.85,174.16)
  IN2 w0.14: v1(117.43,129.61) 117.43,129.48 118.01,128.9 118.34,128.9 118.65,128.59 118.65,122.85 119.01,122.5 119.01,121.18 119.28,120.9 120.08,120.9 v2(120.3,120.68) 120.43,120.68 120.78,121.06 120.78,122.1 v2(120.67,122.22) 119.34,123.55 119.34,127.07 119.49,127.22 119.49,129.41 v1(119.82,129.74)
  BOTTOM w0.127: U35.AK11 134.63,108.39 134.24,108.79 v2(133.86,108.79) ; v1(117.43,129.61) 117.49,129.67 117.49,129.98 116.64,130.83 ; v1(188.91,123.22) 188.48,122.79 U3002.K5 ; v1(147.5,107.59) 147.71,107.39 152.48,107.39 152.84,107.74 v1(153.85,107.74) ; 105.19,111.62 105.14,111.62 105.06,111.7 105.06,112.47 104.96,112.57 104.51,112.57 U35.AA65 ; R592.1 146.49,105.56 147.12,106.19 152.58,106.19 152.96,105.81 153.35,105.81 v1(153.74,105.43) ; C351.1 154.49,108.22 154.79,108.53 156.98,108.53 157.16,108.35 157.16,104.79 156.9,104.54 154.57,104.54 154.49,104.62 C362.1 ; U5.J1 188.95,161.41 v2(189.35,161.01) ; v2(135.82,107.94) 135.92,108.05 136.28,108.05 136.62,108.39 U35.AK8 ; Y4.2 114.8,133.15 114.46,133.5 v1(114.46,134) 114.46,135.63 114.74,135.91 116.69,135.91 Y4.4
  BOTTOM w0.14: v2(178.5,142.09) 178.48,142.12 U3002.AB30 ; v1(172.99,133.26) 173,133.26 U3002.AH19 ; v1(191.73,136.4) 191.93,136.19 U3002.E22 ; U3002.N28 v2(185.58,140.84)
  BOTTOM w0.152: U35.BB60 106.94,101.4 106.94,100.52 v1(106.92,100.5) ; v2(180.55,140.82) 180.98,141.24 U3002.W28 ; U35.B22 128.05,122.59 127.84,122.38 127.84,122.03 128.05,121.82 U35.D22
  BOTTOM w0.157: v1(124.44,100.25) 124.32,100.37 124.32,101.4 U35.BB30
  BOTTOM w0.178: v1(121.7,99.64) 121.68,99.66 121.68,101.41 U35.BB34 ; v1(61.77,20.82) PU11.11 ; PU10.11 56.95,54.45 v1(56.8,54.3) ; v1(194.82,114.99) 194.98,114.83 v1(194.98,114.09) ; v1(191.62,117.49) 192.09,117.49 194.19,115.4 C4207.1 ; U3002.AH5 173.88,122.35 173.88,123.18 U3002.AH7 ; 138.63,119.56 138.51,119.69 138.51,120.38 138.86,120.74 U35.F4 U35.F2 139.99,121.02 140.34,121.02 U35.F1 140.82,120.87 141.84,121.89 v1(142.88,121.89) ; v1(116.7,100.46) 116.73,100.48 U35.BB43 ; v1(193.12,110.31) 193.78,110.31 194,110.52 195.54,110.52 195.67,110.65 195.67,112.74 195.37,113.04 Y4200.4 ; v1(99.46,107.08) 99.63,107.24 100.23,107.24 U35.AM71 ; v1(126.72,100.48) 126.66,100.53 U35.BB26 ; U35.AG71 100.16,109.9 99.83,109.9 99.61,110.12 99.41,110.12 99.39,110.14 v1(99.36,110.14) ; v1(119.33,100.48) 119.33,100.48 U35.BB38 ; v1(99.42,119.34) 99.58,119.5 100.51,119.5 U35.H71 ; v1(109.6,100.39) 109.56,100.43 U35.BB55 ; U35.AV68 102.47,104.07 102.51,104.11 102.51,104.37 102.46,104.42 102.46,104.8 102.46,104.8 U35.AT68 ; Y4200.2 192.37,111.34 191.62,112.08 191.62,114.37 v1(192.27,115.01) 192.27,115.25 v1(190.57,116.95) ; U35.AT71 100.46,104.94 99.46,104.94 99.46,104.94 v1(99.44,104.94)
  BOTTOM w0.203: U35.AT68 102.46,105.03 102.46,105.03 102.46,105.28 102.5,105.33 102.5,105.61 102.46,105.66 102.46,106.02 102.46,106.03 U35.AP68 102.46,106.53 102.5,106.57 102.5,106.82 102.46,106.86 U35.AM68 ; U35.E18 130.84,120.9 130.36,120.42 130.36,119.52 U35.H18 ; U3002.B31 195.15,143.71 196.62,143.71 v2(196.64,143.69) ; U35.BA1 140.35,101.55 U35.BA2 ; v1(141.51,103.17) 141.28,103.4 140.99,103.4 U35.AV1 ; U3002.C25 U3002.B25 195.21,138.77 196.63,138.77 v2(196.71,138.69) ; U35.K68 102.05,118.14 U35.K70 ; U35.AW34 121.78,103.53 v2(122.11,103.86) ; JDIM1.192 132.47,44.18 131.12,45.54 v1(130.79,45.54) ; JDIM2.1 82.72,62 83.15,61.57 v1(83.54,61.57) ; v2(134.95,103.8) 134.75,103.8 134.31,103.36 U35.AW12 ; v1(11.06,119.27) 11.56,119.78 U4509.3 ; U35.AW57 107.8,103.36 107.77,103.39 107.48,103.39 107.44,103.36 U35.AW60 106.57,103.36 106.54,103.39 106.25,103.39 106.22,103.36 U35.AW62 ; U3002.C22 U3002.B22 195.23,136.29 196.45,136.29 196.49,136.25 v2(196.51,136.25) ; v2(190.98,147) 191.09,146.89 191.09,145.45 U3002.G33 U3002.G32 ; U35.AW16 131.25,103.36 131.22,103.39 130.93,103.39 130.9,103.36 U35.AW18 130.38,103.39 129.58,103.39 129.55,103.36 U35.AW21 128.83,103.36 128.8,103.39 128.51,103.39 128.48,103.36 U35.AW23 127.51,103.36 127.47,103.39 127.18,103.39 127.15,103.36 U35.AW26 126.38,103.36 126.35,103.39 125.89,103.39 125.86,103.36 U35.AW28 125.1,103.36 125.07,103.39 124.62,103.39 124.59,103.36 U35.AW30 123.83,103.36 123.79,103.39 123.5,103.39 123.47,103.36 U35.AW32 ; U35.BA66 U35.AY66 103.47,102.91 103.47,103.43 ; U35.AW38 119.09,103.36 v2(118.56,103.9) 118.03,103.37 U35.AW41 117.57,103.36 117.54,103.39 117.24,103.39 117.21,103.36 U35.AW43 116.34,103.36 116.31,103.39 116.02,103.39 115.99,103.36 U35.AW45 115.12,103.36 115.08,103.39 114.79,103.39 114.76,103.36 U35.AW47 113.95,103.36 113.92,103.39 113.63,103.39 113.6,103.36 U35.AW49 112.69,103.36 112.66,103.39 112.37,103.39 112.34,103.36 U35.AW51 111.53,103.36 111.5,103.39 111.2,103.39 111.17,103.36 U35.AW53 110.3,103.36 110.27,103.39 109.98,103.39 109.95,103.36 U35.AW55 ; JDIM1.65 98.72,50.45 98.9,50.27 v1(98.9,50.11) ; 103.47,103.43 U35.AW66 103.18,103.73 102.51,103.73 U35.AV68 ; 103.47,103.43 103.73,103.43 103.76,103.4 104.47,103.4 U35.AW64 ; v1(90.66,50.11) 91.02,50.11 91.22,50.32 JDIM1.35 ; U3002.D33 193.62,145.48 193.62,146.91 v2(193.69,146.98) ; U3002.AN30 169.76,143.27 170.49,143.27 U3002.AL30 ; v2(197.09,120.89) 196.95,121.03 195.29,121.03 U3002.B4 ; v1(220.76,52.5) 220.52,52.73 U19.10 ; U3002.C7 U3002.B7 195.15,123.66 196.76,123.66 v2(196.8,123.7) ; U35.D45 114.98,121.76 114.6,121.76 114.57,121.73 114.28,121.73 114.25,121.76 113.87,121.76 U35.D47 U35.D48 ; U3002.AE32 U3002.AE33 v2(175.98,146.81) ; U35.AW6 137.58,103.41 136.54,103.41 U35.AW8 ; U3002.C10 U3002.B10 196.79,126.19 v1(196.81,126.17) ; v1(188.48,147.01) 188.48,146.73 188.68,146.53 188.68,145.54 U3002.K33 U3002.K32 ; v1(90.63,48.78) 90.63,48.81 90.66,48.83 91.34,48.83 92.22,49.72 JDIM1.39 ; U3002.K30 188.48,142.76 188.49,142.75 188.49,142.04 v1(188.91,141.63) ; v2(173.48,146.85) 173.31,146.68 173.31,145.51 U3002.AH33 U3002.AH32 ; JDIM1.68 v1(99.47,44.5) ; JDIM2.51 95.22,62.39 v1(95.35,62.26) ; U3002.C28 U3002.B28 195.46,141.19 195.48,141.21 196.52,141.21 v2(196.6,141.29) ; v1(116.97,23.49) 116.81,23.33 U1006.3 ; v2(185.98,146.95) 185.99,146.94 185.99,145.71 185.99,145.71 185.99,145.49 186,145.48 186,145.37 U3002.N33 U3002.N32 ; v2(170.98,146.89) U3002.AL33 U3002.AL32
  BOTTOM w0.229: v1(100.26,48.61) 100.18,48.61 99.72,49.07 JDIM1.69 ; JDIM1.73 100.72,49.76 100.44,49.48 100.39,49.48 v1(100.29,49.37) ; v1(106.05,49.38) 106.05,49.41 106.03,49.4 105.75,49.4 105.42,49.72 105.42,50.17 105.72,50.47 JDIM1.93 ; v1(132.29,54) 132.47,54.19 JDIM2.192 ; JDIM2.69 99.72,61.9 100.13,61.49 v1(100.41,61.49) ; JDIM1.103 108.22,50.47 107.57,49.82 107.57,49.37 107.92,49.02 108.08,49.02 108.11,49 v1(108.11,49.02) ; CN5.12 126.43,175.48 127.01,175.48 v1(127.69,176.17) ; JDIM1.188 v1(131.47,41.8) ; v1(106.36,53.18) 107.22,52.31 JDIM1.99 ; v1(136.15,52.75) 135.72,52.33 JDIM1.205 ; v1(132.11,57.35) 131.81,57.35 131.47,57.02 JDIM2.188 ; v1(100.41,64.92) 100.72,64.6 JDIM2.73
  BOTTOM w0.254: v1(132.97,54.01) 133.14,54.01 133.47,54.35 JDIM2.196 ; U35.AW32 123.01,103.34 v1(123.01,102.78) 123.01,102.17 U35.BA32 ; v1(88.5,48) 88.69,48.19 89.63,48.19 90.07,48.64 90.07,50.26 90.22,50.41 JDIM1.31 ; U35.AH63 U35.AH64 ; JDIM1.56 96.47,41.8 v1(96.65,41.62) ; 105.79,102.83 105.78,102.82 U35.BA62 ; 105.79,102.83 105.78,102.84 U35.AW62 ; 105.79,102.83 v2(105.81,102.83) ; v1(169.73,126.61) 169.73,126.59 169.65,126.51 169.65,126.51 U3002.AN10 ; U35.B34 120.67,122.69 v2(120.67,122.22) 120.62,122.17 U35.D34 ; CN5.24 121.09,172.34 121.09,173.02 v1(121.67,173.6) 121.95,173.32 122.22,173.32 CN5.21 ; 131.14,118.68 131.14,118.74 U35.H18 ; 131.14,118.68 131.55,118.68 131.95,118.28 U35.K16 ; 131.14,118.68 U35.K18 130.74,118.15 130.59,118 130.59,117.59 U35.L18 130.74,117.35 v1(131.05,117.04) 131.39,117.37 U35.L17 131.47,117.44 131.52,117.49 131.91,117.49 131.96,117.44 U35.L16 ; v2(125.76,122.24) 125.58,122.05 U35.D26 ; v2(125.76,122.24) 126.23,121.76 U35.D25 ; v2(125.76,122.24) 125.94,122.41 U35.C25 ; v1(141.29,110.26) U35.AF1 U35.AF2 139.53,110.26 v2(139.35,110.08) 139.17,110.26 U35.AF4 ; Q37.1 227.07,111.97 227.77,111.27 v1(227.77,110.89) ; U35.G58 v2(107.52,119.94) U35.G60 ; CN10.33 192.95,184 v1(193.22,184.27) ; U3002.AL2 171.23,119.29 v1(171.23,118.97) ; U7.H1 179.55,161.82 v2(179.57,161.82) ; JDIM1.239 144.22,49.98 143.57,49.32 v1(143.31,49.32) ; v1(136.2,57.51) 136.68,57.51 136.97,57.21 JDIM2.210 ; JDIM1.98 v1(106.97,44.48) ; JDIM2.180 129.47,56.35 129.23,56.58 129.23,57.17 129.62,57.56 v1(129.75,57.56) ; v1(98.77,102.75) 99.53,103.5 U35.AV71 U35.AV70 ; v1(86.21,52.8) 86.22,52.79 JDIM1.15 ; JDIM2.15 86.22,65.05 86.85,65.68 v1(86.98,65.68) ; JDIM2.94 105.97,56.35 v1(106.36,56.73) ; v1(134.58,45.1) 134.55,45.1 134.97,44.68 JDIM1.202 ; 101.16,115.33 100.84,115.01 U35.U70 ; 101.16,115.33 101.49,115.01 U35.U69 ; 101.16,115.33 v1(101.16,115.33) ; JDIM2.31 90.22,61.57 89,60.35 v1(88.7,60.35) ; U35.A67 102.14,124.17 v1(102.14,124.4) ; 105.08,114.32 105.39,114.63 U35.U63 ; 105.08,114.32 v2(105.08,114.37) ; 105.08,114.32 104.74,114.66 U35.U64 ; v1(83.54,45.21) 83.52,45.18 83.42,45.18 82.97,44.74 JDIM1.2 ; v1(104.37,52.78) 104.72,52.42 JDIM1.89 ; v2(116.7,105.18) U35.AT42 ; v2(116.7,105.18) U35.AR43 ; v2(116.7,105.18) U35.AR42 ; CN23.51 162.25,103.43 162.25,102.24 v1(162.16,102.15) 162.03,102.28 160.89,102.28 160.75,102.42 160.75,103.43 CN23.57 ; JDIM1.22 87.97,45.6 v1(87.84,45.74) ; v2(129.77,117) 129.66,117.11 129.66,117.21 U35.L20 ; U35.T2 U35.T4 138.64,115.56 v2(138.4,115.32) ; JDIM2.2 82.97,56.37 v1(82.48,56.87) ; v1(135.9,60.29) 136.72,61.12 JDIM2.209 ; JDIM2.230 141.97,57.62 141.68,57.92 v1(141.37,57.92) 141.28,57.92 140.9,57.54 140.9,56.62 140.97,56.54 JDIM2.226 ; JDIM2.175 128.22,65.17 128.72,65.66 v1(129.72,65.66) 130.78,65.66 131.72,64.72 JDIM2.189 ; CN2021.A1 v1(8.25,117.15) ; U35.AR20 130.26,105.17 v2(130.4,105.17) 130.08,104.85 U35.AT20 129.92,104.73 129.94,104.72 129.94,104.33 129.92,104.32 U35.AU20 ; v1(127.15,58.15) 127.53,58.15 128.47,57.2 JDIM2.176 ; v1(84.64,41.89) 84.97,42.23 JDIM1.10 ; U35.D53 110.71,121.92 v2(110.47,122.16) 110.71,122.4 U35.B53 ; v1(94.85,48.64) 95.22,49.01 JDIM1.51 ; Q56.1 218.1,74.15 218.52,74.57 v1(218.73,74.57) ; v2(113.93,121.25) v1(113.93,119.96) 113.9,119.93 113.71,119.93 U35.G48 ; JDIM2.202 134.97,56.55 v1(134.09,57.43) ; v1(136.96,46.25) 137.47,46.25 137.97,45.74 JDIM1.214 ; CN5.28 120.98,169.62 v1(121.11,169.62) ; v1(83.88,65.58) 84.02,65.58 84.72,64.88 JDIM2.9 ; v1(108.41,103.87) U35.AW57 U35.BA57 ; JDIM2.18 86.97,56.74 v1(86.92,56.79) ; v1(218.42,52.39) 218.42,52.89 219.02,53.49 U19.13 ; JDIM2.48 94.47,56.42 94.55,56.5 94.55,56.99 94.11,57.43 v1(93.97,57.43) ; U3002.AH11 173.43,126.98 v1(173.81,126.61) 174.23,127.03 U3002.AG11 ; U14.3 162.38,86.78 162.49,86.89 162.49,87.23 162.23,87.5 R214.2 ; v1(193.27,174.16) 193.27,174.42 192.69,175 CN10.69 ; JDIM1.61 97.72,50.43 98.02,50.13 98.02,49.6 97.78,49.35 97.45,49.35 v1(97.43,49.33) ; U35.K66 103.54,118.33 103.56,118.33 103.74,118.15 v2(103.74,118.05) U35.K65 U35.K64 ; CN2020.10 211.99,18.15 v1(212.2,18.36) 211.91,18.65 CN2020.9 ; U44.23 167.12,73.88 166.93,73.7 v1(166.93,73.04) ; U3002.AL12 170.92,127.84 170.53,127.45 v1(170.53,127.44) ; JDIM2.205 135.72,64.82 136.21,65.31 v1(136.32,65.31) ; v1(101.22,111.62) 101.25,111.59 101.26,111.59 101.49,111.36 U35.AE69 U35.AE68 102.19,111.22 102.74,111.22 U35.AE67 102.81,111.19 103.41,111.19 U35.AE66 103.46,111.19 104.06,111.19 U35.AE65 104.11,111.19 104.71,111.19 U35.AE64 105.19,111.62 U35.AD62 ; v2(127.6,108.84) 128.06,108.39 U35.AK22 128.27,108.22 U35.AK21 128.79,107.92 v2(128.58,107.72) 128.84,107.45 U35.AM21 ; v1(96.15,47.19) 96.15,45.92 95.47,45.25 JDIM1.52 ; v1(148.64,65.64) 147.98,65.64 147.22,64.88 JDIM2.251 ; v1(94.06,61.68) 93.78,61.68 93.22,62.23 JDIM2.43 ; U35.AW18 U35.BA18 U35.BB18 ; JDIM2.90 104.97,57.72 104.66,58.04 v1(104.37,58.04) ; v1(91.59,58.03) 91.76,58.03 92.47,57.32 JDIM2.40 ; v1(121.93,170.43) 121.9,170.4 121.98,170.33 121.98,170.31 122.13,170.15 122.16,170.15 R447.2 ; U35.AV69 101.94,103.5 v2(101.99,103.54) 102.13,103.69 U35.AV68 ; v1(189.36,179.45) 189.42,179.5 CN10.51 ; U35.E15 132.69,120.99 133.06,120.62 v2(133.1,120.62) 133.3,120.62 U35.F13 ; v1(104.64,100.44) 104.68,100.47 104.68,101.34 U35.BB64 ; JDIM1.26 88.97,44.86 88.97,44.87 88.97,44.89 88.68,45.17 88.66,45.17 v1(88.48,45.35) ; v1(91.47,41.8) 91.47,41.81 JDIM1.36 ; v1(96.8,61.68) 96.99,61.68 97.72,62.42 JDIM2.61 ; JDIM1.1 82.72,52.52 82.97,52.76 v1(83.18,52.76) ; JDIM2.10 84.97,57.22 84.22,57.97 v1(83.95,57.97) ; U5.C1 188.95,156.62 v2(188.55,157.02) ; U35.AL45 116.21,107.47 U35.AM43 ; U35.AU10 135.36,104.2 v2(134.95,103.8) 135.25,103.5 U35.AW10 ; JDIM2.185 130.72,64.63 130.4,64.95 v1(129.72,64.95) ; v1(193.63,180.11) 193.63,180.44 193.07,181 CN10.45 ; v1(109.83,53.38) 109.56,53.38 109.22,53.05 JDIM1.107 ; v1(127.15,50.12) 127.22,50.2 JDIM1.171 ; v1(143.8,45.38) 143.62,45.21 143.6,45.21 143.31,44.92 143.31,44.9 142.97,44.56 JDIM1.234 142.97,42.09 143.14,41.93 143.79,41.93 143.97,42.11 JDIM1.238 ; v1(152.33,67) 152.03,67 150.68,68.35 147.64,68.35 143.65,72.33 135.41,72.33 123.37,84.37 93.94,84.37 90.47,87.84 C357.2 ; JDIM1.23 88.22,52.44 88.47,52.68 v1(88.7,52.68) ; v2(137.47,102.68) 137.47,102.34 U35.BA6 137.67,102.14 137.67,101.42 U35.BB6 ; U3002.AM13 170.13,128.66 v1(170.52,128.27) ; U3002.AM13 170.02,128.8 169.44,128.8 U3002.AN13 ; U3002.AM13 170.93,129.49 U3002.AL14 170.67,129.8 170.67,130.08 U3002.AL15 ; v1(136.32,66.07) 136.12,66.07 134.72,64.67 JDIM2.201 ; v1(179.38,138.58) 179.67,138.29 179.67,138 U3002.Y23 ; v1(99.64,121.49) 99.83,121.3 U35.E71 ; v1(137.89,49.43) 138.07,49.43 138.72,50.09 JDIM1.217 ; v2(103.09,118.05) U35.K67 102.35,118.45 102.15,118.25 U35.K68 ; v1(215.47,57.83) 215.76,57.54 U19.16 ; JDIM2.231 142.22,65.19 141.72,65.69 v1(141.52,65.69) ; v1(139.6,47.14) 139.97,46.77 JDIM1.222 ; JDIM2.77 101.72,61.04 102.42,60.34 v1(102.93,60.34) ; U35.E21 129.44,121.42 v2(129.49,121.42) ; v1(101.74,50.12) 101.72,50.13 JDIM1.77 ; v1(101.12,130.83) 101.12,130.8 101.28,130.65 R558.1 ; v1(101.49,100.31) 101.63,100.45 102.12,100.45 102.6,100.93 U35.BB67 ; v1(141.54,65.03) 141.22,64.71 JDIM2.227 ; JDIM1.176 128.47,44.96 127.43,46 v1(127.15,46) ; U35.AR55 109.92,105.5 v2(110.26,105.16) ; v2(102.46,112.54) U35.AA68 ; JDIM2.181 v1(129.72,62.32) ; JDIM2.27 89.22,62.54 89.3,62.46 89.3,61.95 89,61.65 v1(88.72,61.65) ; v2(103.76,116.23) 103.76,116.33 U35.N65 ; U4001.3 v1(209.4,107.85) ; JDIM1.19 87.22,49.86 86.72,49.36 86.5,49.36 v1(86.47,49.33) ; U35.B44 115.73,122.67 115.73,121.79 U35.D44 116.01,121.38 116.67,121.38 v2(116.73,121.44) ; JDIM2.6 83.97,56.67 v1(83.95,56.7) ; JDIM2.19 87.22,64.67 v1(86.98,64.92) ; U5.H14 199.35,160.61 v2(198.95,160.21) ; JDIM1.181 v1(129.72,50.12) ; v1(99.42,119.34) 99.42,119.72 97.19,121.95 R161.2 ; v1(135.87,119.42) 135.68,119.42 U35.G10 ; U3002.AH13 173.43,128.64 v1(173.81,128.26) ; U35.U10 135.48,114.49 v2(135.78,114.19) 135.78,113.95 U35.W9 ; JDIM2.35 91.22,64.64 91.28,64.7 91.28,65.29 90.88,65.69 v1(90.72,65.69) ; U35.BA41 v2(118.03,102.78) U35.AW41 ; U35.B14 v2(133.01,122.22) U35.D14 ; JDIM1.230 141.97,45.19 v1(143.62,46.83) ; U35.AT2 139.65,105.14 v2(139.35,105.14) 139.12,105.14 138.93,104.96 U35.AT4 138.32,105.5 U35.AR5 ; U35.W6 138.77,112.91 U35.AA4 139.17,112.91 v2(139.35,112.73) 139.53,112.91 U35.AA2 ; JDIM1.60 97.47,44.38 97.14,44.72 97.14,45.33 97.57,45.77 v1(97.64,45.77) ; v1(106.36,58.12) 106.37,58.12 106.97,57.52 JDIM2.98 ; JDIM2.47 94.22,64.84 v1(94.06,65) ; U35.AW49 113.14,102.74 v2(113.26,102.62) 113.26,102.18 U35.BA49 ; U3.C12 208.23,119.6 v2(208.62,119.98) ; U35.AP18 U35.AP20 129.92,106.25 129.94,106.26 129.94,106.65 129.92,106.66 U35.AN20 130.06,106.8 v2(130.43,107.17) ; v1(101.99,141.65) 101.77,141.44 U33.3 ; 174.25,102.1 174.25,103.43 CN23.3 ; 174.25,102.1 174.02,102.33 172.9,102.33 172.75,102.49 172.75,103.43 CN23.9 ; 174.25,102.1 v1(174.3,102.05) 174.75,102.5 174.75,103.43 CN23.1 ; U35.B66 103.1,122.57 v2(103.1,122.24) 103.22,122.12 103.22,121.78 U35.D66 ; JDIM2.184 130.47,54.44 130.91,54 v1(132.29,54) ; v1(133.47,41.8) JDIM1.196 ; U35.B18 130.53,122.24 ; 130.53,122.24 130.57,122.21 130.57,121.76 U35.D18 ; 130.53,122.24 v2(130.53,122.22) ; JDIM2.14 85.97,54.24 v1(86.21,54) ; Q40.1 219.4,69.12 Q56.4 ; v2(176.44,142.54) 176.04,142.94 U3002.AE30 ; v1(123.4,109.21) 123.4,108.86 123.07,108.53 U35.AL32 ; JDIM2.30 89.97,56.73 v1(89.99,56.75) ; v1(125.39,46.75) 125.58,46.75 126.32,46.02 126.32,44.34 126.47,44.18 JDIM1.168 ; JDIM2.44 93.47,54.38 93.75,54.11 v1(93.97,54.11) ; U35.F27 125.2,120.34 v1(124.9,120.03) 124.59,120.34 U35.F28 123.98,119.88 U35.J28 ; CN10.39 189.66,182.5 v1(189.29,182.87) ; U3002.AC22 176.73,136.84 v1(177.18,136.38) ; JDIM1.90 v1(104.97,44.48) ; v1(140.98,44.65) 140.97,44.65 JDIM1.226 ; U4002.3 215.72,107.34 215.64,107.42 v1(215.64,108.1) ; U3002.AH16 v1(173.83,131.59) ; v1(95.46,57.61) 95.68,57.61 96.47,56.82 JDIM2.56 ; U35.B30 v2(123.1,122.22) U35.D30 ; U35.AW14 132.9,103.29 132.9,102.92 v1(132.8,102.81) 132.83,102.78 U35.BA14 ; JDIM2.244 145.47,54.11 v1(145.39,54.03) 145.55,53.87 146.51,53.87 147.22,53.16 JDIM1.251 ; CN10.1 v1(192.53,192) ; v2(127.71,120) 127.37,120.34 U35.F23 ; v2(127.71,120) 128.02,119.69 U35.G22 U35.K22 ; v2(127.71,120) 128.05,120.34 U35.F22 ; v1(104.32,65.59) 104.85,65.59 105.72,64.72 JDIM2.93 ; v1(86.32,125.98) 86.32,126.47 86.08,126.71 85.8,126.71 85.54,126.45 U6.3 ; v1(141.28,53.74) 142.22,52.8 JDIM1.231 ; U35.B71 99.65,123.25 v1(99.47,123.43) ; v1(100.46,56.68) 100.47,56.66 JDIM2.72 ; JDIM1.201 134.72,53.02 135.11,53.41 v1(136.15,53.41) ; JDIM1.72 100.47,44.99 v1(100.64,45.16) ; U35.U67 102.79,114.75 v2(103.11,114.42) 103.44,114.75 U35.U66 ; v1(138.43,53.99) 138.85,53.99 138.97,54.12 JDIM2.218 ; v1(172.27,125.88) 171.96,126.18 171.74,126.18 U3002.AK10 ; U35.AP68 v2(101.86,106.07) U35.AP70 ; v1(173.88,121.55) 173.49,121.94 U3002.AH5 ; v1(82.89,49.42) 82.99,49.42 83.72,50.16 JDIM1.5 ; U35.AM45 115.19,107.45 v2(114.85,107.12) ; v1(188.73,176.98) 189.71,177.96 190.05,177.96 190.09,178 CN10.57 ; v1(93.47,41.77) JDIM1.44 ; JDIM1.85 103.72,49.89 104.13,49.48 104.29,49.48 v1(104.32,49.46) ; U35.L4 139.25,118.21 v2(139.35,118.11) 139.45,118.21 U35.L2 ; CN5.9 127.69,176.34 v1(127.69,176.17) ; JDIM1.210 136.97,44.71 v1(136.96,44.72) ; JDIM1.94 105.97,44.26 v1(106.25,44.53) ; U35.F32 122.15,119.94 ; 122.15,119.94 v2(122.15,119.89) U35.J32 ; 122.15,119.94 U35.F33 ; v1(145.48,57.4) 145.73,57.4 146.47,56.66 JDIM2.248 ; v1(132.77,64.89) 132.77,64.77 132.72,64.73 JDIM2.193 ; U35.AR52 111.85,105.29 112.34,105.29 U35.AR50 ; v1(166.95,70.77) 167.3,70.77 167.62,70.46 U44.32 ; JDIM1.206 v1(135.97,41.78) ; JDIM1.213 137.72,52.52 v1(138.43,53.22) ; JDIM2.89 104.72,64.64 104.44,64.93 v1(104.32,64.93) ; v1(130.61,41.8) 130.47,41.94 JDIM1.184 ; v1(127.15,48.8) 126.78,48.8 126.22,49.36 JDIM1.167 ; JDIM2.81 102.72,64.72 v1(102.93,64.92) ; U35.AM8 135.97,107.8 135.96,107.8 v2(135.82,107.94) ; JDIM1.172 127.47,44.36 v1(127.15,44.68) ; U35.AF10 136.01,109.87 137.45,109.87 137.99,109.33 U35.AH6 ; CN5.3 128.4,179.88 v1(128.38,179.88) ; v1(135.77,49.37) 136.07,49.37 136.72,50.02 JDIM1.209 ; JDIM2.103 108.22,64.75 108,64.98 v1(107.63,64.98) ; U35.AW36 v2(120.51,102.78) U35.BA36 ; v1(129.14,45.51) 128.89,45.26 128.89,44.73 129.47,44.15 JDIM1.180 ; v2(107.55,105.19) 107.64,105.19 U35.AT58 ; JDIM2.172 127.47,56.56 v1(127.15,56.88) ; JDIM2.171 127.22,62.4 v1(127.15,62.32) ; v1(8.29,122.7) 8.24,122.65 CN2021.A12 ; JDIM2.22 87.97,57.14 87.05,58.06 v1(86.92,58.06) ; JDIM1.189 131.72,52.49 132.04,52.8 132.82,52.8 v1(132.92,52.7) 132.72,52.5 JDIM1.193 ; v1(143.19,61.6) 143.55,61.6 144.22,62.27 JDIM2.239 ; JDIM1.252 147.47,44.19 148.64,45.36 v1(148.64,45.51) ; U35.AL48 v2(113.92,107.13) ; JDIM1.64 98.47,44.95 v1(99.45,45.92) ; v1(103,54.11) 102.19,54.11 101.97,54.32 JDIM2.78 ; CN23.27 168.25,103.43 168.25,102.31 168.79,101.77 v1(169.75,101.77) ; Q37.4 224.51,110.67 224.52,110.66 v1(224.52,109.82) ; U35.AM27 125.22,107.45 v2(124.91,107.14) ; U19.15 v1(215.47,57.04) ; U35.C1 141.63,123.57 v1(141.66,123.57) ; U48.3 173.85,51.24 173.72,51.1 173.36,51.1 v1(173.28,51.18) ; U35.K63 105.38,118.47 105.38,118.62 v2(105.66,118.9) 105.8,118.76 U35.K61 ; R534.1 105.34,131.24 v1(105.16,131.41) ; JDIM2.223 140.22,62.19 140.87,61.55 v1(141.37,61.55) ; JDIM1.14 85.97,44.56 v1(85.88,44.65) ; v1(212.2,20.19) 212.08,20.15 CN2020.6 ; U35.AW23 v2(127.97,102.78) U35.BA23 ; v1(96.81,65.05) 96.72,64.97 JDIM2.57 ; v1(129.98,52.75) 130.4,52.75 130.72,52.43 JDIM1.185 ; JDIM1.106 v1(108.97,44.48) ; U35.AW10 135.6,103.36 135.75,103.51 136.34,103.51 U35.AW8 ; U35.AW10 U35.BA10 ; v1(98.99,118.02) 99.11,118.14 U35.K71 ; U35.B58 U35.D58 108.1,121.72 107.63,121.25 v2(107.52,121.25) ; v1(189.67,173.63) 189.8,173.5 CN10.75 ; v1(103.1,49.25) 103.07,49.28 102.76,49.28 102.59,49.44 102.59,50.26 102.72,50.39 JDIM1.81 ; 124.95,174.84 124.95,174.85 v1(124.24,175.56) 123.55,175.56 123.04,175.05 123.04,174.62 123.89,173.78 CN5.18 ; U44.16 164.12,73.96 164.57,73.5 164.57,71.83 v1(164.75,71.65) ; JDIM2.85 103.72,62.09 104.2,61.61 v1(104.32,61.61) ; U44.9 164.27,70.46 v1(164.75,70.94) ; v1(165.21,104.74) 165.25,104.7 CN23.39 ; JDIM1.175 128.22,53.23 128.43,53.44 v1(129.98,53.44) ; v1(138.41,64.94) 138.72,64.62 JDIM2.217 ; JDIM2.167 126.22,61.71 126.89,61.05 v1(127.15,61.05) ; v2(114.84,119.94) U35.G45 ; CN2020.13 v1(212.24,16.65) ; JDIM2.247 146.22,64.68 145.86,65.04 v1(145.34,65.04) ; JDIM1.197 133.72,49.69 133.43,49.4 v1(132.91,49.4) ; JDIM1.218 138.97,44.3 139.27,44.6 v1(139.38,44.6) ; v2(121.25,106.46) 121.36,106.46 U35.AN33 ; U35.AG20 129.44,109.83 v2(129.76,109.5) 129.76,109.38 U35.AJ20 ; v1(139.83,57.61) 140.03,57.61 140.24,57.4 140.24,56.65 139.97,56.38 JDIM2.222 ; JDIM2.102 107.97,56.36 108.16,56.54 108.16,57.05 107.77,57.43 107.65,57.43 v1(107.65,57.43) ; v1(88.51,49.43) 88.53,49.46 88.61,49.46 89.22,50.07 JDIM1.27 ; v1(173.82,125.79) 173.82,125.81 173.44,126.19 U3002.AH10 ; v1(163.75,104.79) CN23.45 ; v1(221.29,61.49) 221.02,61.22 U19.5 ; U35.BA1 141.12,101.24 v1(141.51,101.24) ; JDIM2.64 98.47,56.41 98.28,56.61 98.28,57.22 98.57,57.51 v1(98.8,57.51) ; JDIM2.106 108.97,56.4 v1(109.38,56.8) ; JDIM2.243 145.22,61.13 v1(145.51,60.84) ; v1(133.29,61.62) 133.48,61.62 133.91,62.05 133.91,62.44 133.72,62.63 JDIM2.197 ; v1(125.39,58.8) 125.73,58.8 126.32,58.22 126.32,56.54 126.47,56.38 JDIM2.168 ; JDIM2.68 99.47,54.34 99.21,54.08 v1(98.81,54.08) ; v1(125.61,108.85) U35.AK27 124.89,107.93 U35.AL28 ; JDIM1.9 84.72,49.45 84.64,49.36 84.64,49.35 84.26,48.98 v1(84.26,49) ; U35.BA53 v2(110.74,102.83) U35.AW53 ; JDIM2.206 135.97,54.25 v1(136.15,54.07) ; v1(92.49,41.7) 92.47,41.71 JDIM1.40 92.47,44.97 92.03,45.41 v1(91.85,45.41) ; v1(83.88,64.92) 83.72,64.76 JDIM2.5 ; v1(91.57,61.61) 91.85,61.61 92.22,61.99 JDIM2.39 ; v2(217.4,146.65) 217.8,147.05 U4.C12 ; JDIM2.107 109.22,64.75 v1(109.38,64.9) ; U35.D39 118.33,121.91 v2(118.33,122.2) 118.14,122.39 U35.B39 ; U35.AP23 127.1,106.15 v2(126.72,106.53) 126.91,106.53 U35.AN23 ; JDIM1.78 v1(101.97,44.5) ; JDIM2.234 142.97,54.21 v1(143.44,53.74) ; v2(116.67,119.94) 117.06,120.34 U35.F42 ; v1(166.75,104.64) CN23.33 ; U35.C5 138.55,122.33 U35.D6 137.94,121.52 v2(137.69,121.26) 137.58,121.26 137.31,120.99 U35.E6 ; U35.AP10 135.71,105.86 v2(135.83,105.86) 136.18,105.5 U35.AR8 ; U19.12 219.52,53.24 219.08,52.8 v1(219.08,52.39) ; v1(149.49,57.79) 148.03,57.79 147.47,57.23 JDIM2.252 ; v1(93.22,48.79) 93.22,48.82 93.25,48.84 93.48,48.84 94.22,49.59 JDIM1.47 ; D3.2 v1(87.56,85.28) C374.2 90.64,85.28 93.38,82.54 122.59,82.54 134.78,70.35 143.47,70.35 146.97,66.85 149.61,66.85 151.54,64.92 v1(152.3,64.92) ; JDIM1.30 89.97,44.52 v1(90.1,44.65) ; U35.AR16 131.75,105.57 131.98,105.8 v2(132.21,105.8) 132.4,105.8 132.67,105.53 U35.AR15 ; JDIM1.235 143.22,52.71 v1(143.44,52.93) ; v1(167.34,139.03) 167.52,139.03 167.86,138.69 U3002.AN25 U3002.AM25 ; v1(88.32,126.64) 88.21,126.53 U47.3 ; v2(110.26,119.94) U35.G55 ; v1(97.43,48.01) 97.42,48 97.26,48 96.72,48.54 JDIM1.57 ; JDIM2.238 143.97,57.15 143.59,57.53 143.17,57.53 v1(143.17,57.54) ; JDIM2.26 88.97,56.34 89.13,56.49 89.13,57.12 88.85,57.41 v1(88.6,57.41) ; CN23.21 169.75,103.43 v1(169.75,101.77) ; JDIM1.82 v1(102.97,44.88) ; v1(169.75,101.77) 170.52,101.77 171.25,102.51 171.25,103.43 CN23.15 ; JDIM2.86 103.97,56.36 103.81,56.52 103.81,57.05 104.14,57.38 v1(104.37,57.38) ; v1(67.99,76.4) 67.45,75.86 PU15.19 ; U35.D22 128.05,121.69 v1(127.69,121.33) ; U35.AT63 104.9,105.19 104.79,105.19 v2(104.77,105.21) ; v1(140.14,49.68) 140.22,49.76 JDIM1.223 ; PU22.19 217.54,173.29 217.53,173.28 217.49,173.28 v1(217.13,172.92) ; JDIM1.86 v1(103.97,44.48) ; JDIM2.23 88.22,62.51 88.07,62.35 88.07,61.17 87.21,60.3 v1(86.92,60.3) ; JDIM1.244 145.47,42.03 145.65,41.85 146.31,41.85 146.47,42.02 JDIM1.248 146.47,44.56 145.83,45.21 v1(145.65,45.21) ; U35.AW45 U35.BA45 ; JDIM2.36 91.47,56.67 v1(91.57,56.76) ; v2(118.56,103.9) U35.AU38 ; JDIM2.99 107.22,64.54 107.11,64.65 107.11,65.2 v1(107.63,65.71) ; v1(190.64,134.08) 190.64,134.08 U3002.G19 ; JDIM2.235 143.22,65.03 141.78,66.48 v1(141.54,66.48) ; v1(97.47,56.7) JDIM2.60 ; U3002.G7 v1(190.63,124.03) ; U35.BA28 v2(125.49,102.78) U35.AW28 ; U35.AK18 130.74,108.33 v2(130.43,108.63) 130.43,108.81 130.68,109.06 U35.AJ18 130.41,109.38 130.41,109.57 U35.AG18 ; JDIM1.48 94.47,45 v1(93.88,45.59) ; U35.AT56 v1(108.41,104.53) ; v1(138.53,61.66) 138.09,61.66 137.72,62.03 JDIM2.213 ; U3002.N2 185.86,119.42 185.86,118.28 v1(185.63,118.05) ; JDIM1.243 145.22,49.8 145.9,49.12 147.02,49.12 v1(147.02,49.12) ; v1(128.26,110.27) 128.41,110.27 U35.AG21 ; JDIM1.43 v1(93.22,50.11) ; v2(112.02,120.02) 111.69,119.69 U35.G52 ; U35.A5 138.61,123.71 139.02,124.12 140.34,124.12 v1(140.9,123.57) ; v1(98.33,65.07) 98.72,64.68 JDIM2.65 ; v2(108.45,107.12) 108.44,107.14 U35.AL58 ; JDIM1.18 v1(86.97,44.62) ; v1(188.02,176.98) 188.02,176.83 188.55,176.3 189.52,176.3 189.72,176.5 CN10.63 ; v1(190.66,126.61) 191.03,126.24 U3002.G10 ; v2(139.34,107.8) 138.87,108.27 U35.AJ4 ; JDIM1.102 107.97,45.14 107.31,45.8 v1(106.97,45.8) ; U35.E65 104.74,120.48 104.74,120.2 U35.G63 ; v1(138.56,57.33) 138.23,57.33 137.97,57.07 JDIM2.214 ; JDIM1.6 v1(83.97,41.89) ; U3002.AM16 170.05,131.27 169.41,131.27 U3002.AN16 ; JDIM1.227 v1(141.22,53.03) ; JDIM1.247 146.22,52.48 146.01,52.69 v1(145.4,52.69) ; v1(95.47,56.92) JDIM2.52 ; v1(157.69,30.5) 157.69,30.85 156.96,31.58 U50.3 ; U35.B48 U35.D48 ; U35.AN38 U35.AP38 ; CN10.7 v1(192.53,190.5) ; v1(102.97,56.7) JDIM2.82 ; v2(114.85,105.18) U35.AR45 ; U35.N68 v1(102.46,116.2) ; 101.99,120.72 U35.F68 101.93,120.72 v2(101.45,121.19) 101.63,121.37 U35.D69 101.99,121.37 v2(102.32,121.05) 101.99,120.72
  BOTTOM w0.305: U3002.F7 191.94,123.69 v2(192.34,123.29) 192.73,123.68 U3002.E7 ; U4.T5 207.4,141.45 v2(207,141.05) ; v2(209.4,149.05) U4.N14 ; v2(170.02,160.19) 169.98,160.19 U7.K13 ; v2(171.58,156.19) 171.18,156.59 U7.R11 ; v2(190.15,158.61) 190.55,158.22 U5.E3 v2(190.95,158.61) ; U3.J1 212.98,128.4 v2(212.58,128.8) ; U5.C3 190.55,156.61 v2(190.95,156.21) U5.C4 v1(190.96,157.01) ; U5.M10 196.15,163.77 v2(195.79,163.41) ; U3002.AM16 170.93,131.99 U3002.AL17 170.77,132.2 170.77,132.68 U3002.AL18 170.93,132.89 170.9,132.89 v1(170.53,133.26) 170.51,133.26 170.53,133.28 U3002.AM19 ; U3002.AN30 v1(168.82,143.35) ; v1(191.45,141.62) 191.06,141.24 U3002.G28 ; U35.B62 v2(105.75,122.23) U35.D62 ; v2(218.18,118.4) 217.79,118 U3.R14 ; v1(193.12,139.11) 193.12,139.08 U3002.E25 ; U35.AR23 v2(126.72,105.18) U35.AT23 ; U35.R13 133.25,116.02 133.25,116.3 v2(133.22,116.33) 133.25,116.36 133.25,116.52 U35.N13 ; U35.AD8 136.9,111.59 v2(136.9,111.99) ; U7.N12 170.38,158.19 v2(170.78,157.79) ; U4.M5 210.6,141.45 v2(211,141.05) 211.4,141.45 U4.L5 ; v2(210.2,145.85) U4.M10 ; U35.F38 118.56,119.94 118.49,119.94 ; U35.F38 118.96,120.34 v2(119.41,119.89) 119.86,120.34 U35.F37 ; U35.F38 119.14,120.53 119.68,120.53 U35.F37 ; v2(195.77,167.41) 196.15,167.03 U5.T10 ; R4337.2 v1(184.46,113.18) ; v2(168.39,156.17) 168.39,156.2 168.78,156.59 U7.R14 ; v2(196.55,166.62) U5.R11 ; v2(207.8,149.05) U4.R14 ; U35.T21 U35.P21 128.79,115.88 v2(129.1,116.2) ; U5.K1 188.92,162.22 188.58,161.87 v2(188.53,161.87) ; v2(134.04,106.47) 134.04,106.99 U35.AM13 ; v2(211.78,128) 212.18,127.6 U3.H2 ; U35.B10 U35.D10 135.4,121.81 134.86,121.81 U35.D11 134.51,121.76 v2(134.12,121.37) 134.5,121 U35.E11 ; U7.R12 170.38,156.59 v2(170.78,156.19) ; U7.A1 179.36,167.97 v2(179.74,167.97) ; U3002.AH29 173.86,141.71 v1(173.86,141.67) 173.85,141.66 U3002.AH28 ; v2(206.98,125.6) U3.B5 ; U35.AL45 115.75,108.94 v1(115.45,109.24) ; v2(219.79,128.8) U3.U1 ; v2(134.96,118.81) 134.54,118.39 U35.J11 U35.L11 134.83,117.63 135.41,116.8 U35.N10 ; Q30.1 194.04,33.47 C812.1 194.41,33.96 194.41,35.81 194.11,36.1 U49.3 193.59,36.86 194.11,37.38 v1(195.66,37.38) 196.8,37.38 v1(197.15,37.03) ; U3002.B34 195.14,146.14 v1(195.54,145.74) 195.93,145.35 U3002.A33 ; U4.G5 214.6,141.45 v2(214.2,141.05) ; v2(218.18,120.8) 218.58,121.2 U3.T10 ; v2(188.4,167.94) 188.8,167.94 188.92,167.82 U5.U1 ; v2(192.06,126.08) 192.64,126.08 192.73,126.17 U3002.E10 ; v2(218.6,142.11) 218.6,142.1 U4.B5 ; U3.N1 216.18,128.4 v2(216.58,128) ; U3002.C19 194.33,133.69 v2(193.91,134.11) ; v2(198.95,160.21) 198.55,160.61 U5.H13 ; v2(111.12,105.18) U35.AR52 ; v2(132.26,107.77) 132.26,108.02 132.06,108.22 U35.AK16 ; v2(176.38,166.59) U7.C4 ; U7.E14 167.94,164.59 v2(167.76,164.41) ; v2(168.39,160.17) 168.39,160.2 U7.K14 ; v2(190.51,168.4) 190.55,168.35 190.55,167.81 U5.U3 ; U35.AB8 136.78,112.62 136.49,112.91 v2(136.49,113.15) ; v1(168.5,145.94) 168.53,145.92 U3002.AP33 ; v2(175.57,167.38) 175.97,166.99 U7.B5 ; U3002.P20 185.21,135.46 v1(185.21,135.47) 185.2,135.47 U3002.R21 184.71,135.94 183.73,136.93 U3002.T22 ; v2(219.79,118.4) 219.39,118 U3.U14 ; v2(191.75,155.41) U5.B5 ; U35.J13 133.32,118.39 U35.H15 132.67,118.91 U35.K16 ; U35.AT28 v2(123.98,105.18) ; U4.R1 208.19,138.25 v2(207.8,138.65) ; 177.58,156.59 U7.R3 ; 177.58,156.59 v2(177.98,156.99) ; 177.58,156.59 177.62,156.59 v2(178.01,156.2) ; U35.AR35 120.4,105.18 v2(120.39,105.18) ; U35.AP32 v1(122.11,105.81) ; v1(171.53,22.02) 172.22,22.02 172.96,21.28 CN2019.28 ; U5.K13 198.55,162.24 v2(198.92,162.61) ; U3002.AL21 U3002.AL20 170.5,134.12 ; v1(173.56,118.96) 173.48,119.05 U3002.AH2 ; U3.N12 216.19,119.6 v2(216.58,120) ; v2(215.8,140.25) U4.E3 ; v2(205.75,147.16) 205.85,147.26 206.38,147.26 U4.U12 ; U35.AK68 102.03,108.46 101.65,108.46 v2(101.65,108.47) 101.26,108.47 U35.AK69 ; v2(169.17,162.64) 169.58,162.23 U7.H13 ; 170.5,134.12 v1(170.53,134.12) ; 170.5,134.12 170.13,133.74 U3002.AM19 ; U35.AD19 v2(129.76,111.15) U35.AD20 ; v2(104.77,105.21) 104.77,105.19 U35.AR63 ; v2(214.18,121.56) 214.54,121.2 U3.L10 ; U3.K1 213.78,128.4 v2(213.38,128.8) ; v2(216.58,126.4) U3.N3 ; U35.F37 120.32,119.88 U35.J35 ; U35.F37 120.21,120.68 v2(120.3,120.68) 120.64,120.34 U35.F35 ; U35.AF15 133.03,111.07 133.03,111.17 v2(133.05,111.2) ; v2(198.14,164.99) 198.13,164.99 U5.N12 ; v2(196.55,157.81) 196.15,157.42 U5.D10 ; U35.J25 v2(125.81,118.54) ; v2(178.78,161.79) U7.H2 ; v2(129.1,116.2) 129.1,116.31 128.81,116.6 U35.N21 ; v2(129.1,116.2) 129.11,116.18 U35.P20 ; U35.AG19 130.09,109.83 v2(129.76,109.5) ; PC206.1 201.22,55.59 201.56,55.93 v1(201.56,55.98) ; U3002.C13 194.33,128.66 v2(194.72,128.27) ; v2(172.37,167.38) 171.98,166.99 U7.B10 ; v1(111.69,17.67) 111.33,17.67 110.75,17.09 CN95.4 ; v2(190.65,128.27) 191.03,128.65 U3002.G13 ; U3.R4 217.79,126 v2(218.18,126.4) ; v1(193.07,119.16) 193.09,119.18 193.12,119.18 U3002.D2 ; U35.AL35 121.21,107.95 v1(121.21,108.66) ; U35.AP58 v2(107.55,105.84) ; U35.Y19 v2(129.76,112.83) U35.Y20 ; U35.D53 110.88,121.56 110.88,121.15 U35.E53 ; v2(199.73,158.62) 199.35,158.24 U5.E14 ; U7.M5 175.98,158.99 v2(176.38,158.59) ; U7.N1 179.55,158.56 v2(179.55,158.59) ; U4.C4 217.8,140.64 v2(217.4,140.25) U4.C3 ; v2(178.78,160.19) U7.K2 ; v1(169.09,146.83) 169.33,146.6 U3002.AN34 ; U35.V16 131.76,114.5 ; 131.76,114.5 U35.V17 ; 131.76,114.5 v2(131.74,114.5) ; U3002.K7 188.49,123.64 188.91,123.22 v1(188.91,123.22) ; U4.U1 206.59,138.25 v2(206.2,138.65) ; U35.AL55 v2(110.26,107.11) ; v2(112.09,107.1) U35.AL52 ; U3002.N7 185.98,123.64 v1(185.58,124.04) ; U35.AR46 v2(114.85,105.18) ; v2(207.78,118.4) 208.18,118 U3.C14 ; U7.C11 171.18,166.19 v2(171.58,166.59) ; v2(191.75,166.62) U5.R4 ; v1(188.74,118) 188.6,118.14 188.6,119.42 U3002.K2 ; U3.B10 v2(207.78,120.8) U3.C11 ; v2(190.62,138.29) 190.62,138.29 191.02,138.69 U3002.G25 ; v2(183.99,141.67) 183.91,141.67 U3002.T28 ; U3002.T17 183.72,131.94 183.19,131.41 v1(183.19,131.39) ; v2(190.95,166.62) U5.R3 ; U3.E3 209.78,126.8 v2(209.38,127.2) ; v1(181.39,144.93) 181.39,144.93 181.39,144.92 181,144.54 U3002.W32 ; U35.AF17 v2(131.71,111.15) U35.AD16 132.04,111.66 v2(131.71,111.99) U35.AB16 132.3,112.15 132.42,112.15 U35.AB15 133.09,112.01 133.09,111.91 U35.AD13 133.79,111.21 v2(133.79,111.02) ; v2(218.2,137.85) U4.C1 ; U3002.T13 183.88,127.94 v1(184.3,128.36) 184.3,128.51 U3002.R14 U3002.P15 ; U4.R4 v2(208.6,140.25) U4.R3 ; U35.AM25 v2(125.84,107.15) ; v1(192.23,141.62) 192.21,141.6 192.21,141.52 U3002.F28 ; v2(210.18,117.6) U3.E14 ; U7.G10 172.2,163.21 v2(172.52,163.21) ; U3002.AN19 U3002.AM19 ; U3002.T22 183.58,136.94 v1(183.22,137.31) ; U3002.T22 U3002.R23 ; v1(119.41,108.67) 119.41,107.93 U35.AL38 ; v2(194.72,130.81) 194.34,131.19 U3002.C16 ; U7.E3 177.58,164.57 177.97,164.18 v2(177.97,164.16) ; v1(179.15,136.49) 178.73,136.91 U3002.AA22 ; U3002.N30 186.03,142.94 v1(186.41,142.56) ; v2(198.13,155.39) 197.75,155.02 U5.A12 197.75,155.01 v2(198.15,154.61) ; v2(193.1,122.42) 193.1,122.31 U3002.E5 ; v2(199.78,157.02) 199.73,156.97 199.68,156.97 199.35,156.64 U5.C14 ; v2(208.6,145.85) U4.P10 ; U4.A14 219.4,148.65 v2(219,148.25) ; U4.D10 217.04,145.45 v2(217.56,144.93) ; U35.AL66 103.44,107.5 v2(103.84,107.1) 104.09,107.34 U35.AL65 U35.AL64 ; U3.R12 217.78,119.6 v2(217.38,119.2) ; v2(188.53,161.01) 188.92,160.62 U5.H1 ; v1(175.59,140.84) 175.59,140.87 175.96,141.24 U3002.AE28 ; U3002.Y19 U3002.AA20 ; U7.E1 v2(179.79,164.59) ; U35.AK63 104.74,109.07 U35.AH64 v2(104.41,109.8) ; U3002.N21 186.73,136.09 185.87,136.94 U3002.P22 U3002.N23 v1(187.16,137.51) U3002.M22 ; v2(213.38,119.2) U3.K13 v2(214.18,118.4) ; 118.49,119.94 U35.J38 ; 118.49,119.94 U35.F40 ; v2(133.86,108.79) 133.86,109.01 U35.AH13 132.96,109.33 U35.AJ15 ; v1(168.87,120.82) 168.96,120.82 U3002.AN4 ; U35.AU15 132.99,104.53 v2(133.09,104.53) ; U3002.U19 v1(183.17,133.49) U3002.T18 ; U5.L10 v2(196.55,163.41) ; U35.G66 103.72,120.32 v2(103.72,120.81) 103.96,121.05 U35.E65 ; U4.E1 216.2,137.16 v2(216.03,137) ; U7.C3 177.24,166.53 177.24,166.54 v2(177.18,166.59) ; U35.E56 109.06,121.16 109.06,121.21 v2(109.28,121.42) ; U3.H1 212.18,128.4 v2(211.78,128.8) ; U5.N1 188.87,164.54 v2(188.37,164.54) ; U35.N6 138.4,116.49 138.4,116.05 U35.R6 138.4,115.42 v2(138.4,115.32) ; U3002.N5 185.93,121.94 v1(185.53,121.54) ; U35.AN32 v2(122.11,106.46) ; v2(134.96,105.23) 134.77,105.23 U35.AR11 ; U35.D47 113.86,121.31 v2(113.93,121.25) 114.12,121.25 U35.E46 ; U35.AN28 v2(123.98,106.48) ; U3.A1 v2(206.18,128) ; U35.F8 136.66,120.01 v2(136.73,120.01) 136.92,120.01 U35.G6 137.44,119.89 137.95,119.89 U35.G5 138.28,119.56 v2(138.66,119.56) ; U35.AN30 v2(123.05,106.48) ; v2(172.37,157.78) U7.P10 ; v2(210.18,128.8) U3.E1 ; U4.T10 v2(207,145.85) ; v2(217.38,120) 217.78,120.4 U3.R11 ; U35.T17 131.69,115.23 v2(131.69,115.35) 131.69,115.46 U35.P17 ; v2(188.4,166.24) 188.92,166.24 U5.R1 ; U3.L5 214.58,125.2 v2(214.18,125.6) ; U3.C3 v2(208.58,126.4) U3.C4 ; v2(217.33,121.69) 217.33,121.54 U3.P10 ; U35.Y21 v2(128.46,112.83) ; U35.AR53 v2(110.26,105.16) ; U3002.AJ7 U3002.AK7 171.73,123.66 v1(171.33,123.26) ; U3002.T2 183.22,119.28 183.22,118.34 v1(183.09,118.21) ; U4.E14 216.2,148.65 v2(216.6,148.25) ; v2(120.37,106.46) 120.77,106.8 U35.AN35 ; v2(137.14,117.27) 137.14,117.39 U35.L8 136.78,117.88 136.45,118.21 136.45,118.26 U35.J8 ; U5.B10 196.15,155.82 v2(196.55,156.21) 196.95,156.61 U5.C11 ; v2(190.15,154.61) U5.A3 ; C677.1 133.54,128.82 132.76,128.04 C172.1 ; v1(171.33,122.42) 170.95,122.04 U3002.AL5 ; U4.N3 209.8,139.85 v2(209.4,139.45) ; v2(218.95,124.78) 218.95,124.83 U3.T5 ; v2(197.35,156.21) 197.75,156.61 U5.C12 ; v2(206.18,126.4) U3.A3 ; U35.AB18 v2(131.06,112.83) U35.Y17 ; v2(112.08,120.76) 112.32,120.76 U35.E50 ; U3002.AB21 177.63,135.94 v1(177.18,136.38) ; U35.J42 v2(116.67,119.94) U35.G43 ; v2(120.39,104.53) 120.77,104.85 U35.AT35 ; v2(168.38,157.79) U7.N14 ; U7.A12 170.38,167.79 v2(169.98,167.39) ; U4.A12 219.4,147.05 v2(219,146.65) ; U35.AR48 v2(112.99,105.18) ; U7.T5 175.98,155.79 v2(176.38,155.39) ; v2(189.35,160.21) U5.H2 ; v2(170.79,154.58) U7.U12 ; v2(214.2,149.05) U4.H14 ; U4.F5 215.4,141.86 v2(215.27,141.98) ; v2(168.23,167.87) 168.7,167.87 U7.A14 ; v2(213.4,147.45) 213.8,147.85 U4.H13 ; U35.T18 131.05,114.62 v2(131.05,114.5) 131.05,114.39 U35.V18 ; v2(206.18,118.4) 206.58,118 U3.A14 ; U3.U3 219.39,126.8 v2(219.79,126.4) ; U5.T5 v2(192.78,167.02) ; v1(191.47,122.39) 191.45,122.39 190.99,121.94 U3002.G5 ; U7.F5 v2(175.59,164.18) ; U35.A70 100.52,123.84 v1(100.01,123.84) ; v2(206.18,120) 206.58,119.6 U3.A12 ; v2(177.74,168.4) 177.58,168.24 U7.A3 ; U3.M5 215.39,125.2 v2(215.78,124.81) ; v2(209.63,137.64) 209.8,137.8 U4.N1 ; U4.C11 v2(218.2,145.85) U4.B10 ; U3.G5 211.38,125.2 v2(210.98,125.6) U3.F5 ; v2(216.24,117.09) 216.18,117.14 U3.N14 ; v2(190.61,130.76) 191.03,131.17 U3002.G16 ; v2(216.6,146.65) U4.E12 ; v2(214.18,117.6) U3.K14 ; U35.T15 133.2,114.41 v2(133.2,114.21) 133.2,114.18 133.53,113.85 U35.W13 ; v2(211.8,149.05) U4.K14 ; U3002.R12 185.11,126.56 v1(185.24,126.56) ; v2(191.75,164.22) U5.M5 ; U35.AG16 131.71,110.23 v2(131.71,110.3) 131.39,109.99 U35.AG17 ; U35.AR58 v2(107.55,105.19) ; U35.AL4 139.14,107.61 v2(139.34,107.8) 139.53,107.61 U35.AL2 ; U5.L5 192.16,163.02 v2(192.57,163.42) ; U35.AP35 v2(120.4,105.83) ; U7.C1 179.26,166.27 v2(179.76,166.27) ; U35.AM61 v2(106.62,107.13) 106.95,107.45 U35.AM60 ; U7.U14 168.78,154.99 168.39,154.6 v2(168.4,154.58) ; v2(207.8,146.65) U4.R11 ; U35.AF63 105.35,110.25 v2(105.06,109.85) 105.39,109.39 U35.AH63 ; v2(175.37,159.28) 175.39,159.28 175.91,159.79 U7.L5 ; v2(177.18,154.59) 177.58,154.99 U7.U3 ; v2(219.79,120) 219.39,119.6 U3.U12 ; v2(211.8,148.25) U4.K13 ; U3002.T5 183.31,122.11 183.31,122.99 v1(183.19,123.1) 183.19,123.35 U3002.T7 ; U3.H14 212.19,118 v2(212.58,118.4) U3.H13 212.18,118.83 v2(212.58,119.22) ; U3002.T32 183.51,144.54 v1(183.9,144.93) ; v2(209.38,119.2) U3.E12 ; v2(215.38,121.83) U3.M10 ; U5.G10 196.15,159.81 v2(196.55,159.41) 196.15,159.02 U5.F10 ; U4.F10 215.19,145.25 215.19,145.18 v2(215.03,145.01) U4.G10 ; U5.E12 197.75,158.21 v2(198.15,157.81) ; v1(198.33,48.31) 198.33,47.92 198.3,47.89 C541.1 ; v2(211,145.85) 211.4,145.45 U4.L10 ; v1(188.91,141.63) 188.91,141.65 188.5,141.24 U3002.K28 ; U35.AP38 v2(119.48,106.48) U35.AN37 ; U35.AU32 v2(122.11,103.86) ; U4.K2 v2(211.8,139.45) ; U35.AP63 105.24,106.15 v2(104.77,105.84) ; U35.AB21 128.4,112.02 v2(128.37,112.15) 128.24,111.8 128.47,111.57 U35.AD21 ; U35.P19 v2(129.76,116.18) U35.N19 ; U7.U1 v2(178.8,155.37) ; v2(197.35,167.42) U5.U12 ; U3.R3 217.78,126.8 v2(217.38,126.4) ; v1(186.99,112.85) R4325.2 ; v1(170.53,139.94) 170.53,139.94 170.93,139.54 U3002.AL26 ; U3.K2 213.78,127.6 v2(213.38,128) ; U7.G5 175.98,163.01 v2(175.6,163.4) ; v2(199.74,162.6) U5.K14 ; U35.AH67 v2(102.46,109.8) ; U35.AN58 v2(107.55,106.49) ; U35.AP28 v2(123.98,105.83) U35.AR28 ; U5.A1 188.93,155.02 v2(188.55,155.39) ; v2(219,140.25) U4.A3 ; v2(168.19,161.79) 168.38,161.79 U7.H14 ; v2(199.93,168.01) 199.54,168.01 U5.U14 ; U5.P10 196.15,165.43 v2(195.77,165.81) ; U3002.G22 191.03,136.16 v1(190.63,135.77) ; U7.C14 168.75,166.16 v2(168.23,166.16) ; v2(207.78,128) U3.C1 ; U7.N3 177.58,158.19 v2(177.18,158.59) ; v2(189.35,161.81) U5.K2 ; v2(209.38,120.8) U3.D10 ; v1(173.07,142.49) 173.43,142.85 173.43,142.9 U3002.AH30 ; v2(172.56,163.85) 172.5,163.79 U7.F10 ; U3002.AL28 v1(170.52,141.6) ; U4.U3 206.59,139.85 v2(206.2,140.25) ; U5.N3 190.55,164.61 v2(190.95,164.22) ; v2(104.77,106.49) U35.AN63 ; v2(217.78,129) 217.78,129 U3.R1 ; v1(191.42,143.35) 191.41,143.35 191,142.94 U3002.G30 ; U7.C12 170.38,166.19 170.41,166.22 v2(170.78,166.59) ; U7.K1 179.55,160.96 v2(179.55,160.99) ; v2(172.37,165.76) 172,165.39 U7.D10 ; U5.R14 199.81,166.22 v2(199.91,166.32) ; U5.N14 v2(199.96,164.62) ; v2(206.2,149.05) U4.U14 ; v2(219,138.65) U4.A1 ; v2(212.6,137.85) U4.K1 ; U7.R4 176.78,156.59 v2(177.18,156.99) ; U4.C14 217.8,149.41 v2(217.58,149.63) ; U4.H1 213.79,138.25 v2(213.4,138.65) 213.8,139.05 U4.H2 ; v2(207.8,147.45) U4.R12 ; v2(171.56,158.57) U7.M10 171.98,159.02 v2(172.37,159.41) 171.99,159.79 U7.L10 ; v2(178.87,144.16) 178.5,144.54 U3002.AB32 ; U35.AF10 135.22,110.66 v2(135.22,110.88) ; v2(113.92,107.13) U35.AM46 ; U3.F10 v2(210.98,120.8) U3.G10 ; v2(188.58,158.61) 188.95,158.24 U5.E1 ; v2(170.02,164.99) 170.38,164.64 U7.E12 ; U35.AM55 v2(109.35,107.13) ; v2(207.78,120) U3.C12 ; CN10.18 v1(197.06,187.75) ; v2(209.4,147.45) U4.N12 ; U5.R12 v2(198.15,166.62)
  BOTTOM w0.356: U7.R1 179.55,156.96 v2(179.55,156.98)
  BOTTOM w0.381: U3002.AE2 176.39,119.95 v1(176.43,119.95) ; C4750.1 21.78,68.21 v1(22.66,67.33) ; R4208.1 v1(182.43,113.18) ; C713.1 11.6,87.66 v1(11.79,87.85) ; PR135.1 49.79,83.56 v1(49.36,83.99) ; R616.1 149.87,101.87 v1(149.92,101.83) 150.08,101.99 R614.1 ; U3002.AC13 U3002.AB12 177.84,126.82 v1(177.84,125.95) ; U3002.M20 188.65,134.94 v1(188.8,135.09) ; U3002.AC15 177.13,130.35 v1(177.13,130.42) ; U5.A14 v2(199.78,155.39) ; v1(153.74,105.43) 153.74,105.24 153.94,105.04 C362.1 ; v1(119.82,129.74) 119.82,129.86 118.8,130.88 118.8,131.73 C658.1 ; v1(12.03,88.5) 12.29,88.24 C720.1 ; U3002.P13 185.73,127.94 186.2,128.41 v1(186.2,128.51) 186.63,128.94 U3002.N14 ; C508.2 180.14,46.65 v1(180.17,46.68) ; v1(111.82,21.99) R2872.2 ; U3002.AP2 168.53,119.54 169.33,118.74 U3002.AN1 169.35,118.74 v1(169.86,118.23) 170.49,118.23 v1(171.23,118.97) ; PR289.1 49.53,85.87 v1(49.33,85.87) ; U3002.M13 U3002.N12 186.76,126.91 186.76,126.7 187.01,126.44 v1(187.04,126.44) ; U3002.G3 191,120.34 v1(191.42,119.92) 191.04,119.54 U3002.G2 ; v1(112.45,39.9) EC47.2 C1256.2 ; PC227.1 196.66,54.54 197.14,55.01 ; v1(152.58,92.86) 152.34,93.1 C732.2 ; v1(207.96,107.97) 207.83,107.85 C4030.1 ; v1(202.65,41.37) 202.65,40.89 202.49,40.74 C488.2 ; C172.1 132.64,127.79 132.64,127.3 v2(132.8,127.15) ; v1(150.25,89.66) 150.45,89.66 150.72,89.93 C806.2 ; R1367.1 C1416.2 212.67,154.21 v1(212.12,154.76) ; U7.T10 172.37,156.18 v2(172.37,156.21) ; C351.1 154,107.6 v1(153.85,107.74) ; U3002.AB2 178.89,119.95 v1(178.9,119.95) ; C774.2 162.03,75.41 v1(162.77,76.14) ; v1(14.94,84.98) 14.36,84.4 Q21.2 ; v1(193.91,144.16) 193.91,144.12 U3002.D31 ; C4200.2 176.68,106.44 177.09,106.85 Q4200.1 177.58,106.09 177.65,106.01 v1(177.65,105.63) ; CN20.29 180.9,11.23 v1(182.48,9.65) ; U3002.AA15 178.73,129.91 179.08,129.56 v1(179.19,129.56) ; R4343.2 187.97,113.73 187.97,113.2 v1(188.02,113.15) ; C771.2 177.87,24.37 ; PC43.2 137.65,185.59 137.65,185.97 v1(137.95,186.28) ; v1(194.82,114.99) C4207.1 ; v1(168.92,123.26) 169.33,123.67 U3002.AN7 ; U3002.AB14 U3002.AA13 U3002.Y12 180.13,126.54 v1(180.13,125.95) ; 183.16,135.44 183.66,134.94 U3002.T20 ; 183.16,135.44 182.73,135.88 U3002.U21 ; 183.16,135.44 v1(183.2,135.44) ; v1(148.9,120.09) 148.82,120.16 R569.2 ; v1(146.59,123.31) 146.75,123.48 R555.2 ; v1(149.51,141.65) 149.55,141.69 PC171.2 ; v1(143.44,109.75) 143.49,109.8 R587.2 ; U3002.W22 181.16,136.51 v1(181.16,136.42) 181.29,136.42 181.61,136.1 181.61,136.1 181.73,135.98 U3002.V21 ; PC200.2 v1(206.08,56.31) 205.83,56.06 PR112.1 ; C824.1 87.53,121.55 87.26,121.28 v1(87.26,120.95) ; v1(95.81,127.27) 95.93,127.15 C136.1 ; C530.2 202.29,26.33 v1(201.86,25.9) 201.4,26.36 C527.2 ; U3002.M15 187.83,129.94 188.18,129.59 v1(188.18,129.56) ; v1(107.12,130.88) 107.12,130.33 R537.1 ; R624.2 149.7,100.43 147.4,100.43 v1(147.38,100.45) ; U3002.T15 183.89,129.94 184.29,130.34 ; U3002.V23 U3002.U23 182.73,138.12 v1(182.2,138.65) ; U3002.N19 U3002.P18 185.18,133.48 v1(185.18,133.56) 184.81,133.94 U3002.R19 ; v1(128.96,92.35) 129.34,92.35 129.6,92.6 C739.2 ; v1(124.64,162) 124.8,161.84 PR225.2 ; U3002.AB28 v1(178.05,140.81) ; C3008.1 113.22,24.79 v1(113.21,24.78) ; v1(173.81,138.26) 173.43,137.89 U3002.AH24 ; C484.2 C485.2 v1(199.95,36.72) ; U5.G5 192.15,159.81 v2(192.55,159.41) U5.F5 ; R337.1 v1(225.99,57.04) ; v1(204.45,39.21) 204.53,39.14 C493.1 ; EC44.2 v1(131.76,39.9) ; R4005.1 v1(218.17,108.35) ; v1(143.64,128.19) 143.78,128.32 C698.1 ; 197.14,55.01 v1(197.14,54.96) ; 197.14,55.01 PR268.2 ; C742.1 v1(130.87,96.26) ; U3002.AB16 177.73,130.99 177.43,131.29 177.28,131.29 v1(177.11,131.47) ; R450.2 125.15,169.95 125.41,169.69 v1(125.66,169.69) ; v1(97.08,133.5) 97.58,133 C815.1 ; 181.24,131.47 v1(181.24,131.47) ; 181.24,131.47 180.77,131.94 U3002.W17 ; 181.24,131.47 181.73,130.98 U3002.V16 U3002.U16 ; U3002.W18 180.23,133.44 v1(180.05,133.44) 179.73,133.76 U3002.Y19 ; v1(47.3,81.96) 47.3,82.06 47.68,82.44 R707.1 R706.1 ; v1(59.85,21.76) 59.87,21.76 60.3,21.33 PC175.2 PC98.2 ; v1(177.98,138.47) 177.98,138.45 177.73,138.19 U3002.AB23 ; v1(136.25,164.94) 136.33,164.94 136.5,164.77 PR224.2 ; U3002.W15 180.58,129.94 180.11,130.41 v1(180.11,130.48) 180.04,130.48 179.73,130.79 U3002.Y16 ; v1(184.3,130.42) 184.29,130.34 ; 184.29,130.34 184.73,130.77 U3002.R16 ; C3007.1 113.22,23.52 v1(113.21,23.51) ; U3002.W20 180.73,135.08 v1(180.21,135.6) 179.86,135.94 U3002.Y21 ; R4315.1 189.92,112.67 v1(190.05,112.8) ; v1(165.33,65.17) 165.33,65.15 C776.2 164.98,66.43 165.06,66.43 165.19,66.56 C775.2 165.69,66.71 165.87,66.71 166.1,66.94 R729.1 ; U3002.M18 188.06,132.61 v1(188.06,132.43) 188.06,132.33 187.73,132 U3002.M17 ; R554.2 95.94,123.84 R548.2 ; C1273.2 EC46.2 114.1,39.9 v1(114.1,39.9) ; 211.08,57.4 PQ18.1 ; R785.2 175.11,46.68 175.04,46.76 ; U3002.U12 U3002.V12 v1(181.2,127.47) U3002.W13 180.65,127.94 179.73,128.86 U3002.Y14 ; C4737.2 D4014.2 172.79,81.11 v1(172.73,81.05) ; v1(185.24,132.61) 185.24,132.43 U3002.P17 U3002.N16 ; R612.1 v1(146.13,103.38) 146.61,102.91 R610.1 ; v1(165.74,140.76) Q4203.1 ; U3002.AH22 173.04,136.57 v1(172.99,136.57) ; R4308.1 191.01,109.32 v1(190.58,109.75) ; C428.2 v1(225.99,56.03) ; C4203.2 v1(162.1,142.87) ; U3002.AC18 176.73,132.81 v1(177.09,132.45) 176.73,132.09 U3002.AC17 ; C332.1 165.83,85.14 v1(166.12,85.14) ; R621.1 95.19,102.26 v1(95.81,102.89) 94.8,103.91 v1(94.11,103.91) 92.13,103.91 91.88,103.65 91.88,101.23 R760.2 ; 175.04,46.76 v1(175.06,46.76) ; 175.04,46.76 175.09,46.81 C4726.2 ; D4013.2 C4736.2 ; R736.2 173.92,46.88 v1(173.87,46.83) 173.87,46.65 173.92,46.6 R735.2 ; U3002.AL24 U3002.AL23 170.93,137.03 v1(170.52,136.62) 170.13,136.23 U3002.AM22 U3002.AN22 ; R642.2 134.93,92.81 v1(134.37,92.25) 133.91,92.7 R648.2 ; v1(191.27,110.74) 191.12,110.89 R4212.1 ; C772.2 186.11,46.38 185.13,47.37 185.12,47.37 184.78,47.71 183.88,47.71 EC52.1 v1(183.7,46.71) ; C4206.1 v1(192.27,115.01) ; v1(119.3,19.15) 119.1,19.15 118.89,19.36 C787.1 ; R4340.2 R4339.2 v1(182.43,110.89) ; R766.1 R605.1 149.87,105.05 149.66,104.85 v1(149.66,104.87) ; v1(182.25,48.89) 182.23,48.89 182.05,48.71 182.05,48.48 181.92,48.36 R739.2 ; v1(121.95,18.95) 121.7,19.21 C788.1 ; v1(145.82,118.06) 145.75,118.13 C793.1 ; R350.1 v1(203.51,39.21) ; v1(160.86,87.35) 161.22,87.35 161.91,88.03 R214.2 ; R784.2 189.97,44.77 v1(190.3,45.1) ; v1(195.41,107.94) 194.98,108.38 R4313.1 ; R4009.1 v1(163.51,144.29) ; U3002.AB7 v1(178.48,122.74) U3002.AB5 ; U3002.AE7 v1(175.98,122.74) U3002.AE5 ; CN5.43 123.8,180.28 v1(125.15,181.63) ; R4311.1 188.91,112.8 v1(189.01,112.9) ; v1(154.74,95.4) 153.73,95.4 153.69,95.36 C4723.2 ; C816.1 v1(103.28,133.17) ; C797.2 188.07,45.03 188.02,45.08 188.02,46.25 188.3,46.53 189.54,46.53 v1(189.64,46.43) ; R750.2 209.72,25.26 v1(209.62,25.36) ; v1(196.78,110.76) 196.27,111.27 R858.2 ; v1(67.75,21.51) 67.67,21.58 PC84.2 ; C768.2 171.34,75.39 v1(171.74,75.79) ; U3002.AC20 176.81,134.94 177.73,134.02 U3002.AB19 177.73,133.89 177.43,133.59 177.23,133.59 177.21,133.57 v1(177.21,133.57) ; C1244.2 v1(131.76,40.91) ; v1(204.2,184.8) 204.2,183.71 203.75,183.27 U43.3 ; C803.1 134.05,178.92 135.13,180 v1(135.13,180.41) ; R4206.1 v1(159.17,138.9) ; C454.2 v1(225.99,57.93) ; v1(179.38,109.65) 179.38,110.56 179.04,110.9 R4202.1 ; v1(188.68,35.4) 189.08,35 R380.1 189.41,35.96 C491.2 ; R553.1 109.78,131.95 v1(109.33,132.4) ; R1333.1 211.37,154.21 211.05,153.89 v1(210.85,153.89) ; R592.1 145.85,105.56 v1(145.73,105.68) ; C823.1 v1(88.7,120.92) ; U3002.U14 182.48,128.94 182.48,128.94 182,128.94 182,128.94 U3002.V14 181.58,128.94 v1(181.2,129.32) ; C712.2 v1(145.12,107.84) ; PC129.2 135.05,170.61 134.02,170.61 133.84,170.78 v1(133.84,170.96) ; v1(181.34,134.45) 181.41,134.35 181.73,134.04 U3002.V19 ; R532.2 v1(96.56,130.12) ; C325.2 v1(129.6,96.29)
  BOTTOM w0.406: U3002.AA18 178.89,132.94 v1(179.24,132.58) 178.73,132.07 U3002.AA17
  BOTTOM w0.457: R389.2 R782.2 C780.2
  BOTTOM w0.508: v1(158.43,59.79) 158.59,59.95 PC78.1 PC76.2 157.67,62.25 PC79.1 ; PC75.1 164.73,62.96 v1(165.61,62.07) ; v1(197.15,37.03) C500.2 C501.2 ; v1(169.45,21.13) 170.47,20.11 170.47,20.07 170.49,20.06 CN2019.30 ; v1(77.72,97.56) 78.41,97.56 PC6230.1 79.91,97.74 PC6231.1 ; C4202.2 160.43,140.89 Q4202.1 v1(161.7,140.58) ; v1(160.2,43.07) 159.57,42.44 PQ17.1 ; CN5.41 127.15,183.34 v1(126.47,184.02) v1(125.75,184.74) ; v1(111.69,17.67) 111.82,17.8 C3002.1 ; v1(161.35,51.68) 161.35,51.48 161.35,51.48 PC232.2 162.03,50.71 162.21,50.52 PC241.1 ; v1(62.87,53.03) 62.73,53.03 PC112.2 62.27,54.48 PC111.2 62.19,55.52 PC107.2 ; C1325.2 v1(119.41,67.08) ; PC13.1 v1(221.72,186.54) ; CN6.5 224.2,136.93 224.67,136.45 v1(225.75,136.45) ; C785.1 218.08,37.52 219.06,38.5 v1(219.13,38.5) ; v1(168.54,82.06) 168.61,81.99 C4736.2 ; CN95.10 107.06,13.44 107.06,10.68 v1(106.84,10.46) ; v1(196.81,31.36) 197.08,31.63 C509.2 C510.2 ; CN2019.29 202.44,16.32 v1(201.76,15.64) ; C4650.1 12.22,116.73 v1(12.38,116.58) ; v1(174.05,94.48) 173.98,94.48 173.91,94.41 C1166.2 C1167.2 ; C1253.2 v1(122.24,41.07) ; Q129.1 v1(205.19,157.75) ; v1(152.33,74.72) 152.43,74.82 156.12,74.82 156.8,74.15 PC80.2 ; C805.2 v1(149.54,18.33) ; C482.2 C778.2 190.18,37.98 v1(190.73,37.43) 191.05,37.75 C490.1 ; PC159.2 PC160.2 v1(132.77,144.79) ; EC38.2 120.19,68.22 v1(119.41,68.22) ; R375.2 208.51,36.65 v1(209.07,37.21) ; C822.2 189.28,33.17 v1(188.73,33.17) ; v1(83.06,121.76) 83.28,121.55 C164.1 ; R1337.1 v1(214.69,111.3) ; v1(181.24,85.21) 180.46,85.21 180.42,85.17 C1163.2 178.84,85.17 178.7,85.31 C1164.2 177.91,84.97 PR85.1 ; U9.41 29.58,117.57 C4773.2 ; C767.2 169.11,67.02 169,67.13 C766.2 169.25,67.79 v1(169.65,67.38) ; C301.2 10.9,81.76 v1(11.61,81.05) ; EC49.2 v1(102.16,40.02) ; v1(209.99,26.84) 209.99,27.19 209.98,27.2 C4713.1 ; C190.1 85.24,127.77 85.33,127.85 85.93,127.85 86.11,128.04 v1(86.19,128.04) ; v1(109.38,67.84) 109.5,67.71 EC41.2 ; CN20.28 v1(151.42,17.27) ; v1(165.03,92.15) 165.41,92.53 R957.1 ; D34.2 152.67,20.56 v1(152.76,20.47) ; C4024.1 v1(213.33,105.66) ; C781.2 v1(132.52,17.81) ; v1(97.68,123.45) 97.22,123.45 R554.2 ; C515.1 199.2,23.71 v1(199.52,23.39) 199.57,23.35 C525.2 ; v1(231.55,116.17) 230.71,115.34 R4012.2 ; PC247.1 204.05,177.54 203.63,177.96 v1(203.44,177.96) 204.01,178.53 PC252.1 ; PR302.1 170.31,51.56 v1(170.06,51.81) ; v1(217.02,63.77) 216.75,63.5 216.75,62.53 216.83,62.45 216.83,62.44 217.51,61.77 C412.2 ; R968.1 170.18,106.45 169.62,107.01 v1(169.62,107.15) 169.28,107.15 168.71,107.72 168.71,108.1 ; PC300.1 204.21,173.55 v1(204.55,173.89) ; v1(197.95,24.99) 197.9,24.94 197.89,24.94 C4809.2 ; v1(206.84,42.64) 207.17,42.31 Q27.1 ; v1(115.46,66.26) 115.46,66.26 116.58,66.26 C1336.2 EC39.2 ; v1(114.13,16.81) 114.13,17.11 114.47,17.45 EC54.1 ; v1(25.63,121.89) 26.43,121.09 R11209.2 ; R401.1 v1(211.38,28.75) ; EC48.2 104.82,40.02 v1(104.2,40.02) ; v1(225.75,135.79) 225.56,135.6 222.06,135.6 CN6.1 ; v1(205.31,159.53) 205.93,160.15 R1415.1 C1432.2 R1416.1 ; CN18.5 84.95,16.42 v1(85.78,15.6) ; v1(183.7,46.71) 183.27,46.27 C801.2 C777.2 C514.2 ; PAD14.1 186.24,52.77 v1(184.44,54.58) ; v1(131.25,11.65) 130.95,11.36 C790.2 ; PC6225.1 75.08,48.29 v1(75.27,48.1) ; v1(205.52,156.66) C1212.2 ; v1(168.79,43.12) 168.98,43.31 C799.2 ; U9.37 31.19,120.62 C4774.2 ; EC43.2 v1(90.72,67.47) C1337.2 ; v1(56.88,79.09) 56.65,78.86 PC229.2 ; CN18.6 82.6,9.01 82.35,9.26 v1(82.35,10) ; C763.2 200.33,185.94 201.1,186.71 v1(201.86,186.71) ; Q40.1 219.13,67.05 219.21,66.97 v1(219.26,66.97) ; PC178.1 v1(203.1,54.93) ; v1(188.5,29.2) 188.86,28.85 C800.2 ; v1(213.95,33.9) 213.95,33.29 213.65,32.99 U4511.2 ; R856.2 198.82,110.64 v1(198.94,110.76) ; PR276.1 206.94,62.17 v1(207.3,61.82) ; C187.1 v1(230.56,144.04) ; Q115.1 209.1,155.85 v1(209.38,156.13) ; v1(171.6,25.79) 170.74,26.64 C798.1 ; EC37.2 v1(123.64,67.97) ; v1(175.85,100.86) CN23.76 ; C431.2 220.79,62.89 220.4,62.5 v1(220.27,62.5) ; Y4200.2 192.56,110.87 v1(193.12,110.31) ; R369.2 C494.2 197.16,40.03 v1(196.88,39.75) ; v1(209.62,25.36) R399.2 ; v1(132.67,68.5) 132.9,68.27 C1335.2 ; PC187.2 212.58,57.91 212.08,57.4 210.64,57.4 210.27,57.78 v1(210.27,58.36) ; v1(109.38,66.44) 109.43,66.39 C1318.2 ; C477.2 R354.1 207.63,36.72 v1(207.47,36.57) ; v1(167.72,45.18) 168.15,45.61 PC240.1 ; SW2.5 217.14,32.8 v1(217.27,32.92) ; EC36.2 129.72,68.37 v1(129.72,68.37) ; U42.25 v1(31.18,89.72) ; C796.2 v1(172.04,46.76) ; C821.1 201.51,179.19 v1(202.27,179.19) ; v1(114.85,15.48) 114.85,14.37 CN95.9 ; PR118.2 194.27,59.24 194.54,59.51 PC221.2 194.84,59.24 195.26,58.82 195.5,58.82 v1(195.5,58.81) ; C4025.1 v1(220.42,105.2) ; v1(156.27,35.13) 156.28,35.13 156.34,35.2 C813.1 ; C364.1 v1(35.37,89.18) ; v1(202.62,21.48) 203,21.86 U25.2 ; EC53.1 116.51,17.45 116.85,17.11 v1(116.85,16.89) ; C1314.2 v1(126.93,67.59) ; R176.2 77.43,107.72 v1(77.78,107.72) ; v1(157.49,92.25) 157.77,92.53 C1168.2 C1169.2 ; v1(165.97,35.67) 165.97,34.51 166.19,34.3 167.05,34.3 167.45,34.7 C770.2 167.5,35 168.17,35 168.26,34.91 R783.2 ; v1(203.46,177.07) 204,176.52 PR309.2 ; C537.2 211.9,33.91 v1(211.96,33.97) ; v1(194.98,114.09) 194.76,113.87 Y4200.4 ; v1(116.85,15.46) CN17.10 ; v1(182.2,56.56) 182.2,56.81 182.17,56.84 U41.4 ; C456.2 v1(213.92,40.69) ; v1(168.04,30.91) 168.2,30.75 R463.2 ; C786.2 v1(129.28,17.3) ; PC77.1 155.98,60.51 155.48,60.01 v1(155.48,59.46) 155.99,58.95 PQ6066.1 ; v1(166.2,45.13) 165.97,44.9 PC233.2 ; C1271.2 v1(97.29,39.97) ; C783.2 v1(133.91,16.11) ; v1(121.95,18.95) 122,18.91 CN17.5 ; C1261.2 v1(102.16,41.04) ; PU16.2 168.05,47.59 v1(168.05,47.72) ; v1(163.68,50.72) 164,50.4 PC244.2 ; Q19.1 224.11,127.55 224.59,128.04 v1(225.75,128.04) ; PR75.2 160.99,61.18 v1(161.17,61.01) ; v1(188.8,105.94) 189.23,105.51 R4326.1 ; Q4201.1 175.04,108.86 v1(175.55,108.35) ; C1332.2 v1(100.41,67.21) ; C321.1 64.79,116.34 64.35,115.9 v1(64.35,115.19) ; EC50.2 v1(97.29,41.12) ; EC42.2 102.79,65.06 v1(102.93,64.92) ; C1409.2 v1(213.54,111.3) ; v1(54.29,55.09) 54.49,54.88 PC177.2 ; v1(176.51,110.64) 176.25,110.9 C4201.2 ; R1335.1 v1(212.4,111.3) ; v1(125.69,13.58) 128.13,13.58 128.15,13.57 CN17.9 ; v1(57.68,51.3) 57.03,50.65 PC174.2 ; v1(199.17,65.68) PC195.2 ; v1(160.74,122.04) 161.45,122.04 162,122.59 R4332.1 R4334.1 ; PC100.1 v1(56.19,79.77) ; C808.1 86.54,120.31 v1(86.52,120.29) ; C811.1 v1(174.42,55.55) ; C1165.2 176.21,89.76 v1(176.05,89.61) ; v1(118.93,133.9) v1(118.93,133.19) 118.93,132.27 118.68,132.02 C658.1 ; Y4.2 115.54,132.51 116,132.06 C665.1 116,131.47 116.64,130.83 ; C1254.2 v1(104.2,41.04) ; PR102.2 207.37,58.67 v1(207.4,58.69) ; v1(133.79,39.9) 133.91,40.02 EC45.2 ; v1(225.75,131.69) 224.7,131.69 224.2,131.2 CN6.6 ; C1260.2 v1(138.7,40.14) ; R782.2 v1(190.89,30.88) ; PC176.2 v1(54.39,53.87)
  BOTTOM w0.762: v3(65.88,37.52) PC6226.1 ; CN5.44 116.88,173.25 v1(117.3,173.25) ; PC6098.2 57.77,39.54 v1(57.92,39.69) ; PR6125.1 54.61,36.86 v3(54.24,37.23) 54.24,37.26 53.63,37.87
  vias: v1(6.12,41.77) v1(6.91,39.61) v1(7.43,41.79) v1(7.91,71.47) v1(8.43,39.6) v1(8.75,41.8) v1(9.81,119.63) v1(9.77,39.59) v1(10.65,70.45) v1(11.61,41.58) v1(12.87,42.09) v1(12.89,41.33) v1(13.14,51.58) v1(13.24,49.96) v1(13.24,48.28) v1(13.29,46.37) v1(13.82,44.42) v1(13.93,91.99) v1(13.93,91.33) v1(14.69,91.99) v1(14.69,91.33) v1(15.45,32.23) v1(15.73,38.45) v1(15.75,39.24) v1(17.61,29.64) v1(17.89,118.03) v1(18.01,120.06) v1(18.34,116.1) v1(18.7,38.58) v1(18.7,37.93) v1(19.2,15.28) v1(19.2,14.62) v1(19.67,32.61) v1(21.27,38.07) v1(21.75,14.49) v1(21.77,12.37) v1(22.1,28.72) v1(22.26,117.77) v1(22.51,119.98) v1(22.64,68.32) v1(22.66,69.36) v1(23.68,69.41) v1(23.68,68.35) v1(23.65,67.28) v1(23.81,28.67) v1(24.24,117.22) v1(24.29,119.15) v1(24.49,29.08) v1(24.47,28.42) v1(24.69,69.36) v1(24.72,68.32) v1(24.69,67.33) v1(25.56,40.74) v1(25.8,35.51) v1(26.35,44.17) v1(27.01,113.15) v1(27.01,48.66) v1(27.01,47.95) v1(27.06,52.04) v1(27.46,112.67) v1(30.61,60.22) v1(31.15,67.56) v1(31.68,70.02) v1(32,95.07) v1(32,91.9) v1(36.02,74.54) v1(36.12,72.59) v1(36.07,70.76) v1(36.25,85.36) v1(36.56,97.3) v1(36.56,96.64) v1(37.14,84.2) v1(37.83,74.57) v1(37.83,14.78) v1(37.9,72.66) v1(37.95,70.78) v1(38.16,82.57) v1(38.54,110.18) v1(38.54,109.44) v1(38.54,108.73) v1(38.54,108) v1(38.84,58.64) v1(38.83,57.93) v1(38.81,56.84) v1(38.81,56.18) v1(38.77,55.08) v1(39.81,74.59) v1(39.81,72.59) v1(39.81,70.81) v1(40.52,105.86) v1(40.87,60.1) v1(41.17,46.36) v1(42.32,50.51) v1(42.86,46.37) v1(42.96,27.27) v1(43.34,37.38) v1(43.47,36.72) v1(44.05,37.13) v1(44.25,57.3) v1(44.67,56.76) v1(45.21,56.32) v1(46.26,74.39) v1(47.82,37.23) v1(47.96,80.21) v1(49.65,51.76) v1(50.34,51.78) v1(50.68,95.98) v1(52.25,80.51) v1(53.27,119.65) v1(54.29,120.67) v1(54.72,59.05) v1(54.77,107.21) v1(55.4,27.05) v1(56.33,59.07) v1(56.44,120.29) v1(56.83,107.59) v1(57.28,29.1) v1(57.46,121.18) v1(58.2,28.32) v1(58.35,52.7) v1(58.55,51.53) v1(58.86,107.21) v1(58.99,69.6) v1(59.01,52.72) v1(59.52,122.8) v1(59.75,96.39) v1(60.23,47.57) v1(60.41,122.8) v1(61.32,122.8) v1(62.33,95.35) v1(64.87,119.13) v1(65.03,66.29) v1(65.53,119.13) v1(66.15,66.06) v1(68.41,21.41) v1(68.87,21.89) v1(70.52,57.07) v1(70.73,75.41) v1(71.89,119.6) v1(72.5,19.17) v1(72.57,119.6) v1(75.93,76.07) v1(75.95,76.83) v1(75.95,75.23) v1(76.69,76.83) v1(76.71,76.12) v1(76.74,75.23) v1(77.04,129.94) v1(77.04,128.44) v1(77.04,127.78) v1(77.07,129.23) v1(77.07,127.1) v1(77.25,123.9) v1(77.58,76.88) v1(77.58,76.14) v1(77.55,75.2) v1(77.76,130.02) v1(77.78,129.23) v1(77.78,128.52) v1(77.78,127.83) v1(79.91,35.68) v1(79.91,35.02) v1(79.91,34.34) v1(80.68,77.9) v1(83.42,117.55) v1(83.9,31.01) v1(84.24,46.41) v1(85.15,116.15) v1(85.12,61.87) v1(85.12,59.2) v1(85.47,46.03) v1(85.6,116.66) v1(86.14,117.09) v1(86.54,75.18) v1(86.49,47.98) v1(86.8,117.16) v1(86.9,113.05) v1(86.92,61.61) v1(87.23,120.29) v1(87.48,117.16) v1(87.92,120.29) v1(88.02,120.95) v1(88.14,117.16) v1(88.17,134.56) v1(88.5,135.22) v1(88.86,134.56) v1(88.86,117.16) v1(89.16,135.25) v1(90.02,59.29) v1(90.1,47.26) v1(90.56,130.32) v1(91.57,60.32) v1(93.22,47.47) v1(94.04,60.41) v1(95.18,111.65) v1(95.43,108.45) v1(95.35,59.72) v1(96.08,104.91) v1(96.17,110.14) v1(96.8,60.41) v1(97.21,102.25) v1(97.47,107.06) v1(97.47,57.97) v1(97.69,111.83) v1(97.99,114.43) v1(98.65,114.43) v1(98.9,48.77) v1(99.37,96.73) v1(99.66,101.22) v1(100.3,99.95) v1(100.46,59.22) v1(100.64,96.36) v1(101.11,47.57) v1(102.72,95.12) v1(102.93,61.61) v1(102.97,57.99) v1(102.97,46.23) v1(104.65,97.94) v1(104.65,93.39) v1(106.28,45.26) v1(106.7,61.63) v1(107.58,95.3) v1(107.58,94.66) v1(107.65,61.61) v1(108.13,144.88) v1(108.29,45.79) v1(108.79,144.88) v1(109.15,152.78) v1(109.22,48.46) v1(109.41,95.08) v1(109.38,60.34) v1(109.53,153.36) v1(109.45,139.21) v1(109.48,138.55) v1(109.48,137) v1(109.58,143.33) v1(109.58,142.67) v1(109.58,142.01) v1(109.89,130.4) v1(110.09,153.89) v1(110.23,45.32) v1(110.42,160.04) v1(110.63,95.08) v1(110.78,153.89) v1(110.95,60.36) v1(111.08,130.32) v1(111.44,161.26) v1(111.46,161.92) v1(111.49,133.73) v1(111.51,45.26) v1(111.7,111.43) v1(111.84,138.96) v1(111.86,49.03) v1(111.86,47.71) v1(111.99,136.29) v1(111.99,133.29) v1(112.07,134.08) v1(112.34,111.43) v1(112.5,138.96) v1(112.5,136.8) v1(112.45,45.99) v1(112.55,133.62) v1(112.69,96.22) v1(112.97,111.43) v1(113.31,58.95) v1(113.44,48.15) v1(113.61,111.43) v1(113.97,45.46) v1(114.24,111.43) v1(114.88,111.43) v1(115.02,117.22) v1(115.32,45.26) v1(115.69,115.93) v1(115.73,96.27) v1(115.88,114.07) v1(115.88,113.41) v1(116.01,49.4) v1(116.08,112.47) v1(116.19,111.73) v1(116.35,115.93) v1(116.44,113.74) v1(116.62,117.22) v1(116.61,45.44) v1(116.72,157.32) v1(116.87,110.61) v1(116.92,96.93) v1(117.48,159.33) v1(117.74,45.44) v1(117.74,35.45) v1(117.83,59.97) v1(118.04,158.01) v1(118.09,47.08) v1(118.17,126.41) v1(118.5,108.65) v1(118.65,163.75) v1(119.18,63.27) v1(119.18,25.04) v1(119.4,97.16) v1(119.37,95.25) v1(119.44,60.78) v1(119.36,47.08) v1(119.77,165.17) v1(119.82,131.97) v1(120.35,35.45) v1(121.13,95.89) v1(121.34,25.01) v1(121.44,46.6) v1(121.41,45.28) v1(121.49,60.22) v1(121.49,58.73) v1(121.49,57.46) v1(121.52,48.89) v1(122.71,61.61) v1(122.71,49.39) v1(122.9,95.31) v1(123.68,60.6) v1(123.68,57.69) v1(123.68,45.56) v1(124,118.06) v1(124.06,116.86) v1(124.14,113.86) v1(124.14,113.2) v1(124.14,112.52) v1(124.23,114.81) v1(124.17,111.64) v1(124.52,156.53) v1(124.82,97.2) v1(124.81,95.25) v1(125.51,126.21) v1(125.48,125.42) v1(125.62,49.27) v1(125.89,127.73) v1(126.41,95.89) v1(127.26,159.25) v1(127.31,157.98) v1(127.31,157.22) v1(127.29,140.23) v1(127.77,124.86) v1(127.97,140.23) v1(128.02,135.1) v1(128.2,172.61) v1(128.37,95.25) v1(128.66,140.23) v1(129.01,183.89) v1(129.09,174.01) v1(129.24,131.92) v1(129.34,140.23) v1(129.57,47.47) v1(129.72,59.78) v1(130.03,140.23) v1(130.71,140.23) v1(131.28,61.65) v1(131.4,140.05) v1(131.57,49.4) v1(131.65,77.92) v1(132.04,149.52) v1(132.09,140.05) v1(132.11,58.62) v1(132.3,77.06) v1(132.77,140.05) v1(133.43,140.05) v1(133.79,47.77) v1(133.86,156.13) v1(134.14,140.05) v1(134.09,59.97) v1(134.55,47.77) v1(134.6,11.3) v1(134.8,154.68) v1(136.2,58.78) v1(137.06,158.34) v1(138.32,175.62) v1(138.39,178.1) v1(138.41,176.96) v1(139.25,175.48) v1(139.55,129.94) v1(139.66,36.75) v1(139.8,61.47) v1(139.81,58.92) v1(140.09,176.02) v1(140.19,177.08) v1(140.21,129.94) v1(140.47,177.85) v1(141.28,49.32) v1(141.37,60.28) v1(141.37,59.19) v1(141.45,118.51) v1(141.79,137.61) v1(143.19,60.33) v1(143.17,58.81) v1(143.57,137.94) v1(144.15,40.25) v1(144.41,152.78) v1(144.46,35.2) v1(144.58,42.01) v1(144.84,40.28) v1(145.52,59.99) v1(145.65,47.9) v1(146.11,137.87) v1(146.11,60.55) v1(146.46,169.97) v1(146.56,141.42) v1(146.82,35.25) v1(146.84,33.65) v1(147,156.13) v1(146.97,61.08) v1(147.02,47.8) v1(147.53,137.66) v1(147.53,35.25) v1(147.94,7.92) v1(148.11,116.22) v1(148.72,170.63) v1(148.67,7.92) v1(149.43,7.92) v1(149.84,137) v1(150.32,110.64) v1(152.46,137.31) v1(154.31,189.78) v1(155.53,106.6) v1(155.56,156.71) v1(155.86,165.91) v1(156.01,107.74) v1(156.19,102.05) v1(156.55,109.72) v1(156.5,106.57) v1(156.85,102.05) v1(156.85,67.3) v1(156.85,66.66) v1(157.08,109.11) v1(157.21,109.8) v1(157.51,102.05) v1(158.04,125.83) v1(158.83,147.57) v1(159.31,124.96) v1(159.54,146.25) v1(159.54,145.59) v1(159.54,144.93) v1(159.87,123.77) v1(160.89,160.34) v1(161.27,67.1) v1(161.27,66.44) v1(162.31,169.31) v1(164.67,131.72) v1(165.23,130.3) v1(165.82,145.66) v1(166.22,128.52) v1(166.25,125.22) v1(166.58,121.61) v1(166.78,148.23) v1(166.81,146.88) v1(166.95,72.38) v1(166.95,71.71) v1(167.42,179.14) v1(167.62,123.87) v1(167.87,178.02) v1(167.93,122.07) v1(168.36,121.33) v1(168.97,150.95) v1(169.09,148.97) v1(169.25,135.05) v1(170.57,119.12) v1(173.08,111.27) v1(173.34,39.29) v1(173.62,110.87) v1(174.2,110.43) v1(175.47,126.71) v1(176.26,112.8) v1(177.48,112.82) v1(178.54,173.4) v1(178.7,128.52) v1(179.41,172.82) v1(180.04,102.56) v1(180.52,112.77) v1(180.55,112.08) v1(180.55,111.42) v1(180.68,149.14) v1(181.74,24.89) v1(182.25,173.43) v1(182.71,24.89) v1(182.91,173.43) v1(182.99,151.58) v1(183.67,24.89) v1(184.66,24.89) v1(185.04,138.9) v1(185.45,24.94) v1(186.11,24.94) v1(186.39,138.95) v1(187.64,139) v1(188.04,126.43) v1(188.93,139.03) v1(188.91,138.35) v1(188.91,137.56) v1(191.06,25.09) v1(191.34,11.91) v1(191.32,11.2) v1(191.32,10.48) v1(191.29,9.82) v1(192.18,112.31) v1(194.16,176.91) v1(194.93,173.76) v1(195.08,68.3) v1(196.5,25.09) v1(196.63,191.15) v1(196.63,190.01) v1(197.16,134.21) v1(197.29,191.15) v1(197.29,190.01) v1(198.79,69.9) v1(199.42,60.6) v1(199.43,59.8) v1(200.29,60.57) v1(200.27,59.84) v1(201.86,187.47) v1(201.99,131.26) v1(202.52,187.47) v1(202.52,34.31) v1(202.55,32.41) v1(202.52,30.53) v1(202.75,132.07) v1(204.37,34.31) v1(204.4,32.4) v1(204.4,30.53) v1(205.24,33.19) v1(205.75,175.16) v1(205.76,175.84) v1(206.28,34.31) v1(206.25,32.38) v1(206.25,30.58) v1(207.32,50.21) v1(208.74,62.35) v1(209.1,175.66) v1(209.1,174.9) v1(210.42,65.58) v1(210.59,174.51) v1(212.17,85.72) v1(213.67,22.88) v1(214.36,22.88) v1(214.53,26.41) v1(214.56,27.86) v1(214.56,27.17) v1(214.56,25.67) v1(214.88,175.95) v1(221.28,32.8) v1(221.28,31.89) v1(221.28,31.03) v1(221.28,30.22) v1(222.21,50.46) v1(222.21,49.78) v1(222.21,49.12) v1(222.22,32.87) v1(222.19,30.17) v1(223.95,158.47) v1(224.44,158.01) v1(224.47,192.09) v1(224.87,117.34) v1(225.38,43.45) v1(227.36,105.94) v1(227.74,110.23) v1(228.68,107.39) v1(228.91,110.21) v1(228.89,109.11) v1(228.86,108.1) v1(231.07,102.15) v1(231.68,180.51) v1(231.73,102.15) v1(231.76,101.49) v2(117.61,106.52) v2(121.98,123.41) v2(128.24,113.42) v2(128.26,109.63) v2(169.3,153.89) v2(169.98,161.84) v2(171.58,161.01) v2(195.59,119.1) v2(196.1,118.72) v2(197.37,128.57) v2(198.15,161.87) v2(213.39,145.87) v3(0.97,126.82) v3(2.62,127.6) v3(2.67,24.12) v3(3.92,93.59) v3(3.99,113.58) v3(3.97,90.93) v3(4.15,65.4) v3(4.32,112.67) v3(4.45,96.24) v3(4.45,61.44) v3(4.78,114.09) v3(5.16,67.71) v3(5.26,59.1) v3(5.39,24.05) v3(5.44,6.47) v3(5.54,113.46) v3(5.62,93.64) v3(5.62,92.43) v3(5.75,85.06) v3(5.8,87.19) v3(5.8,72.33) v3(5.77,70.61) v3(6.38,95.37) v3(6.84,92.4) v3(6.94,93.64) v3(7.35,113.41) v3(7.32,91.26) v3(7.45,73.04) v3(7.63,59.13) v3(8.16,96.18) v3(8.24,72.38) v3(8.31,70.68) v3(8.36,92.02) v3(8.72,112.49) v3(8.92,69.92) v3(8.87,24) v3(9.05,93.31) v3(9.05,71.52) v3(9.4,94.43) v3(9.76,70.73) v3(10.5,23.44) v3(12.07,23.64) v3(12.17,112.39) v3(12.22,96.46) v3(12.81,109.6) v3(12.76,99.33) v3(18.09,0.96) v3(18.17,6.75) v3(18.52,2.64) v3(21.14,127.6) v3(21.11,125.62) v3(21.7,10.97) v3(22.82,125.95) v3(22.97,8.07) v3(23.27,5.94) v3(23.73,8.76) v3(23.78,127.65) v3(24.19,7.89) v3(25.03,8.73) v3(25.63,7.97) v3(25.81,5.96) v3(26.42,8.71) v3(26.9,128.8) v3(27.67,6.09) v3(28.84,8.2) v3(28.96,130.04) v3(30.74,14.37) v3(31.35,127.5) v3(31.65,8.76) v3(32.65,13.89) v3(34.58,127.5) v3(34.91,8.68) v3(36.23,125.52) v3(36.73,124.43) v3(36.71,121.25) v3(36.99,119.15) v3(37.39,122.91) v3(38.49,124.48) v3(38.64,125.65) v3(38.59,121.23) v3(38.56,119.15) v3(38.59,8.66) v3(38.69,127.53) v3(38.89,12.82) v3(40.06,122.91) v3(40.21,124.45) v3(41.36,8.66) v3(41.61,119.48) v3(41.69,125.55) v3(41.89,12.82) v3(42.38,60.8) v3(42.6,122.91) v3(43.16,6.42) v3(43.39,117.75) v3(43.72,119.55) v3(43.72,9.01) v3(44.02,7.87) v3(44.23,125.55) v3(44.41,116.83) v3(44.99,9.04) v3(45.14,122.91) v3(45.29,7.89) v3(45.4,117.72) v3(45.4,5.89) v3(46.26,119.55) v3(46.44,116.89) v3(46.41,9.01) v3(46.72,7.87) v3(46.77,125.55) v3(47.4,6.01) v3(47.58,117.7) v3(47.58,8.94) v3(47.68,122.91) v3(47.83,7.87) v3(48.8,119.55) v3(49.31,125.55) v3(49.54,8.07) v3(50.22,122.91) v3(51.21,119.55) v3(51.34,93.31) v3(51.85,125.55) v3(51.82,9.04) v3(52.18,122.91) v3(52.2,81.27) v3(52.89,80.92) v3(53.47,6.95) v3(53.7,122.93) v3(54.14,59.73) v3(54.39,125.55) v3(54.64,61.14) v3(54.76,60.35) v3(55.21,61.67) v3(55.33,28.24) v3(55.5,60.97) v3(55.81,62.15) v3(56.11,61.43) v3(56.19,28.24) v3(56.24,26.05) v3(56.29,2.97) v3(56.56,62.14) v3(56.6,25.39) v3(56.72,49.02) v3(57,26.05) v3(57.11,28.26) v3(57.22,59.03) v3(57.36,48.41) v3(57.44,25.42) v3(57.59,7.49) v3(57.89,26.05) v3(58.02,48.97) v3(58.22,25.34) v3(58.73,26.72) v3(58.73,25.93) v3(58.83,48.43) v3(58.81,47.42) v3(58.87,71.96) v3(59.11,9.01) v3(59.37,94.84) v3(59.44,27.12) v3(59.42,26.28) v3(59.44,25.42) v3(59.75,95.52) v3(59.79,71.95) v3(60.13,94.84) v3(60.18,26.36) v3(60.2,25.6) v3(60.28,27.12) v3(60.53,125.57) v3(60.51,95.52) v3(60.79,71.93) v3(60.89,94.84) v3(60.94,26.36) v3(61.09,27.1) v3(61.07,8.35) v3(61.27,95.52) v3(61.65,94.84) v3(61.86,96.18) v3(61.91,79.42) v3(62.08,124.53) v3(62.41,78.66) v3(62.52,2.89) v3(62.77,79.47) v3(62.79,16.91) v3(63.02,77.95) v3(63.3,123.36) v3(63.38,78.66) v3(63.58,79.52) v3(63.56,16.91) v3(63.85,77.97) v3(64.24,78.71) v3(64.68,77.99) v3(65.33,2.92) v3(65.61,122.3) v3(65.61,8.05) v3(65.56,5.43) v3(68.1,8.96) v3(68.54,122.19) v3(69.98,8.53) v3(70.29,43.2) v3(70.29,42.31) v3(70.29,41.42) v3(70.41,6.73) v3(70.39,5) v3(70.59,56.15) v3(70.92,123.44) v3(71.3,57.14) v3(71.3,43.2) v3(71.3,42.31) v3(71.3,41.42) v3(71.38,56.18) v3(72.17,124.96) v3(72.4,122.8) v3(72.53,74.73) v3(72.73,126.99) v3(73.01,128.95) v3(73.08,124.15) v3(73.67,74.7) v3(73.7,73.64) v3(73.71,72.45) v3(73.77,125.32) v3(74,130.73) v3(74,58.31) v3(74,57.5) v3(74.02,56.64) v3(73.97,42.31) v3(73.97,41.42) v3(74.3,129.66) v3(74.3,128.62) v3(74.35,127.6) v3(74.35,126.49) v3(74.86,125.34) v3(75.39,129.69) v3(75.39,128.65) v3(75.44,127.63) v3(75.44,126.51) v3(76.36,131.36) v3(79.36,132.4) v3(82.38,4.64) v3(82.51,3.65) v3(82.63,133.67) v3(82.66,2.46) v3(83.06,0.91) v3(83.34,3.91) v3(83.62,3.04) v3(84.61,2.48) v3(86.11,135.45) v3(86.19,2.38) v3(86.39,0.88) v3(87.76,2.43) v3(89.34,137.51) v3(89.39,0.88) v3(89.49,7.54) v3(89.52,5.1) v3(89.54,2.61) v3(90.68,8.88) v3(91.5,9.9) v3(92.18,139.72) v3(93.17,10.05) v3(93.27,9.11) v3(93.39,120.15) v3(94.15,120.15) v3(94.91,120.15) v3(95.03,142.31) v3(95.33,10.03) v3(95.43,9.09) v3(97.16,144.6) v3(97.36,10.05) v3(97.47,9.11) v3(99.42,147.54) v3(99.37,10) v3(99.47,9.06) v3(101.1,150.01) v3(101.76,10.05) v3(101.86,9.11) v3(102.9,153.28) v3(104.12,10.08) v3(104.17,11.17) v3(104.22,9.14) v3(104.32,156.56) v3(105.67,159.96) v3(106.76,9.14) v3(107.12,162.91) v3(108.54,165.96) v3(109.3,9.14) v3(110.32,169.39) v3(111.69,172.08) v3(111.84,9.14) v3(113.09,174.59) v3(114.38,9.14) v3(115.07,177.36) v3(116.92,9.14) v3(117.18,179.88) v3(117.58,157.2) v3(119.34,181.83) v3(119.46,9.14) v3(120,157.55) v3(120.15,158.31) v3(121.11,158.29) v3(121.09,157.53) v3(121.72,183.92) v3(122,9.14) v3(122.94,157.53) v3(122.87,156.74) v3(123.12,155.93) v3(123.12,155.16) v3(123.12,154.35) v3(124.54,9.14) v3(124.92,186.1) v3(125.89,158.44) v3(125.89,157.68) v3(125.89,156.92) v3(125.89,156.15) v3(126.65,158.44) v3(126.65,157.68) v3(126.65,156.92) v3(126.65,156.15) v3(126.78,170.17) v3(127.08,9.14) v3(128.81,170.12) v3(129.65,157.53) v3(129.62,9.14) v3(129.93,158.29) v3(130.49,157.53) v3(130.79,158.29) v3(131.93,156.76) v3(132.09,9.14) v3(132.49,157.27) v3(132.59,156.33) v3(132.59,155.57) v3(132.59,154.81) v3(132.57,154.02) v3(132.57,153.18) v3(132.57,152.29) v3(132.59,151.48) v3(134.85,9.11) v3(135.79,157.63) v3(135.77,156.46) v3(136.3,157.04) v3(136.76,157.65) v3(136.84,156.48) v3(139.45,189.91) v3(139.81,158.11) v3(139.76,157.32) v3(140.72,158.13) v3(140.67,157.32) v3(141.38,189.91) v3(142.55,157.25) v3(142.55,156.48) v3(142.68,155.67) v3(142.68,153.84) v3(142.68,153.05) v3(142.68,152.22) v3(142.73,151.43) v3(142.68,150.62) v3(142.75,154.71) v3(143.29,189.94) v3(143.41,156.51) v3(143.47,157.27) v3(143.47,155.67) v3(143.54,154.76) v3(143.49,151.4) v3(143.52,150.64) v3(144.23,157.27) v3(144.28,156.51) v3(144.28,155.65) v3(144.3,154.76) v3(144.28,151.38) v3(146.82,189.94) v3(147.12,171.34) v3(147.1,170.58) v3(147.1,169.34) v3(147.55,169.97) v3(147.88,171.34) v3(148.04,170.58) v3(148.11,158.01) v3(148.14,155.57) v3(148.16,156.81) v3(148.55,154.93) v3(148.65,157.47) v3(148.65,156.23) v3(148.67,171.32) v3(150.3,189.91) v3(150.63,7.97) v3(151.52,157.58) v3(151.57,158.36) v3(152.51,158.39) v3(152.48,157.63) v3(152.74,189.81) v3(152.69,7.97) v3(155.3,7.94) v3(156.88,189.88) v3(160.86,189.88) v3(161.42,157.47) v3(161.55,158.97) v3(161.58,158.21) v3(162.24,158.57) v3(162.16,157.7) v3(163.3,169.13) v3(163.89,169.9) v3(164.8,178.4) v3(165.28,189.83) v3(165.36,170.05) v3(165.49,178.71) v3(166.22,178.45) v3(167.06,178.23) v3(167.06,7.84) v3(167.49,188.16) v3(167.82,180.84) v3(167.93,180.08) v3(169.2,186.96) v3(169.6,7.84) v3(172.14,7.84) v3(174.68,7.84) v3(175.16,73.4) v3(175.16,72.61) v3(175.22,71.85) v3(177.22,7.84) v3(179.76,7.84) v3(181.41,182.8) v3(181.44,98.04) v3(181.54,99.61) v3(181.51,94.15) v3(181.46,93.24) v3(181.54,91.74) v3(181.57,98.85) v3(182.3,99.59) v3(182.3,7.84) v3(182.51,98.04) v3(182.51,94.15) v3(182.45,93.24) v3(182.51,91.71) v3(182.94,98.75) v3(183.19,99.59) v3(183.34,94.15) v3(183.44,98.04) v3(183.42,91.74) v3(184.03,98.75) v3(184.08,99.71) v3(184.26,182.77) v3(184.84,7.84) v3(187.38,7.84) v3(187.66,182.72) v3(189.92,7.84) v3(193.4,76.96) v3(193.43,75.18) v3(193.35,71.72) v3(193.45,73.35) v3(193.53,70.2) v3(193.73,77.9) v3(193.68,72.59) v3(193.71,70.99) v3(193.73,69.41) v3(193.76,76.12) v3(193.81,74.21) v3(194.06,194.33) v3(194.21,71.75) v3(194.27,76.98) v3(194.29,75.2) v3(194.34,73.3) v3(194.39,70.23) v3(194.65,72.61) v3(194.7,77.92) v3(194.72,76.14) v3(194.67,71.01) v3(194.7,69.44) v3(194.77,74.24) v3(195.1,71.77) v3(195.15,77.01) v3(195.18,75.23) v3(195.23,73.32) v3(195.28,70.25) v3(195.61,77.9) v3(195.64,76.12) v3(195.64,72.64) v3(195.59,70.99) v3(195.61,69.41) v3(195.69,74.21) v3(196.04,71.85) v3(196.07,76.98) v3(196.09,75.2) v3(196.14,73.3) v3(196.2,70.23) v3(196.6,194.33) v3(197.54,7.84) v3(199.14,194.33) v3(200.08,7.84) v3(201.68,194.33) v3(202.62,7.84) v3(204.22,194.33) v3(206.76,194.33) v3(209.3,194.33) v3(209.48,99.33) v3(209.48,98.44) v3(209.48,96.67) v3(209.48,95.78) v3(209.48,94) v3(209.48,93.19) v3(209.48,91.59) v3(209.48,90.7) v3(209.48,89.68) v3(209.48,88.79) v3(209.48,88.03) v3(209.48,87.14) v3(209.48,86.35) v3(210.34,93.19) v3(210.32,87.62) v3(210.32,86.74) v3(210.32,85.72) v3(210.37,99.33) v3(210.37,98.44) v3(210.37,96.67) v3(210.37,95.78) v3(210.37,94) v3(211.84,194.33) v3(212.65,7.08) v3(213.11,158.36) v3(213.87,158.36) v3(214.18,88.54) v3(214.18,87.65) v3(214.18,86.63) v3(214.18,85.74) v3(214.18,84.98) v3(214.27,178.26) v3(214.28,177.37) v3(214.38,194.33) v3(214.62,176.66) v3(215.02,178.22) v3(215.03,177.37) v3(214.99,70.12) v3(214.99,69.31) v3(214.99,68.47) v3(215.09,72.41) v3(215.7,103.65) v3(215.7,102.76) v3(216.92,194.33) v3(218.37,23.95) v3(218.37,21.46) v3(218.37,19.17) v3(218.4,15.87) v3(218.37,12.8) v3(218.37,9.6) v3(219.13,194.33) v3(220.3,171.15) v3(220.3,25.62) v3(221.12,171.13) v3(221.58,170.51) v3(221.67,194.33) v3(221.94,169.84) v3(221.98,171.17) v3(222.18,171.93) v3(222.42,160.2) v3(222.47,170.55) v3(222.7,169.82) v3(222.73,169.07) v3(222.84,171.22) v3(222.99,25.57) v3(223.07,78.28) v3(223.07,75.74) v3(223.07,73.2) v3(223.07,70.66) v3(223.07,68.12) v3(223.07,65.58) v3(223.48,169.85) v3(223.52,159.04) v3(224.21,194.33) v3(224.34,63.95) v3(225.1,177.57) v3(225.08,25.24) v3(225.86,177.57) v3(226.75,194.33) v3(227.11,63.88) v3(227.54,25.27) v3(228.63,184.04) v3(228.63,183.15) v3(228.61,182.09) v3(228.61,181.2) v3(228.58,180.33) v3(229.29,194.33) v3(229.77,183.71) v3(229.77,182.82) v3(230.56,137.08) v3(230.79,140.84) v3(231.35,41.8) v3(231.32,37.89) v3(231.43,64.05) v3(231.4,60.83) v3(231.37,39.82) v3(231.4,26.84) v3(231.4,25.24) v3(231.48,57.8) v3(231.48,55.26) v3(231.45,35.88) v3(231.48,33.57) v3(231.45,31.49) v3(231.45,29) v3(231.73,80.84) v3(231.83,197.63) v3(233.99,170.45) v3(233.99,157.75) v3(233.99,155.21) v3(233.99,152.67) v3(233.99,150.13) v3(233.99,147.59) v3(233.99,145.05) v3(233.99,142.51) v3(233.97,126.11) v3(233.97,123.57) v3(234.02,120.66) v3(233.97,118.49) v3(233.97,116.66) v3(234.37,197.63) v3(234.68,103.3) v3(234.68,100.76) v3(234.78,110.97) v3(234.78,108.83) v3(234.78,86.53) v3(236.48,184.7) v3(236.91,197.63) v3(239.12,197.58)
