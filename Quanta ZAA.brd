# Allegro board Quanta ZAA.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VIN on TOP (solid shape): 166.2,184.96 166.2,181.3 165.79,180.89 165.79,179.65 165.69,179.55 165.03,179.55 164.14,178.66 164.14,177.97 163.94,177.77 161.35,177.77 161.25,177.87 161.25,179.19 161.55,179.49 161.77,179.6 161.88,179.83 162.68,180.62 162.69,180.63 162.79,180.7 162.86,180.8 162.86,180.81 163.38,181.33 163.38,184.63 163.96,185.21 165.94,185.21
VIN on TOP (solid shape): 231.06,175.92 231.06,172.46 229.7,171.1 226.18,171.1 225.9,171.37 223.34,171.37 223.09,171.62 223.09,175.79 229.04,175.79 229.04,175.72 229.05,175.66 229.07,175.6 229.1,175.54 229.13,175.49 229.17,175.44 229.22,175.4 229.27,175.36 229.33,175.33 229.39,175.3 229.45,175.29 229.51,175.28 229.58,175.28 229.64,175.29 229.7,175.3 229.76,175.33 229.82,175.36 229.87,175.4 229.92,175.44 229.96,175.49 229.99,175.54 230.02,175.6 230.04,175.66 230.05,175.72 230.06,175.79 230.05,175.85 230.04,175.91 230.02,175.98 229.99,176.03 229.96,176.09 229.92,176.14 229.87,176.18 229.82,176.22 229.76,176.25 229.7,176.27 229.64,176.29 229.58,176.3 229.51,176.3 229.45,176.29 229.39,176.27 229.33,176.25 229.27,176.22 229.22,176.18 229.17,176.14 229.13,176.09 229.1,176.03 229.07,175.98 229.05,175.91 229.04,175.85 229.04,175.79 223.09,175.79 223.09,176.31 223.83,177.06 229.93,177.06
VIN on TOP (solid shape): 58.15,35.28 58.15,32.81 58.12,32.79 58.12,30.5 57.94,30.32 55.23,30.32 54.51,29.61 54.51,29.08 54.18,28.75 50.37,28.75 49.87,29.26 49.87,32.56 50.36,33.05 53.71,33.05 54.31,33.65 54.31,34.22 56.8,34.22 56.8,34.15 56.81,34.08 56.83,34.02 56.85,33.95 56.88,33.89 56.92,33.84 56.97,33.79 57.02,33.74 57.07,33.71 57.13,33.67 57.19,33.65 57.26,33.63 57.33,33.63 57.39,33.63 57.46,33.63 57.53,33.65 57.59,33.67 57.65,33.71 57.7,33.74 57.75,33.79 57.8,33.84 57.84,33.89 57.87,33.95 57.89,34.02 57.91,34.08 57.92,34.15 57.92,34.22 57.91,34.28 57.89,34.35 57.87,34.41 57.84,34.47 57.8,34.53 57.75,34.58 57.7,34.62 57.65,34.66 57.59,34.69 57.53,34.72 57.46,34.73 57.39,34.74 57.33,34.74 57.26,34.73 57.19,34.72 57.13,34.69 57.07,34.66 57.02,34.62 56.97,34.58 56.92,34.53 56.88,34.47 56.85,34.41 56.83,34.35 56.81,34.28 56.8,34.22 54.31,34.22 54.31,35.33 54.57,35.58 57.84,35.58
VIN on TOP (solid shape): outline of 1085 points within 208.53,75.1 229.87,182.14
VIN on BOTTOM (solid shape): 135.29,169.62 135.29,167.58 134.91,167.2 131.5,167.2 131.43,167.28 131.43,169.59 131.55,169.72 135.18,169.72
VIN on BOTTOM (solid shape): 166,181.02 166,180.08 165.82,179.9 164.06,179.9 163.81,180.16 163.81,180.97 164.01,181.17 165.84,181.17
VIN on BOTTOM (solid shape): 219,98.67 219,96 217.26,94.25 215.31,94.25 215.07,94.5 215.07,98.72 215.32,98.98 218.7,98.98
VIN on BOTTOM (solid shape): 136.02,164.59 136.02,162.66 135.44,162.07 132.14,162.07 131.81,162.4 131.81,163.45 132.03,163.67 132.28,163.67 132.48,163.87 132.48,164.74 132.69,164.94 135.67,164.94
VIN on BOTTOM (solid shape): 183.36,80.81 183.36,74.6 183.67,74.29 183.67,68.24 183.29,67.86 176.74,67.86 176.61,67.99 176.61,80.27 176.83,80.5 178.92,80.5 179.74,81.32 182.86,81.32
VIN on BOTTOM (solid shape): 59.44,68.64 61.17,68.64 61.6,68.21 61.6,65.83 61.5,65.73 59.34,65.73 59.33,65.72 58.01,65.72 57.41,65.12 57.41,64 57.26,63.85 55.1,63.85 54.87,64.08 54.87,68.42 55.1,68.65 59.43,68.65
VIN on BOTTOM (solid shape): 218.78,82.77 218.78,76.98 217.35,75.56 214.38,75.56 213.34,74.52 213.34,69.03 213.21,68.9 213.21,67.46 212.99,67.23 207.4,67.23 207.14,67.48 207.14,82.09 207.73,82.67 212.48,82.67 213.34,83.54 218.01,83.54
VIN on BOTTOM (solid shape): 212.77,184.01 212.77,183.26 212.73,182.67 212.77,182.08 212.77,180.98 213.32,180.44 213.32,179.27 213.15,179.1 210.18,179.1 209.39,179.89 209.39,182.06 209.1,182.36 209.1,184.14 209.16,184.21 212.58,184.21
VIN on BOTTOM (solid shape): 61.21,34.46 61.22,34.46 61.5,34.18 61.95,34.18 62.21,33.92 62.21,31.97 62.13,31.9 58.1,31.9 57,30.8 55.28,30.8 54.87,31.21 54.87,34.39 56.8,34.39 56.8,33.9 57.59,33.12 58.55,33.12 58.68,33.24 58.68,34.03 57.89,34.82 57.23,34.82 56.8,34.39 54.87,34.39 54.87,35.08 55.38,35.59 60.08,35.59
VIN on BOTTOM (solid shape): 221.51,175.33 221.51,175.19 221.68,175.01 222.7,175.01 222.94,175.26 226.07,175.26 226.14,175.33 228.12,175.33 228.53,174.92 230.21,174.92 230.43,174.7 230.43,170.94 230.08,170.58 227.15,170.58 225.24,172.49 223.89,172.49 222.55,173.82 221.98,173.82 221.79,174.01 218.91,174.01 218.89,174.04 218.89,174.48 218.9,174.49 218.9,174.54 218.77,174.67 217.78,174.67 217.78,174.89 217.8,174.91 218.67,174.91 218.89,175.13 218.89,175.35 218.9,175.35 221.48,175.35
VIN on BOTTOM (solid shape): 112.78,163.62 112.78,162.76 112.97,162.57 112.99,162.57 112.99,162.19 114.61,162.19 114.61,162.2 114.9,162.49 114.9,162.57 115.04,162.71 115.04,163.33 116.52,163.33 116.52,163.34 116.97,163.34 117.14,163.18 117.14,162.98 117.15,162.96 117.15,161.61 117.14,161.6 116.91,161.6 116.9,161.59 116.87,161.59 116.74,161.46 116.44,161.46 116.31,161.59 115.47,161.59 114.89,161.01 112.43,161.01 111.99,161.45 111.99,162.06 111.56,162.48 111.56,163.7 111.72,163.85 112.55,163.85
VIN on BOTTOM (solid shape): 157.55,166.01 157.74,165.96 157.93,166.01 159.7,166.01 160.46,165.25 160.46,164.61 160.48,164.59 160.48,159.25 160.36,159.13 150.45,159.13 150.41,159.14 150.4,159.18 150.4,159.53 150.32,159.61 150.22,159.61 150.22,159.62 149.71,159.62 149.68,159.63 149.66,159.67 149.66,159.82 149.68,159.86 149.71,159.87 150.22,159.87 150.24,159.89 150.32,159.89 150.4,159.96 150.4,160.55 150.41,160.58 150.45,160.6 153.02,160.6 153.85,161.44 153.85,161.46 156.29,163.9 156.29,165.09 157.21,166.01
VIN on BOTTOM (solid shape): 54.72,82.72 54.72,81.58 55.07,81.22 55.48,81.22 55.71,81 55.71,80.33 55.66,80.28 55.12,80.28 55.02,80.18 55.02,79.45 55.3,79.17 55.63,79.17 55.71,79.09 55.71,78.53 56.27,77.97 56.27,77.95 59.6,77.95 62.1,75.45 62.11,75.45 63.08,75.45 63.41,75.12 66.06,75.12 66.08,75.1 66.08,74.62 66.2,74.5 66.38,74.5 66.38,74.48 67.18,74.48 67.18,74.23 66.38,74.23 66.38,74.21 66.23,74.21 66.09,74.07 66.09,73.8 66.07,73.78 63.46,73.78 63.46,73.79 63.46,73.97 63.3,74.12 62.26,74.12 62.03,73.89 55.99,73.89 55.91,73.81 53.14,73.81 52.46,74.49 52.46,79.6 53.93,81.07 53.93,81.99 54.21,82.27 54.21,82.77 54.22,82.81 54.26,82.82 54.62,82.82
VIN on BOTTOM (solid shape): outline of 125 points within 47.94,41.5 61.6,46.17
VIN on BOTTOM (solid shape): outline of 117 points within 137.61,158.9 154.87,171.57
VIN on SVCC (solid shape): outline of 2538 points within 49.84,24.66 230.56,186.1
1P35V_BOOT on TOP (solid shape): 45.88,61.1 45.88,60.3 45.74,60.16 45.36,60.16 44.94,59.74 44.94,59.02 44.91,58.99 44.91,58.93 44.84,58.86 44.84,57.86 44.64,57.86 44.64,58.85 44.63,58.85 44.63,59.74 44.34,60.04 44.34,60.46 44.92,61.05 44.92,61.08 45.01,61.16 45.82,61.16
1P35V_LGATE on TOP (solid shape): 48.04,57.79 48.04,57.61 47.9,57.47 45.84,57.47 45.83,57.48 45.83,57.7 45.85,57.72 46.42,57.72 46.75,58.06 47.78,58.06
1P35V_LGATE on BOTTOM (solid shape): 58.71,61.77 58.71,61.16 58.68,61.13 57.26,61.13 57.17,61.22 57.17,61.73 57.31,61.87 58.6,61.87
1P35V_PHASE on TOP (solid shape): 48.43,59.9 48.43,59.06 47.85,58.48 46.42,58.48 45.79,57.85 45.47,57.85 45.44,57.88 45.44,58.85 45.89,58.85 46.99,59.95 48.39,59.95
1P35V_PHASE on BOTTOM (solid shape): 65.94,65.08 65.94,59.89 64.52,58.47 59.49,58.47 59.29,58.67 59.29,65.15 59.34,65.2 61.6,65.2 62.1,65.69 65.33,65.69
1P35V_UGATE on TOP (solid shape): 45.73,59.73 45.73,59.34 45.31,58.93 45.3,58.93 45.23,58.86 45.23,57.89 45.2,57.86 45.06,57.86 45.06,58.96 45.08,58.99 45.08,59.62 45.29,59.83 45.63,59.83
1P35V_UGATE on BOTTOM (solid shape): 59.11,65.12 59.11,64.33 59.11,64.33 59,64.23 57.98,64.23 57.82,64.38 57.82,64.92 58.05,65.15 59.09,65.15
554LX_0.95V on BOTTOM (solid shape): 207.5,173.98 207.53,173.97 207.55,173.93 207.55,172.96 207.75,172.96 207.75,173.93 207.76,173.97 207.8,173.98 208,173.98 208.03,173.97 208.05,173.93 208.05,172.96 208.24,172.96 208.24,173.93 208.26,173.97 208.3,173.98 210.04,173.98 210.24,173.78 210.24,171.75 210.57,171.42 212.71,171.42 214.33,169.79 214.33,167.22 213.96,166.85 208.44,166.85 207.24,168.04 207.24,173.93 207.26,173.97 207.3,173.98
554SVIN_0.95V on BOTTOM (solid shape): 207.55,178.56 207.55,177.15 207.55,176.22 207.53,176.18 207.5,176.17 207.3,176.17 207.26,176.18 207.24,176.22 207.24,177.15 207.22,177.17 207.22,177.54 206.84,177.92 206.41,177.92 206.18,178.15 204.93,178.15 204.83,178.25 204.83,178.89 205.06,179.12 206.99,179.12
1658R-BOOT1 on BOTTOM (solid shape): 203.38,62.68 203.38,61.89 203.27,61.78 202.69,61.78 201.96,61.06 201.96,60.89 201.95,60.86 201.91,60.84 201,60.84 200.96,60.86 200.95,60.89 200.95,61.11 202.57,62.73 203.33,62.73
1658R-BOOT2 on BOTTOM (solid shape): 198.76,61.13 198.76,60.85 198.75,60.84 197.8,60.84 197.76,60.86 197.75,60.89 197.75,61.26 197.2,61.81 196.36,61.81 196.25,61.92 196.25,62.73 196.27,62.76 197.14,62.76
1658R-LGATE1 on BOTTOM (solid shape): 197.82,79.24 197.82,77.9 197.77,77.85 196.73,77.85 196.65,77.92 196.65,79.27 196.91,79.52 197.54,79.52
1658R-LGATE1 on BOTTOM (solid shape): 197.86,73.1 197.86,71.72 197.81,71.67 196.77,71.67 196.72,71.72 196.72,73.12 197,73.4 197.55,73.4
1658R-LGATE2 on BOTTOM (solid shape): 192.87,76.03 192.87,74.73 192.56,74.43 191.98,74.43 191.7,74.71 191.7,76 191.78,76.08 192.82,76.08
1658R-LGATE2 on BOTTOM (solid shape): 192.82,69.88 192.82,68.51 192.2,67.89 191.19,67.89 191.14,67.94 191.14,68.4 191.42,68.68 191.42,69.62 191.43,69.63 191.43,69.81 191.56,69.93 192.77,69.93
1658R-LGATE2 on BOTTOM (solid shape): 199.55,63.16 199.55,61.26 199.52,61.23 199.4,61.23 199.37,61.25 199.35,61.28 199.35,62.24 199.35,62.24 199.35,62.4 198.89,62.86 198.89,63.24 199.04,63.39 199.32,63.39
1658R-PHASE1 on BOTTOM (solid shape): 202.62,64.1 202.62,63.06 200.82,61.26 200.6,61.26 200.57,61.27 200.55,61.31 200.55,62.24 201.43,63.11 201.43,64.05 201.53,64.15 202.57,64.15
1658R-PHASE1 on BOTTOM (solid shape): 203.31,85.14 204.43,85.14 204.86,84.7 204.86,78.73 205.29,78.3 206.28,78.3 206.41,78.18 206.41,74.26 206.15,74.01 205.19,74.01 204.81,73.63 204.81,72.16 205.34,71.62 206.36,71.62 206.46,71.52 206.46,67.33 206.3,67.18 198.71,67.18 198.43,67.46 198.43,79.52 198.05,79.9 194.39,79.9 193.17,81.12 193.17,84.93 193.4,85.16 203.28,85.16
1658R-PHASE2 on BOTTOM (solid shape): 198.23,64 198.23,63.19 199.15,62.26 199.15,61.28 199.14,61.25 199.1,61.23 198.94,61.23 197.03,63.14 197.03,64.13 197.08,64.18 198.05,64.18
1658R-PHASE2 on BOTTOM (solid shape): 191.62,84.88 191.62,80.84 190.91,80.13 190.91,68.9 190.28,68.27 187.18,68.27 185.1,70.35 183.98,70.35 183.95,70.38 183.95,73.58 184.03,73.65 185.28,73.65 185.59,73.96 185.59,76.44 185.44,76.59 183.96,76.59 183.85,76.7 183.85,84.57 184.52,85.24 191.27,85.24
1658R-PVCC on BOTTOM (solid shape): 201.59,64.7 201.59,64.51 200.7,63.62 200.15,63.62 200.13,63.62 200.12,63.61 199.97,63.46 199.96,63.44 199.95,63.42 199.95,62.24 199.95,62.24 199.95,61.26 199.75,61.26 199.75,62.25 199.73,62.28 199.73,63.35 199.72,63.37 199.71,63.38 199.46,63.63 199.45,63.64 199.43,63.65 198.96,63.65 198.89,63.72 198.89,64.26 198.96,64.33 199.5,64.33 199.52,64.34 199.54,64.35 199.87,64.68 200.95,64.68 201.08,64.82 201.47,64.82
1658R-UGATE1 on BOTTOM (solid shape): 206.33,73.45 206.33,72.08 206.28,72.03 205.26,72.03 205.21,72.08 205.21,73.5 205.42,73.71 206.08,73.71
1658R-UGATE1 on BOTTOM (solid shape): 206.39,80.16 206.39,78.84 206.32,78.76 205.33,78.76 205.25,78.84 205.25,80.16 205.48,80.39 206.17,80.39
1658R-UGATE1 on BOTTOM (solid shape): 202.95,61.01 202.95,60.47 202.9,60.42 201.97,60.42 201.95,60.44 201,60.44 200.96,60.46 200.95,60.49 200.95,60.62 200.96,60.64 201.95,60.64 201.95,60.65 202.01,60.65 202.49,61.13 202.83,61.13
1658R-UGATE2 on BOTTOM (solid shape): 185.3,76.07 185.3,74.64 185.07,74.41 184.36,74.41 184.13,74.64 184.13,76.07 184.18,76.12 185.24,76.12
1658R-UGATE2 on BOTTOM (solid shape): 185.42,69.5 185.42,68.23 185.27,68.08 184.33,68.08 183.94,68.46 183.94,69.83 184,69.88 185.04,69.88
1658R-UGATE2 on BOTTOM (solid shape): 197.59,60.88 197.59,60.75 197.69,60.65 197.76,60.65 197.76,60.64 198.74,60.64 198.76,60.62 198.76,60.49 198.75,60.46 198.71,60.44 197.76,60.44 197.74,60.42 197.59,60.42 197.58,60.41 196.86,60.41 196.76,60.5 196.76,60.99 196.93,61.16 197.31,61.16
24780_BST on TOP (solid shape): 161.56,182.19 161.57,182.17 161.58,182.15 161.58,181.51 161.46,181.39 161.45,181.38 161.43,181.38 160.57,181.38 160.43,181.51 160.41,181.52 160.37,181.52 160.37,181.53 159.33,181.53 159.25,181.59 159.24,181.6 159.22,181.6 159.12,181.6 159.12,181.61 158.37,181.61 158.34,181.62 158.32,181.66 158.32,181.72 158.38,181.79 158.4,181.8 158.42,181.81 159.12,181.81 159.12,181.81 160.36,181.81 160.38,181.81 160.4,181.82 160.65,182.07 160.66,182.09 160.66,182.11 160.66,182.19 160.66,182.21 160.68,182.23 160.75,182.3 160.76,182.31 160.78,182.32 161.42,182.32
24780_DH on TOP (solid shape): 168.36,184.86 168.36,184.12 168.23,183.99 166.86,183.99 166.76,184.09 166.76,184.88 166.81,184.93 168.28,184.93
24780_DH on TOP (solid shape): 160.33,182.44 160.33,182.06 160.23,181.96 159.49,181.96 159.44,182.01 158.35,182.01 158.32,182.04 158.32,182.16 158.34,182.19 158.38,182.21 159.13,182.21 159.16,182.24 159.49,182.24 159.8,182.54 160.23,182.54
24780_DL on TOP (solid shape): 169.27,179.52 169.27,178.2 169.07,178 168.66,178 168.51,178.15 168.51,179.55 168.54,179.57 169.22,179.57
24780_DL on TOP (solid shape): 158.42,181.01 159.12,181.01 159.12,181.02 159.98,181.02 160.2,180.79 160.2,180.46 160.1,180.36 159.72,180.36 159.29,180.79 159.12,180.79 159.12,180.81 158.39,180.81 158.32,180.87 158.32,180.97 158.38,181.02 158.42,181.02
24780_LX on TOP (solid shape): 171.43,183.76 171.43,182.36 176.49,182.36 176.56,182.29 176.56,179.52 176.56,179.52 176.56,179.45 176.33,179.22 171.76,179.22 171.13,178.58 169.68,178.58 169.42,178.84 169.42,181.55 168.92,182.06 166.83,182.06 166.78,182.11 166.78,183.74 166.81,183.76 169.61,183.76 170.01,184.16 171.03,184.16
24780_LX on TOP (solid shape): 161.65,183.61 161.65,182.82 161.6,182.77 159.82,182.77 159.47,182.42 158.38,182.42 158.34,182.43 158.32,182.47 158.32,182.54 158.39,182.61 159.12,182.61 159.12,182.62 159.19,182.62 159.25,182.68 159.25,182.68 159.47,182.9 159.47,182.95 159.48,182.96 159.48,183.45 159.7,183.66 161.6,183.66
24780_LX on BOTTOM (solid shape): 168.94,184.14 168.97,184.14 168.99,184.12 169.32,183.92 169.66,184.12 169.68,184.14 169.7,184.14 175.05,184.14 176.51,182.68 176.51,180.23 176.23,179.95 169.98,179.95 167.93,182.01 167.93,183.56 168.51,184.14
25810_CC1 on TOP (solid shape): 30.19,110.63 30.19,110.2 30.4,109.99 30.93,109.99 30.98,109.94 30.98,109.8 30.97,109.77 30.93,109.75 30.36,109.75 30.33,109.72 30.25,109.72 29.89,110.08 29.89,110.66 29.92,110.69 30.13,110.69
25810_CC2 on TOP (solid shape): 29.55,109.39 29.54,109.39 29.54,109.15 29.71,108.98 30.33,108.98 30.36,108.96 30.96,108.96 30.97,108.94 30.97,108.8 30.96,108.77 30.92,108.75 30.36,108.75 30.33,108.73 29.64,108.73 29.27,109.11 29.27,109.36 29.28,109.4 29.29,109.45 29.31,109.48 29.34,109.49 29.44,109.49
51225_DH1 on TOP (solid shape): 51.66,37.64 51.69,37.62 51.71,37.59 51.71,36.84 51.72,36.84 51.72,36.65 51.11,36.04 50.96,36.04 50.76,36.24 50.76,36.49 51.42,37.15 51.42,37.56 51.49,37.64
51225_DH1 on BOTTOM (solid shape): 58.5,33.88 58.5,33.32 58.45,33.27 57.74,33.27 56.98,34.03 56.98,34.26 57.33,34.61 57.77,34.61
51225_DH2 on BOTTOM (solid shape): 63.02,42.77 63.02,41.63 62.72,41.32 62.29,41.32 62.24,41.37 62.24,42.77 62.25,42.8 62.29,42.82 62.97,42.82
51225_DL1 on TOP (solid shape): 50.51,38.03 51.26,38.03 51.3,38.02 51.31,37.98 51.31,37.87 51.3,37.83 51.26,37.82 51.21,37.82 51.21,37.8 50.2,36.79 50.06,36.79 49.87,36.98 49.87,37.46 50.45,38.04 50.51,38.04
51225_DL1 on BOTTOM (solid shape): 58.5,28.24 58.5,27.4 57.84,26.74 57.56,26.74 57.31,26.99 57.31,27.55 57.77,28.01 57.77,28.26 58.48,28.26
51225_DL2 on BOTTOM (solid shape): 60.08,50.01 60.08,49.17 60.03,49.12 59.01,49.12 58.45,49.68 58.45,50.06 58.55,50.16 59.92,50.16
51225_SW1 on TOP (solid shape): 52.46,37.64 52.49,37.62 52.51,37.59 52.51,36.82 52.59,36.74 52.59,36.72 52.61,36.72 52.63,36.7 52.63,33.85 52.2,33.42 51.42,33.42 51.36,33.47 51.36,34.28 51.47,34.39 51.7,34.39 51.99,34.68 51.99,35.47 52.3,35.78 52.3,36.84 52.31,36.84 52.31,37.59 52.32,37.62 52.36,37.64
51225_SW1 on BOTTOM (solid shape): 68.21,34.67 68.21,27.78 67.72,27.3 65.28,27.3 65.2,27.21 64.03,27.21 62.2,29.04 58.08,29.04 57.94,29.18 57.94,31.26 58.15,31.47 62.11,31.47 62.77,32.13 62.77,34.61 63.59,35.44 67.43,35.44
51225_SW2 on TOP (solid shape): 52.79,43.94 52.79,42.16 52.51,41.88 52.51,40.62 52.51,39.9 52.49,39.86 52.46,39.85 52.36,39.85 52.32,39.86 52.31,39.9 52.31,40.62 52.3,40.69 52.23,40.76 52.23,42.84 52,43.07 51.82,43.07 51.72,43.17 51.72,43.99 51.77,44.04 52.69,44.04
51225_SW2 on BOTTOM (solid shape): 67.04,50.08 67.04,42.58 66.76,42.3 63.91,42.3 63.19,43.02 62.24,43.02 62.19,43.07 62.19,45.31 61.04,46.45 60.69,46.45 60.59,46.55 60.59,50.03 60.94,50.39 66.73,50.39
51225_VBST1 on TOP (solid shape): 52.06,37.64 52.09,37.62 52.11,37.59 52.11,36.84 52.13,36.82 52.13,35.94 51.63,35.44 51.63,34.75 51.52,34.64 50.7,34.64 50.65,34.69 50.65,35.5 50.73,35.58 51.09,35.58 51.9,36.39 51.9,36.84 51.9,36.84 51.9,37.59 51.92,37.62 51.96,37.64
51225_VBST2 on TOP (solid shape): 52.1,42.49 52.1,39.85 52.08,39.82 51.96,39.82 51.92,39.84 51.9,39.87 51.9,40.62 51.9,40.62 51.9,40.69 51.82,40.76 51.82,41.55 51.67,41.7 51.03,41.7 50.96,41.78 50.96,42.56 51.03,42.64 51.95,42.64
+AZA_VDD on BOTTOM (solid shape): 201.15,40.37 201.15,38.51 201.16,38.45 201.17,38.38 201.17,37.18 202.29,36.06 202.29,35.07 202.24,35.02 201.73,35.02 200.92,35.83 200.86,35.9 200.79,35.96 200.36,36.39 200.36,40.36 200.4,40.4 201.13,40.4
+TPVDD on TOP (solid shape): 137.32,12.39 137.32,11.86 136.89,11.45 136.52,10.99 135.16,10.99 135.03,11.12 135.03,11.4 136.18,12.54 137.16,12.54
+TPVDD on BOTTOM (solid shape): 119.23,15.4 122.02,12.61 129.06,12.61 129.32,12.87 129.32,14.23 129.58,14.49 130.86,14.49 131.5,13.86 133.91,13.86 134.04,13.99 134.51,13.99 134.57,13.99 134.81,13.99 135.06,13.74 135.06,13.1 135.55,12.61 135.55,11.09 135.45,10.99 135.16,10.99 135.01,11.15 135.01,12.02 134.69,12.33 131.88,12.33 131.63,12.08 131.06,12.08 130.99,12.01 130.08,12.01 129.87,11.8 129.87,11.18 129.8,11.11 119.52,11.11 117.96,12.67 117.96,16.82 118.21,17.07 119.23,17.07
+TYPEC_VBUS on TOP (solid shape): 21.38,112.42 21.38,110.92 21.17,110.71 19.73,110.71 19.68,110.66 18.95,110.66 18.78,110.48 17.28,110.48 16.14,111.63 15.78,111.63 15.68,111.73 15.27,111.73 15.12,111.88 15.12,112.34 15.26,112.48 17.49,112.48 17.56,112.41 17.63,112.41 19.95,112.41 20.11,112.57 21.23,112.57
+TYPEC_VBUS on TOP (solid shape): 8.71,117.42 10.51,117.42 10.62,117.31 10.62,113.96 10.57,113.91 9.3,113.91 8.85,114.37 8.85,115.16 6.85,117.15 7.86,117.15 7.87,117.1 7.88,117.04 7.9,116.99 7.93,116.94 7.96,116.9 8,116.86 8.05,116.83 8.1,116.8 8.15,116.78 8.2,116.77 8.26,116.77 8.32,116.78 8.37,116.79 8.42,116.81 8.47,116.84 8.51,116.88 8.55,116.92 8.58,116.97 8.6,117.02 8.62,117.07 8.63,117.13 8.63,117.18 8.62,117.24 8.6,117.29 8.58,117.34 8.55,117.39 8.51,117.43 8.47,117.46 8.42,117.49 8.37,117.52 8.32,117.53 8.26,117.54 8.2,117.53 8.15,117.52 8.1,117.51 8.05,117.48 8,117.45 7.96,117.41 7.93,117.36 7.9,117.32 7.88,117.26 7.87,117.21 7.86,117.15 6.85,117.15 6.6,117.41 6.49,117.41 5.77,118.13 5.77,118.71 5.9,118.84 6.2,118.84 6.21,118.84 6.61,118.84 6.65,118.85 7.27,118.85
+TYPEC_VBUS on BOTTOM (solid shape): 10.75,116.99 10.75,115.13 10.6,114.98 8.95,114.98 8.79,115.13 8.79,117.01 8.81,117.04 8.85,117.06 10.68,117.06
+TYPEC_VBUS on BOTTOM (solid shape): 6.64,118.79 9.63,118.79 9.64,118.79 10.19,118.79 10.19,118.79 10.27,118.71 10.27,118.05 10.22,118 9.07,118 8.93,118.14 8.55,118.14 8.18,118.51 6.51,118.51 6.25,118.26 5.87,118.26 5.75,118.38 5.75,118.69 5.92,118.87 6.56,118.87
+TYPEC_VBUS on BOTTOM (solid shape): 6.51,121.36 6.53,121.36 6.61,121.28 7.88,121.28 7.96,121.36 8.28,121.36 8.31,121.36 8.33,121.37 8.73,121.37 8.74,121.36 10.19,121.36 10.29,121.26 10.29,120.26 10.22,120.19 9.51,120.19 9.45,120.24 9.45,120.87 9.42,120.91 9.42,120.92 9.17,121.12 8.86,121.06 8.84,121.05 8.79,121.05 8.74,121 7.81,121 7.81,121 6.72,121 6.72,121 6.65,121 6.64,120.99 6.25,120.99 6.23,120.97 5.9,120.97 5.77,121.1 5.77,121.51 5.8,121.53 6.33,121.53
+TYPEC_VBUS on IN1 (solid shape): outline of 1191 points within 5.67,110.51 19.01,121.97
+TYPEC_VBUS_C on TOP (solid shape): 26.97,110.99 26.97,110.98 27.46,110.49 27.46,109.48 27.59,109.35 27.59,109.31 27.63,109.31 27.91,109.03 29.16,109.03 29.17,109.02 29.2,108.96 29.24,108.91 29.47,108.68 29.52,108.64 29.58,108.61 29.72,108.48 30.34,108.48 30.36,108.46 30.92,108.46 30.96,108.44 30.97,108.41 30.97,108.3 30.96,108.27 30.92,108.25 30.36,108.25 30.36,107.96 30.92,107.96 30.96,107.94 30.97,107.91 30.97,107.8 30.96,107.77 30.92,107.75 30.36,107.75 30.36,107.75 30.02,107.75 29.14,106.86 25.57,106.86 24.95,107.49 24.95,108.86 24.82,108.98 24.82,109.11 24.69,109.11 23.95,109.86 22.01,109.86 21.78,110.09 21.78,113.36 22.28,113.86 24.09,113.86
+VGPU_CORE on TOP (solid shape): 178.57,132.71 178.57,132.28 178.09,131.8 177.53,131.8 177.45,131.87 177.45,132.33 177.96,132.84 178.44,132.84
+VGPU_CORE on TOP (solid shape): 205.72,102.28 205.72,101.7 205.48,101.45 204.53,101.45 204.32,101.66 204.32,102.23 204.67,102.57 205.43,102.57
+VGPU_CORE on TOP (solid shape): 178.8,130.47 178.8,129.99 178.47,129.66 178.47,129.33 178.31,129.18 177.96,129.18 177.83,129.31 177.83,130.19 178.21,130.58 178.7,130.58
+VGPU_CORE on TOP (solid shape): 182.61,135.81 182.61,135.15 182.56,135.1 181.79,135.1 181.64,135.25 181.16,135.25 181.06,135.35 181.06,135.68 181.29,135.91 182.51,135.91
+VGPU_CORE on TOP (solid shape): 184.08,134.03 184.64,134.03 184.74,133.93 184.74,133.57 184.66,133.5 183.8,133.5 182.86,134.44 182.86,134.61 183.06,134.82 183.29,134.82
+VGPU_CORE on TOP (solid shape): 185.53,136.67 185.53,136.19 185.43,136.09 185.1,136.09 184.79,136.39 184.03,136.39 183.95,136.47 183.95,137.23 184.03,137.31 184.89,137.31
+VGPU_CORE on TOP (solid shape): 187.79,133.83 187.79,132.86 187.47,132.55 187.46,132.53 187.42,132.48 187.37,132.44 187.36,132.43 187.33,132.4 187.08,132.4 186.95,132.53 186.95,133.93 187,133.98 187.64,133.98
+VGPU_CORE on TOP (solid shape): 181.71,133.46 181.92,133.46 182.45,132.94 182.45,132.15 182.29,132 180.99,132 180.69,131.69 180.69,130.88 180.66,130.86 179.75,130.86 179.72,130.88 179.72,132.69 180.06,133.02 180.51,133.02 180.97,133.47 181.71,133.47
+VGPU_CORE on TOP (solid shape): 193.81,100.78 193.81,99.77 196.58,97 200.69,97 204.12,100.43 205.47,100.43 206.53,99.36 206.53,89.28 205.54,88.28 186.62,88.28 185.35,89.55 185.35,93.49 184.59,94.25 184.59,95.14 184.65,95.21 184.65,97.87 188.02,101.24 193.35,101.24
+VGPU_CORE on TOP (solid shape): 187.51,136.47 187.51,136.43 187.55,136.43 187.64,136.34 188.24,136.34 188.26,136.32 188.29,136.32 188.42,136.19 188.42,135.35 188.3,135.22 185.88,135.22 185.73,135.38 185.73,136.14 185.73,136.14 185.73,136.26 185.85,136.38 186.76,136.38 187.03,136.65 187.33,136.65
+VGPU_CORE on TOP (solid shape): 181.6,130.58 183.32,130.58 183.5,130.4 183.5,129.27 183.35,129.12 181.98,129.12 181.49,129.61 181.45,129.61 181.2,129.7 180.95,129.61 180.37,129.61 180.3,129.69 180.3,130.09 181.01,130.8 181.38,130.8
+VGPU_CORE on TOP (solid shape): 180.4,136.65 180.4,136.32 179.99,135.91 179.94,135.87 179.88,135.8 179.83,135.62 179.86,135.44 179.86,135.43 179.86,135.07 180.09,134.84 180.42,134.84 180.57,134.69 180.57,134.11 180.45,133.98 178.67,133.98 178.59,134.06 178.59,136.06 178.67,136.14 179,136.14 179.01,136.13 179.34,136.16 179.53,136.42 179.53,136.44 179.86,136.77 180.27,136.77
+VGPU_CORE on TOP (solid shape): outline of 104 points within 184.04,126.28 186.98,133.78
+VGPU_CORE on TOP (solid shape): outline of 469 points within 173.28,109.67 183.21,127.34
+VGPU_CORE on BOTTOM (solid shape): 190.89,102.08 205.92,102.08 206.48,101.52 207.55,101.52 207.55,92.96 207.07,92.48 207.07,86.76 206.25,85.95 183.34,85.95 183.34,85.92 182.05,84.63 182.05,83.61 181.77,83.33 180.6,83.33 180.55,83.38 180.55,83.69 180.65,83.79 180.85,83.79 181.46,84.4 181.46,84.75 182.43,85.72 182.43,89.33 184.46,91.36 184.46,97.66 185.73,98.93 185.73,100.76 185.76,100.78 185.76,101.87 186.49,102.61 190.35,102.61
+VGPU_CORE on BOTTOM (solid shape): outline of 4925 points within 174.33,114.55 188.93,139.28
+VGPU_CORE on SVCC (solid shape): outline of 473 points within 153.6,89.68 205.8,140.1
+VGPU_CORE on IN1 (solid shape): outline of 6625 points within 174.92,89.43 205.58,138.31
+VGPU_CORE on IN2 (solid shape): outline of 2000 points within 174.07,113.86 187.91,137.7
+WL_VDD on BOTTOM (solid shape): 201.48,192.42 201.48,188.13 201.38,188.03 200.44,188.03 200.34,188.13 200.34,190.39 199.57,191.15 197.8,191.15 197.67,191.28 197.67,191.4 199.35,191.4 199.35,191.6 197.8,191.6 197.8,191.4 197.67,191.4 197.67,192.17 197.8,192.3 199.32,192.3 199.7,192.68 201.22,192.68
+WL_VDD on BOTTOM (solid shape): 197.5,175.18 197.62,175.06 197.62,174.46 197.69,174.39 199.93,174.39 199.97,174.38 200.19,174.15 200.17,173.9 200.12,173.85 200.09,173.79 200.06,173.73 200.03,173.66 200.02,173.6 200.01,173.53 200,173.46 199.99,173.43 199.97,173.41 199.95,173.4 199.91,173.39 198.16,173.39 197.97,173.25 197.45,173.25 197.43,173.26 197.38,173.32 197.33,173.41 197.27,173.5 197.21,173.57 197.14,173.65 197.06,173.71 196.98,173.77 196.91,173.82 196.91,174.06 197.77,174.06 197.77,173.91 197.8,173.91 197.8,173.9 199.35,173.9 199.35,173.91 199.37,173.91 199.36,174.09 199.35,174.1 199.32,174.11 197.82,174.11 197.79,174.1 197.78,174.09 197.77,174.06 196.91,174.06 196.91,175.03 197.05,175.18
ADOGND on BOTTOM (solid shape): 209.18,28.65 209.18,24.18 209.54,23.81 209.54,23.11 209.43,23.01 208.97,23.01 208.89,23.08 208.89,23.5 208.71,23.69 207.41,23.69 206.91,24.19 206.91,27.4 207.03,27.51 207.04,27.52 207.08,27.53 207.42,27.53 207.52,27.43 207.52,27.02 207.78,26.77 208.44,26.77 208.64,26.97 208.64,28.7 208.72,28.77 209.05,28.77
ADOGND on SVCC (solid shape): outline of 121 points within 198.41,9.9 212.12,36.04
ADOGND on SGND (solid shape): outline of 116 points within 198.41,9.9 212.12,36.04
BAT-V on BOTTOM (solid shape): 167.95,175.97 167.95,171.72 167.85,171.62 159.57,171.62 158.64,172.55 158.28,172.55 158.02,172.81 158.02,174.3 158.03,174.33 158.21,174.48 158.27,174.68 158.27,174.7 159.67,176.09 159.72,176.09 159.9,176.27 167.65,176.27
CCD_PWR on TOP (solid shape): 118.06,169.44 118.06,168.43 117.88,168.24 116.39,168.24 116.22,168.08 116.22,167.6 116.21,167.56 116.17,167.55 115.16,167.55 115.02,167.41 114.82,167.41 114.73,167.51 114.73,168.39 114.85,168.51 116.03,168.51 116.16,168.64 116.16,168.72 116.39,168.95 116.39,169.29 116.72,169.62 117.88,169.62
CCD_PWR on BOTTOM (solid shape): 119.44,168.52 119.44,168.5 118.9,167.96 118.85,167.96 118.01,168.8 116.54,168.8 116.44,168.9 116.44,169.34 116.72,169.62 118.34,169.62
CRTVDD5 on TOP (solid shape): 13.33,84.49 13.33,83.82 13.2,83.69 10.75,83.69 10.52,83.46 10.52,83.45 10.37,83.3 9.99,83.3 9.86,83.42 9.86,84.42 10.01,84.57 13.24,84.57
CRTVDD5 on TOP (solid shape): 9.07,80.69 9.11,80.69 11.11,80.69 11.14,80.68 11.16,80.64 11.16,80.47 11.14,80.44 11.11,80.42 9.38,80.42 8.85,79.89 6.73,79.89 6.65,79.98 6.65,80.64 6.67,80.68 6.7,80.69 9.03,80.69
CRTVDD5 on BOTTOM (solid shape): outline of 94 points within 5.43,76.37 14.1,84.56
DDR_VTTREF on TOP (solid shape): 41.69,59.25 43.68,59.25 44.05,58.88 44.05,58.85 44.04,58.85 44.04,57.9 44,57.86 43.68,57.86 43.61,57.93 43.61,58.32 43.44,58.49 42.87,58.49 42.46,58.07 42.46,57.46 42.64,57.28 42.65,57.26 43.64,57.26 43.64,57.07 43.62,57.06 42.65,57.06 42.65,57.05 42.3,57.05 42.2,57.23 42.02,57.33 41.26,58.08 41.26,59.18 41.34,59.26 41.68,59.26
DDR_VTTREF on TOP (solid shape): outline of 263 points within 144.43,39.64 149.41,56.31
DDR_VTTREF on BOTTOM (solid shape): 149.01,44 149.08,43.96 149.1,43.9 149.1,42.32 149.1,42.32 149.1,42.06 149.26,41.9 149.26,41.57 149.18,41.5 148.8,41.5 148.72,41.57 148.72,42.01 148.82,42.11 148.82,42.3 148.85,42.32 148.85,43.95 148.86,43.98 148.9,44
DDR_VTTREF on IN1 (solid shape): 42.54,58.82 42.54,57.61 42.46,57.53 41.61,57.53 41.51,57.63 41.51,58.86 41.59,58.94 42.42,58.94
DDR_VTTREF on IN1 (solid shape): 148.24,45.66 148.24,44.62 145.95,42.34 144.46,42.34 144.18,42.62 144.18,43.53 144.43,43.78 145.68,43.78 145.74,43.85 145.76,43.85 145.97,43.92 146.14,44.05 147.08,44.98 147.1,44.99 147.56,45.21 147.75,45.69 147.77,45.72 147.8,45.74 148.16,45.74
EC_GND on TOP (solid shape): outline of 140 points within 163.79,27.05 189.01,38.98
ECAGND on TOP (solid shape): 170.9,33.27 170.9,29.05 170.11,28.26 167.34,28.26 167.11,28.49 167.11,29.1 167.27,29.26 168.31,29.26 168.94,29.89 168.94,29.95 169.75,29.95 169.76,29.9 169.77,29.84 169.8,29.79 169.82,29.74 169.86,29.7 169.9,29.66 169.95,29.63 170,29.61 170.05,29.59 170.11,29.59 170.16,29.59 170.22,29.59 170.27,29.61 170.32,29.63 170.37,29.66 170.41,29.7 170.45,29.74 170.48,29.79 170.5,29.84 170.51,29.9 170.52,29.95 170.52,30.01 170.51,30.06 170.49,30.12 170.46,30.17 170.43,30.21 170.39,30.25 170.35,30.29 170.3,30.31 170.25,30.33 170.19,30.34 170.14,30.35 170.08,30.34 170.03,30.33 169.97,30.31 169.92,30.29 169.88,30.25 169.84,30.21 169.81,30.17 169.78,30.12 169.77,30.06 169.76,30.01 169.75,29.95 168.94,29.95 168.94,32.18 170.26,33.5 170.67,33.5
ECAGND on BOTTOM (solid shape): 168.79,28.72 168.79,27.55 168.64,27.4 166.76,27.4 166.63,27.53 166.63,28.34 167.24,28.95 167.32,29.03 167.49,29.03 168.48,29.03
EVDD10 on TOP (solid shape): 32.09,73.22 32.09,72.46 32.38,72.17 35.31,72.17 35.31,72.16 35.31,71.98 35.26,71.98 33.42,71.98 32.82,71.38 30.93,71.38 30.81,71.5 30.81,72.67 31.04,72.9 31.04,73.22 31.1,73.27 32.04,73.27
FB_PLL_AVDD on TOP (solid shape): 182.54,140.21 182.54,139.84 182.53,139.84 182.53,139.8 182.38,139.64 182.38,139.12 182.34,139.05 182.26,139.02 181.82,138.65 182.26,138.27 182.34,138.25 182.38,138.17 182.38,137.79 182.28,137.69 181.67,137.69 181.49,137.51 181.49,137.05 181.41,136.98 180.93,136.98 180.86,137.05 180.86,139.58 180.97,139.69 181.2,139.69 181.21,139.69 181.62,139.69 181.84,140.04 181.84,140.06 182.07,140.3 182.45,140.3
G5335-BST on BOTTOM (solid shape): 217.76,173.93 217.79,173.91 218.55,173.91 218.58,173.88 218.58,173.71 218.54,173.67 217.79,173.67 217.78,173.66 217.26,173.66 216.57,172.97 215.73,172.97 215.67,173.02 215.67,173.84 215.77,173.94 217.75,173.94
G5335-BST-1 on BOTTOM (solid shape): 69.46,75.87 69.46,75.07 69.41,75.02 67.82,75.02 67.66,75.18 67.16,75.18 67.16,75.23 66.38,75.23 66.38,75.46 67.68,75.46 68.15,75.93 69.4,75.93
G5335-LX on BOTTOM (solid shape): 221.79,173.41 222.73,173.41 222.79,173.35 222.79,172.79 222.69,172.69 221.67,172.69 221.65,172.7 219.79,172.7 219.78,172.7 219.66,172.7 219.55,172.59 219.55,171.62 219.59,171.58 219.59,170.79 221.1,169.29 222.02,169.29 222.28,169.02 222.28,167 221.97,166.69 215.4,166.69 215.22,166.87 215.22,170.78 215.65,171.21 215.65,171.62 219.32,171.62 219.32,172.45 219.06,172.45 219.06,171.62 215.65,171.62 215.65,172.3 215.72,172.37 216.58,172.37 216.58,172.37 217.22,172.37 217.75,172.9 218.76,172.9 218.81,172.95 218.81,172.96 218.88,173.03 218.88,173.16 221.76,173.16 221.76,172.92 221.77,172.9 222.59,172.9 222.61,172.93 222.61,173.15 222.59,173.17 221.77,173.17 221.76,173.16 218.88,173.16 218.88,173.65 218.99,173.77 221.44,173.77
G5335-LX-1 on BOTTOM (solid shape): 66.2,85.23 66.2,81.71 67.65,80.26 67.65,78.56 67.66,78.54 67.66,77.5 67.36,77.2 67.36,76.37 67.22,76.23 66.38,76.23 66.38,76.19 66.31,76.19 66.06,75.93 66.06,75.49 66.05,75.48 63.41,75.48 63.16,75.73 62.19,75.73 61.94,75.98 62.39,75.98 63.13,75.98 63.13,75.98 63.16,75.98 63.16,76.23 62.38,76.23 62.38,75.98 61.94,75.98 59.49,78.43 59.49,80.08 61.14,80.08 61.14,78.66 62.82,76.98 62.82,76.93 63.28,76.47 65.26,76.47 65.4,76.62 65.4,77.5 65.64,77.5 65.64,76.71 65.64,76.71 65.89,76.71 65.9,76.71 65.9,77.5 65.88,77.52 65.65,77.52 65.64,77.5 65.4,77.5 65.4,78.36 63.33,80.44 61.5,80.44 61.14,80.08 59.49,80.08 59.49,84.89 60.02,85.42 66.01,85.42
G5335-VCC on BOTTOM (solid shape): 216.71,175.22 217.52,174.4 218.57,174.4 218.58,174.39 218.58,174.2 218.55,174.16 216.95,174.16 216.85,174.26 215.77,174.26 215.64,174.4 215.64,175.18 215.69,175.23 216.71,175.23
G5335-VCC-1 on BOTTOM (solid shape): 67.8,74.73 69.29,74.73 69.6,74.42 69.6,73.57 69.54,73.51 68.54,73.51 67.33,74.72 67.16,74.72 67.16,74.73 66.38,74.73 66.38,74.98 67.16,74.98 67.55,74.98
G5719LX2.5V on BOTTOM (solid shape): 167.47,48.18 167.47,45.65 167.34,45.53 167.16,45.53 166.96,45.59 166.76,45.53 166.18,45.53 166,45.71 164.47,45.71 164.31,45.88 164.29,45.91 164.27,45.94 164.27,48.3 164.37,48.41 167.24,48.41
HDMI_5V on TOP (solid shape): 18.37,57.47 18.37,56.41 17.25,55.29 16.16,55.29 14.97,54.1 11.33,54.1 11.11,54.33 11.11,54.73 11.49,55.11 13.16,55.11 14.46,56.41 16.14,56.41 16.77,57.04 16.77,57.47 16.92,57.63 18.22,57.63
L_SPK+ on TOP (solid shape): 73.46,17.37 73.46,15.39 73.37,15.29 72.49,15.29 72.42,15.36 72.42,16.68 72.7,16.96 72.7,17.44 72.78,17.52 73.31,17.52
L_SPK+ on BOTTOM (solid shape): 200.8,32.31 201.73,32.31 201.77,32.29 201.78,32.26 201.78,32.1 200.8,32.1 200.78,32.08 200.26,32.08 200.03,31.85 200.03,31.7 199.73,31.39 198.84,31.39 198.74,31.49 198.74,31.95 198.81,32.03 199.9,32.03 200.21,32.33 200.78,32.33
L_SPK+ on IN2 (solid shape): 73.46,17.42 73.46,14.96 73.36,14.85 72.83,14.85 72.65,15.03 72.65,17.31 72.86,17.52 73.36,17.52
L_SPK+ on IN2 (solid shape): 199.98,31.87 199.98,31.54 199.4,30.96 197.8,30.96 197.64,31.11 197.64,31.59 198.08,32.02 199.83,32.02
L_SPK+_1 on BOTTOM (solid shape): 73.49,13.74 73.49,12.11 74.66,10.94 77.96,10.94 78.03,10.91 78.06,10.85 78.25,10.53 78.62,10.53 80.5,10.53 80.68,10.35 80.68,9.54 80.53,9.39 77.63,9.39 77.1,9.93 74.42,9.93 74.26,9.98 74.09,9.95 74.06,9.95 74.03,9.96 72.35,11.65 72.35,13.74 72.47,13.86 73.36,13.86
L_SPK- on TOP (solid shape): 74.73,17.42 74.73,15.41 74.62,15.29 73.73,15.29 73.69,15.34 73.69,17.34 73.84,17.5 74.66,17.5
L_SPK- on BOTTOM (solid shape): 200.01,32.71 200.8,32.71 200.8,32.71 201.77,32.71 201.78,32.69 201.78,32.54 201.76,32.51 200.21,32.51 199.9,32.21 198.84,32.21 198.76,32.28 198.76,32.71 198.84,32.79 199.93,32.79
L_SPK- on IN2 (solid shape): 74.73,17.32 74.73,16.71 75.65,15.79 75.65,15.41 75.52,15.29 74.58,15.29 73.84,16.02 73.69,16.17 73.69,17.34 73.87,17.52 74.53,17.52
L_SPK- on IN2 (solid shape): 199,32.83 199.05,32.84 199.64,32.84 199.69,32.83 199.85,32.84 199.95,32.74 199.95,32.33 199.83,32.2 197.97,32.2 197.59,31.82 196.53,31.82 196.37,31.97 196.37,32.3 196.91,32.84 198.96,32.84
L_SPK-_1 on BOTTOM (solid shape): 74.76,13.63 74.76,12.49 75.16,12.08 78.59,12.08 78.89,11.78 80.51,11.78 80.75,11.54 80.75,11.15 80.59,10.99 78.8,10.99 78.48,11.25 78.11,11.05 78.09,11.07 74.81,11.07 73.77,12.11 73.77,13.86 73.87,13.96 74.43,13.96
LANVCC on TOP (solid shape): 45.37,81.99 45.37,80.82 45.27,80.72 43.97,80.72 43.74,80.94 41.97,80.94 41.89,81.02 41.89,81.93 42.04,82.09 45.27,82.09
LANVCC on TOP (solid shape): 35.79,78.05 35.79,77.16 36.2,76.75 36.2,75.33 36.14,75.27 36.07,75.27 36.04,75.28 36.02,75.32 36.02,76.35 35.55,76.82 35.29,76.82 35.1,77.01 33.81,77.01 33.69,77.13 33.69,77.97 33.84,78.12 35.72,78.12
LANVCC on TOP (solid shape): 38.52,67.18 38.52,64.1 38.74,63.88 40.72,63.88 40.93,64.08 40.93,64.69 41.1,64.87 42.81,64.87 43.03,65.09 43.03,66.54 43.18,66.68 44.32,66.68 44.54,66.47 44.54,65.14 45.07,64.62 45.07,63.41 44.92,63.26 43.8,63.26 43.66,63.12 43.66,62.78 43.56,62.68 40.29,62.68 40,62.39 38.61,62.39 37.86,63.14 37.86,65.52 37.9,65.68 37.86,65.84 37.86,67.13 37.88,67.17 37.91,67.18 38.51,67.18
LANVCC on BOTTOM (solid shape): outline of 264 points within 35.06,65.37 42.45,81.55
LCDVCC on TOP (solid shape): 115.75,161.34 116.89,161.34 117.12,161.11 117.12,161.07 117.38,160.81 117.38,159.89 117.15,159.66 114.08,159.66 113.39,160.34 113.39,161.84 113.52,161.97 115.12,161.97
LCDVCC on BOTTOM (solid shape): 116.39,161.23 116.62,161.23 116.72,161.33 116.8,161.34 117.05,161.34 117.06,161.32 117.2,161.32 117.21,161.32 117.23,161.31 117.32,161.22 117.32,159.95 117.17,159.8 115.74,159.8 115.47,160.08 111.05,160.08 110.97,160.16 110.97,160.65 111.12,160.8 114.94,160.8 115.5,161.36 116.26,161.36
LCDVCC_R on TOP (solid shape): 118.46,164.32 118.48,164.24 118.44,164.17 118.3,164.01 118.27,163.8 118.28,163.64 118.36,163.5 118.37,163.47 118.36,163.44 118.29,163.32 118.26,163.16 118.25,163.14 118.1,162.98 117.87,162.98 117.86,162.99 116.46,162.99 116.46,162.98 116.06,162.98 115.75,162.68 115.75,162.66 115.55,162.45 113.7,162.45 113.57,162.58 113.57,163.52 113.63,163.58 114.32,163.58 114.42,163.58 114.42,163.59 114.68,163.59 116.41,165.31 117.47,165.31
LCDVCC_R on BOTTOM (solid shape): 118.91,167.65 118.91,167.16 118.91,167.14 118.9,167.12 118.78,166.88 118.85,166.63 118.86,166.61 118.85,166.57 118.65,166.37 118.65,164.69 117.93,163.97 117.26,163.97 117.07,164.16 117.07,165.66 117.84,166.43 117.84,166.75 117.81,166.78 117.81,166.92 117.02,167.71 117.02,167.79 117.86,168.63 117.94,168.63
NV_PLLVDD on TOP (solid shape): 177.46,125.22 177.46,122.04 176.58,121.15 175.44,121.15 175.32,121.28 175.32,122.07 175.19,122.19 174.55,122.19 174.43,122.32 174.43,122.74 175.6,122.74 175.6,122.69 175.61,122.63 175.63,122.58 175.66,122.53 175.69,122.49 175.73,122.45 175.78,122.42 175.83,122.39 175.88,122.37 175.94,122.36 175.99,122.36 176.05,122.37 176.1,122.38 176.15,122.4 176.2,122.43 176.24,122.47 176.28,122.51 176.31,122.56 176.33,122.61 176.35,122.66 176.36,122.72 176.36,122.77 176.35,122.83 176.33,122.88 176.31,122.93 176.28,122.98 176.24,123.02 176.2,123.05 176.15,123.08 176.1,123.11 176.05,123.12 175.99,123.13 175.94,123.12 175.88,123.11 175.83,123.1 175.78,123.07 175.73,123.04 175.69,123 175.66,122.96 175.63,122.91 175.61,122.85 175.6,122.8 175.6,122.74 174.43,122.74 174.43,123.21 174.55,123.34 175.34,123.34 175.46,123.44 176.58,123.44 176.83,123.69 176.83,125.22 176.96,125.34 177.34,125.34
PEX_PLLVDD on TOP (solid shape): 174.54,141.03 174.54,140.6 174.55,140.59 174.55,140.56 175.01,140.1 175.52,140.1 175.61,140.01 175.61,138.6 175.49,138.48 175.36,138.48 175.19,138.49 175.12,138.57 175.12,138.84 174.27,139.69 174.24,139.69 174.22,139.7 173.91,139.7 173.85,139.69 173.82,139.69 173.17,140.34 172.53,140.34 172.52,140.33 171.71,140.33 171.67,140.37 171.67,141.16 171.69,141.18 174.39,141.18
PLLVDD on TOP (solid shape): 176.7,124.97 176.7,123.95 176.45,123.69 173.03,123.69 172.93,123.59 172.9,123.59 172.9,123.08 172.65,122.83 172.14,122.83 172.01,122.96 172.01,123.59 172.4,123.97 172.4,124.73 172.52,124.86 173.41,124.86 173.79,124.48 174.29,124.48 174.55,124.75 174.55,125.22 174.68,125.34 176.32,125.34
R_SPK+ on TOP (solid shape): 77.58,18.26 77.58,15.44 77.37,15.23 77.35,15.23 77.31,15.25 77.3,15.29 77.3,15.29 76.32,15.29 76.31,15.31 76.31,16.17 76.32,16.19 76.32,18.24 76.43,18.36 77.48,18.36
R_SPK+ on BOTTOM (solid shape): 200.54,33.53 200.78,33.53 200.8,33.51 201.78,33.51 201.81,33.48 201.81,33.35 201.76,33.3 200.8,33.3 200.8,33.3 200.41,33.3 200.06,33.65 198.81,33.65 198.74,33.73 198.74,34.21 198.94,34.42 199.65,34.42
R_SPK+ on IN2 (solid shape): 78.52,18.89 78.52,17.8 78.44,17.72 76.41,17.72 76.31,17.83 76.31,18.97 76.41,19.07 78.34,19.07
R_SPK+ on IN2 (solid shape): 200.03,35.1 200.03,33.95 199.8,33.73 197.94,33.73 197.72,33.95 197.72,35.07 197.85,35.2 199.93,35.2
R_SPK+_1 on BOTTOM (solid shape): 78.81,14.28 80.51,14.28 80.73,14.06 80.73,13.7 80.51,13.48 78.9,13.48 78.62,13.2 76.33,13.2 76.18,13.35 76.18,14.6 76.33,14.75 78.34,14.75
R_SPK- on TOP (solid shape): 76,18.21 76,15.41 75.89,15.29 75.08,15.29 74.96,15.41 74.96,18.21 75.11,18.36 75.85,18.36
R_SPK- on BOTTOM (solid shape): 200.18,33.12 200.8,33.12 200.8,33.11 201.77,33.11 201.81,33.07 201.81,32.94 201.78,32.92 198.84,32.92 198.76,32.99 198.76,33.43 198.86,33.53 199.78,33.53
R_SPK- on IN2 (solid shape): 76,18.23 76,17.8 76.28,17.52 77.45,17.52 77.63,17.34 77.63,16.61 77.49,16.47 76.78,16.47 76.76,16.45 75.49,16.45 74.99,16.96 74.99,18.28 75.06,18.36 75.88,18.36
R_SPK- on IN2 (solid shape): 197.9,33.57 199.85,33.57 199.98,33.45 199.98,33.07 199.89,32.98 197.39,32.98 197.3,33 197.21,33 196.44,33 196.32,33.12 196.32,33.93 196.45,34.06 197.41,34.06
R_SPK-_1 on BOTTOM (solid shape): 76.03,13.74 76.03,13.15 76.13,13.05 76.89,13.05 76.92,13.03 80.51,13.03 80.7,12.83 80.7,12.4 80.51,12.21 75.52,12.21 75.06,12.67 75.06,13.96 75.14,14.04 75.72,14.04
REGOUT on TOP (solid shape): 40.99,69.3 43.26,69.3 43.45,69.11 43.57,68.76 43.93,68.64 44.01,68.56 44.01,67.31 43.94,67.24 43.08,67.24 43.01,67.31 43.01,68.17 42.71,68.47 41.81,68.47 41.64,68.3 41.64,67.86 41.54,67.76 41.15,67.76 40,68.91 40,70.06 40.03,70.08 40.21,70.08
RING2 on BOTTOM (solid shape): 207.2,13.83 207.2,13.26 207.22,13.24 207.22,12.49 207.02,12.29 206.41,12.29 205.54,13.15 205.54,13.79 205.64,13.89 207.14,13.89
RING2 on IN2 (solid shape): 208.01,13.66 208.01,12.77 207.84,12.6 207.82,12.6 207.73,12.57 207.66,12.52 206.16,12.52 206.14,12.52 206.12,12.55 206.01,12.69 205.86,12.77 205.84,12.77 205.8,12.82 205.8,13.69 206,13.89 207.78,13.89
RING2_R on BOTTOM (solid shape): 208.82,13.81 208.82,13.48 209.05,13.25 209.61,13.25 209.62,13.27 209.9,13.27 210.05,13.42 210.06,13.42 210.21,13.51 210.3,13.66 210.31,13.68 210.42,13.79 211.69,13.79 211.74,13.74 211.74,13.55 211.73,13.51 211.69,13.5 210.4,13.5 210.4,13.3 211.69,13.3 211.73,13.29 211.74,13.25 211.74,13.05 211.73,13.01 211.69,13 210.4,13 210.4,12.8 211.69,12.8 211.73,12.79 211.74,12.75 211.74,12.57 211.69,12.52 208.09,12.52 207.91,12.57 207.73,12.52 207.72,12.52 207.65,12.52 207.47,12.69 207.47,13.84 207.5,13.86 208.77,13.86
SLEEVE on BOTTOM (solid shape): 207.2,15.4 207.2,14.78 207.21,14.78 207.24,14.75 207.24,14.22 207.12,14.09 205.7,14.09 205.57,14.22 205.57,14.32 205.58,14.35 205.58,15.39 205.8,15.62 206.99,15.62
SLEEVE on IN1 (solid shape): 207.24,16 207.24,14.22 207.09,14.07 206.1,14.07 205.97,14.19 205.97,16.02 206.08,16.12 207.12,16.12
SLEEVE_R on BOTTOM (solid shape): 208.9,15.36 208.9,14.9 209.05,14.75 209.66,14.75 209.76,14.85 209.76,15.06 209.99,15.29 211.72,15.29 211.74,15.26 211.74,15.05 211.73,15.01 211.69,15 210.4,15 210.4,14.8 211.69,14.8 211.73,14.79 211.74,14.75 211.74,14.55 211.73,14.51 211.69,14.5 210.4,14.5 210.4,14.3 211.69,14.3 211.73,14.29 211.74,14.25 211.74,14.07 211.69,14.02 210.21,14.02 209.97,14.12 209.73,14.03 207.65,14.03 207.47,14.21 207.47,15.51 207.52,15.56 208.69,15.56
SYSTEM_AGND on TOP (solid shape): 57.4,39.66 57.4,37.95 57.54,37.82 57.54,37.28 57.37,37.12 57,37.12 56.78,37.34 56.78,37.66 56.47,37.97 56.06,37.97 55.94,38.09 55.94,39.9 55.05,40.79 55.05,41.24 55.12,41.32 55.73,41.32
SYSTEM_AGND on BOTTOM (solid shape): 57.51,37.74 57.51,37.38 57.33,37.21 57.08,37.21 56.65,37.64 55.73,37.64 55.58,37.79 55.58,38.4 55.81,38.63 56.62,38.63
TERM9 on TOP (solid shape): 25.86,94.41 25.86,78.81 25.58,78.53 24.8,78.53 24.59,78.73 24.59,94.36 24.87,94.63 25.63,94.63
TERM9 on BOTTOM (solid shape): 28.4,94.81 28.4,92.12 28.02,91.74 25.08,91.74 24.59,92.22 24.59,94.81 25.08,95.3 27.92,95.3
TH_FAN_POWER on BOTTOM (solid shape): 64.34,119.25 64.34,118.33 64.65,118.03 67.04,118.03 67.19,118.18 69.53,118.18 69.78,117.93 69.78,117.42 69.53,117.16 62.52,117.16 61.91,117.77 61.91,119.35 62.11,119.55 64.04,119.55
TP_INT on TOP (solid shape): 132.26,181.1 132.26,179.98 132.13,179.84 132.09,179.82 132.06,179.8 131.23,179.8 131.23,179.8 131.1,179.83 130.97,179.8 130.96,179.8 130.41,179.8 129.77,180.44 129.77,180.59 130.41,181.22 132.14,181.22
TP_INT on BOTTOM (solid shape): 133.1,180.99 133.81,180.99 133.91,180.89 133.91,180.41 133.84,180.33 133.07,180.33 133,180.37 132.92,180.39 132.62,180.39 132.54,180.37 132.48,180.33 132.05,180.33 131.98,180.37 131.91,180.39 131.61,180.39 131.54,180.38 131.47,180.34 131.46,180.33 131.4,180.33 130.33,179.27 130.23,179.27 129.39,180.11 129.39,180.21 130.66,181.48 132.62,181.48
TP_PWR on TOP (solid shape): 119.23,171.83 119.23,170.81 119.56,170.48 119.56,169.13 119.51,169.08 119.06,169.08 118.95,169.18 118.95,170.43 118.83,170.56 116.92,170.56 116.62,170.25 115.58,170.25 115.53,170.29 115.53,171.68 115.86,172 119.06,172
TP_PWR on BOTTOM (solid shape): 119.25,171.81 119.25,170.14 120.15,169.23 120.15,169.18 119.64,168.68 119.59,168.68 118.78,169.49 118.78,170.15 118.24,170.68 117.74,170.68 117.2,171.22 117.2,171.75 117.46,172 119.06,172
USBPWR0 on TOP (solid shape): 21.08,16.13 21.08,15.41 20.97,15.3 19.78,15.3 19.65,15.43 19.65,16.13 19.79,16.27 20.93,16.27
USBPWR0 on TOP (solid shape): 25.23,25.99 25.23,24.61 24.36,23.74 22.99,23.74 22.15,22.9 20.78,22.9 20.44,22.56 19.4,22.56 19.1,22.26 19.1,22.05 18.99,21.94 18.55,21.94 18.42,22.07 18.42,22.61 18.43,22.62 18.43,22.9 19.06,23.53 19.06,24.36 18.88,24.54 18.88,25.32 18.96,25.41 20.35,25.41 20.37,25.38 21.29,25.38 21.32,25.41 22.23,25.41 23.1,26.28 24.93,26.28
USBPWR0 on IN2 (solid shape): outline of 286 points within 13.81,14.88 25.63,26.12
USBPWR1 on TOP (solid shape): 16.92,33.83 17.02,33.78 17.14,33.77 17.16,33.77 17.41,33.52 17.41,33.34 17.35,33.29 16.95,33.29 16.72,33.07 15.27,33.07 15.17,33.17 15.17,33.65 15.35,33.83
USBPWR1 on TOP (solid shape): 21.29,37.28 21.29,36.24 20.96,35.91 18.45,35.91 17.71,35.17 14.92,35.17 14.4,34.66 14.25,34.66 13.6,35.3 13.6,35.43 13.68,35.62 13.69,35.83 14.08,36.21 14.94,36.21 15.8,37.08 18.01,37.08 18.32,36.77 19.95,36.77 19.97,36.8 20.2,36.8 20.38,36.98 20.38,37.1 20.61,37.33 21.24,37.33
USBPWR1 on BOTTOM (solid shape): 15.83,35.4 15.83,33.24 15.7,33.12 15.47,33.12 13.73,34.86 13.73,35.87 13.85,35.99 15.25,35.99
USBPWRD2 on BOTTOM (solid shape): 213.92,32.02 213.92,26.18 212.69,24.95 212.69,21.37 212.38,21.05 212.15,21.05 212.11,21.09 212.03,21 210.21,21 210.08,21.12 210.08,21.3 211.78,21.3 211.78,21.5 210.48,21.5 210.48,21.3 210.08,21.3 210.08,21.8 211.78,21.8 211.78,22 210.48,22 210.48,21.8 210.08,21.8 210.08,22.3 211.78,22.3 211.78,22.5 210.48,22.5 210.48,22.3 210.08,22.3 210.08,23.6 210.08,23.6 210.08,24.96 210.08,24.96 210.08,26.36 210.39,26.67 210.39,27.71 210.52,27.83 211.16,27.83 211.77,28.44 211.77,32.14 211.79,32.13 211.84,32.11 211.9,32.1 211.96,32.1 212.01,32.1 212.07,32.12 212.12,32.14 212.17,32.17 212.21,32.21 212.25,32.25 212.28,32.3 212.3,32.35 212.32,32.4 212.32,32.43 213.52,32.43
V_BLIGHT on BOTTOM (solid shape): 116.99,166.02 116.99,165.75 116.94,165.71 116.94,164.13 116.55,163.74 115.01,163.74 114.84,163.57 114.84,162.83 114.79,162.78 113.16,162.78 113.06,162.88 113.06,163.62 113.2,163.76 113.4,163.76 114.86,165.21 114.86,165.91 115.82,166.87 116.13,166.87
VA on TOP (solid shape): 234.45,190.22 237.77,190.22 238.46,189.53 238.46,186.46 237.24,185.74 227.05,185.74 226.32,186.47 226.32,192.53 226.96,193.16 231.5,193.16
VA on BOTTOM (solid shape): 233.7,190.28 238.42,190.28 238.72,189.98 238.72,186.31 238.71,186.28 238.68,186.27 237.24,185.73 235.9,185.73 235.49,185.7 235.08,185.62 235.08,185.62 234.7,185.62 234.64,185.55 233.72,185.55 232.72,184.55 228.53,184.55 227.51,185.57 227.51,191.55 228.49,192.53 231.45,192.53
VA1 on BOTTOM (solid shape): 226.75,192.04 226.75,187.47 226.5,187.22 220.02,187.22 219.47,186.67 214.98,186.67 214.55,187.1 214.55,192.08 214.95,192.48 226.32,192.48
VA2 on BOTTOM (solid shape): 213.82,190.44 213.82,186.25 212.5,184.93 209.02,184.93 208.77,185.19 208.77,189.71 209,189.94 210.55,189.94 211.11,190.49 213.77,190.49
VCORE_PHASE on BOTTOM (solid shape): 142.83,163.27 142.83,162.48 140.93,160.57 140.39,160.57 140.35,160.59 140.34,160.62 140.34,161.08 140.35,161.12 140.39,161.13 140.42,161.13 141.84,162.55 141.84,163.24 141.92,163.32 142.78,163.32
VCORE_PHASE on BOTTOM (solid shape): 142.09,155.77 142.09,150.72 141.89,150.51 139.2,150.51 138.84,150.87 138.84,151.8 138.87,151.82 138.87,153.55 138.31,153.55 138.31,151.82 138.31,151.82 138.31,151.58 138,151.28 135.52,151.28 135.08,151.71 135.08,155.44 135.47,155.83 138.21,155.83 138.66,156.28 138.66,156.56 138.72,156.61 141.26,156.61
VCORE_VBST on BOTTOM (solid shape): 141.37,163.31 141.39,163.3 141.41,163.29 141.41,162.47 141.4,162.45 141.39,162.44 141.35,162.39 141.33,162.38 141.31,162.38 141.2,162.38 141.18,162.37 141.16,162.36 140.19,161.39 140.17,161.38 140.15,161.37 140.06,161.37 140.04,161.36 139.78,161.36 139.76,161.36 139.74,161.35 139.64,161.25 139.63,161.23 139.63,161.21 139.63,161.18 139.63,161.16 139.6,161.13 139.59,161.13 139.59,160.6 139.58,160.57 139.35,160.57 139.34,160.6 139.34,161.13 139.33,161.13 139.33,161.39 139.33,161.41 139.34,161.43 140.5,162.59 140.52,162.61 140.52,162.63 140.52,163.24 140.52,163.26 140.56,163.3 140.58,163.31
VCORE_VCC on BOTTOM (solid shape): 137.95,161.21 137.95,160.9 138.18,160.67 138.18,160.45 138.17,160.41 138.13,160.4 137.62,160.4 137.62,160.15 138.13,160.15 138.17,160.14 138.18,160.1 138.18,159.95 138.17,159.91 138.13,159.9 137.61,159.9 137.61,159.87 137.57,159.84 136.07,159.84 136,159.91 136,160.9 136.53,161.44 137.72,161.44
VDD33/18 on TOP (solid shape): 36.55,70.07 36.59,70.05 36.6,70.02 36.6,69.07 36.61,69.07 36.61,68.93 36.6,68.9 36.46,68.76 36.4,68.6 36.4,68.58 36.3,68.48 36.3,68.24 36.42,68.12 36.57,68.04 36.59,68.02 36.6,68 36.6,67.43 36.59,67.4 36.55,67.38 36.15,67.38 35.79,67.03 34.78,67.03 34.73,67.08 34.73,67.94 34.83,68.04 35.36,68.04 36.28,68.97 36.31,68.97 36.31,68.99 36.38,69.07 36.4,69.07 36.4,70.02 36.42,70.05 36.45,70.07
VREF_CA_DIMM0 on TOP (solid shape): 125.61,44.98 125.64,44.96 125.66,44.93 125.66,43.83 125.91,43.58 125.91,41.42 126.04,41.29 126.04,39.01 126.29,38.75 126.29,38.59 126.28,38.58 126.13,38.11 126.29,37.65 126.29,37.18 126.18,36.94 126.21,36.68 126.21,36.66 126.21,36.63 125.91,36.34 125.41,36.34 125.02,36.72 125.02,44.72 125.25,44.95 125.27,44.96 125.3,44.96 125.41,44.95 125.52,44.97 125.53,44.98
