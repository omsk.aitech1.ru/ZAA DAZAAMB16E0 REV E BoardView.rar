# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HWPG_+VCCOPC: length 206.7
  TOP w0.254: PR293.1 58.6,81.17 58.81,80.97 v1(58.81,80.79)
  IN1 w0.254: v1(148.88,30.42) 148.79,30.33 148.79,30 146.01,27.23 127.12,27.23 124.18,30.17 114.48,30.17 113.62,29.31 110.86,29.31 110.34,29.82 107.29,29.82 105.7,31.41 87.39,31.41 87.38,31.4 87.38,31.39 79.77,23.78 63.95,23.78 60.92,20.75 57.3,20.75 56.91,20.35 54.13,20.35 52.94,21.54 52.94,22.07 52.05,22.96 48.22,22.96 47.02,24.15 45.95,24.15 44.23,25.88 42.98,25.88 41.84,27.02 41.84,29.94 42.21,30.31 42.21,32.85 41.52,33.54 41.52,34.42 41.32,34.63 41.32,42.73 40.29,43.76 40.29,53.25 40.19,53.36 40.19,53.36 39.64,53.91 39.64,59.84 41.94,62.15 42.09,62.3 42.09,62.3 42.29,62.5 43.17,63.37 44.32,63.37 44.57,63.13 44.57,62.76 45.22,62.11 48.74,62.11 53.4,66.77 53.4,72.94 53.85,73.4 56.88,73.4 58.81,75.33 v1(58.81,80.79)
  BOTTOM w0.254: v1(148.88,30.42) 152.1,30.42 155.43,27.1 160.3,27.1 162.08,28.88 D14.1 ; v1(58.81,80.79) 58.81,80.97 58.6,81.17 PR290.1
HWPG_VDDR: length 164.9
  TOP w0.127: PR107.1 42.49,51.88 v1(42.75,51.62) ; v1(46.98,53.72) 46.67,53.41 46.67,53.03 46.43,52.79 PR267.2
  IN1 w0.254: v1(42.75,51.62) 42.75,50.81 43.16,50.41 43.16,47.64 42.27,46.75 42.27,43.29 42.4,43.16 42.4,35.33 43.06,34.67 43.06,33.29 43.01,33.24 43.01,29.31 48.57,23.74 52.38,23.74 53.73,22.39 53.73,21.87 54.45,21.14 56.58,21.14 57.99,22.55 61.22,22.55 63.24,24.57 79.42,24.57 87.08,32.23 87.13,32.23 87.15,32.25 105.97,32.25 107.28,30.94 112.62,30.94 112.95,30.94 113.32,31.31 124.15,31.31 127.37,28.09 128.36,28.09 144.52,28.09 146.65,30.22 v1(146.89,30.22)
  BOTTOM w0.203: v1(42.75,51.62) 42.75,51.13 43.02,50.87 43.41,50.87 43.43,50.85 45.06,50.85 45.65,51.43 45.65,53.15 46.23,53.72 v1(46.98,53.72)
  BOTTOM w0.254: D20.1 161.12,25.85 160.64,26.33 154.67,26.33 152.33,28.67 v1(147.94,28.67) 146.89,29.71 v1(146.89,30.22)
I2C0_SCL: length 152.6
  TOP w0.127: R166.2 145.84,114.82 145.58,114.56 145.41,114.56 145.1,114.87 143.5,114.87 142.91,114.27 v2(138.41,114.27)
  IN2 w0.14: v2(138.41,114.27) 138.58,114.1 143.55,114.1 144.18,114.73 145.87,114.73 146.39,114.21 151.41,114.21 153.41,112.21 157.08,112.21 158.56,110.72 160.71,108.57 160.71,106.71 162.91,104.51 163.22,104.51 164.55,103.18 164.55,87.67 163.96,87.08 163.96,86.08 163.25,85.37 163.25,76.98 163.51,76.73 163.51,75.87 163.49,75.85 163.49,75.85 163.25,75.61 163.25,74.23 163.65,73.83 163.65,72.39 163.45,72.19 163.45,70.4 163.48,70.36 163.48,66.89 164.27,66.1 164.27,65.28 165.6,63.95 166.42,63.95 166.65,63.72 167.95,62.42 169.89,60.48 169.89,59.47 170.38,58.99 170.38,55.82 166.15,51.6 166.15,51.41 158.02,43.28 158.02,42.24 148.72,32.94 143.64,32.94 142.78,32.07 142.09,32.07 v1(141.69,32.48)
  BOTTOM w0.127: v1(141.69,32.48) 141.87,32.3 141.87,28.3 142.96,27.21 142.96,23.08 140.09,20.21 140.09,19.61 140.01,19.53 139.17,19.53 138.74,19.1 138.74,17.03 R403.1 138.24,16.36 137.95,16.07 137.95,15.69 138.12,15.53 Q43.4 ; U35.U6 138.09,114.59 v2(138.41,114.27)
I2C0_SDA: length 163.3
  TOP w0.127: R167.2 145.49,114.3 145.37,114.3 145.01,114.65 143.59,114.65 142.94,114 139.21,114 139.07,113.86 138.06,113.86 137.76,114.15 v2(137.76,114.28)
  IN2 w0.14: v1(142.35,32.56) 142.53,32.38 142.67,32.38 143.52,33.23 148.6,33.23 157.73,42.36 157.73,43.4 165.86,51.53 165.86,51.72 170.08,55.94 170.08,58.86 169.6,59.35 169.6,60.35 168.24,61.72 166.3,63.65 165.48,63.65 163.98,65.16 163.98,65.98 163.19,66.77 163.19,70.24 163.16,70.28 163.16,72.31 163.36,72.51 163.36,73.71 162.96,74.11 162.96,75.73 163.19,75.97 163.19,75.97 163.21,75.99 163.21,76.61 162.96,76.86 162.96,85.49 163.67,86.2 163.67,87.21 164.26,87.79 164.26,103.06 163.1,104.22 162.79,104.22 160.42,106.59 160.42,108.45 158.35,110.51 156.96,111.91 156.44,111.91 156.44,111.91 153.29,111.91 151.29,113.91 146.23,113.91 145.7,114.45 144.33,114.45 143.69,113.81 138.28,113.81 137.82,114.28 v2(137.76,114.28)
  BOTTOM w0.127: Q43.1 136.11,14.23 136.05,14.17 136.05,12.92 136.12,12.85 136.12,12.36 136.73,11.75 137.01,11.75 138.44,13.18 141.97,13.18 142.42,13.63 142.42,14.44 R405.1 141.77,18.2 140.37,19.61 140.37,20.1 143.24,22.97 143.24,27.32 142.14,28.42 142.14,32.35 v1(142.35,32.56) ; v2(137.76,114.28) 137.43,114.61 U35.U7
I2C1_SCL: length 133.8
  TOP w0.114: v2(142.78,114.81) 142.54,115.05 142.54,115.33 142.7,115.49 R169.1
  TOP w0.127: v1(117.33,174.19) 117.35,174.16 117.63,174.16 118.17,173.63 R13.2 119.06,173.64 119.06,174.64 118.94,174.76 Q2.3
  IN2 w0.127: v2(142.78,114.81) 142.4,114.43 142,114.43 141.75,114.68 138.56,114.68 138.56,114.69 136.89,114.69 v1(136.45,114.25)
  IN2 w0.14: v1(117.33,174.19) 116.8,173.65 116.8,173.13 113,169.34 113,168.4 112.25,167.64 110.75,164.56 110.75,163.34 109.8,162.39 109.57,162.02 109.34,161.63 107.75,157.99 107.47,157.35 107.42,156.77 107.42,150.39 105.78,148.75 105.78,139.97 107.85,137.9 113.69,137.9 114.42,138.62 114.42,140.25 117.94,143.77 122.58,143.77 124.91,141.44 124.91,138.95 125.82,138.03 136.37,138.03 138.19,139.86 143.97,139.86 145.24,138.58 145.24,137.9 v1(145.48,137.66)
  BOTTOM w0.127: v1(136.45,114.25) 136.45,114.3 136.13,114.62 U35.U9 ; v2(142.78,114.81) 142.97,115 143.36,115 143.61,115.24 145.36,115.24 145.43,115.31 145.44,115.31 145.69,115.55 148.86,115.55 150.58,117.27 151.26,117.27 152.24,118.25 152.24,119.55 152.69,119.99 152.69,121.47 150.6,123.55 150.6,128.94 145.34,134.2 145.34,137.52 145.34,137.52 v1(145.48,137.66)
I2C1_SCL_C: length 13.8
  TOP w0.127: R6.1 123.35,178.46 123.06,178.75 122.17,178.75 v1(121.67,178.25) 121.17,178.75 120.32,178.75 119.85,178.28 119.85,178.05 120.88,177.01 122.48,177.01 122.87,176.63 122.87,175.57 122.31,175.02 R12.1 121.74,175.02 121.48,174.76 Q2.4 119.83,174.13 R13.1
I2C1_SDA: length 137.2
  TOP w0.114: R165.1 143,116.37 v1(142.18,115.54) 142.18,114.93 v2(142.14,114.89)
  TOP w0.127: Q2.6 120.06,176.06 119.82,176.3 119.82,177.05 R10.2 120.41,176.73 v1(120.53,176.73)
  IN2 w0.127: v2(142.14,114.89) 142.14,114.89 138.65,114.89 138.65,114.89 137.46,114.89 v2(137.05,115.3)
  IN2 w0.14: v1(120.53,176.73) 120.38,176.88 119.23,176.88 116.36,174.01 116.36,173.11 112.71,169.46 112.71,168.52 112.01,167.82 110.46,164.63 110.46,163.46 109.57,162.57 109.32,162.17 109.07,161.77 107.48,158.11 107.18,157.42 107.13,156.78 107.13,150.51 105.49,148.87 105.49,139.85 107.73,137.6 113.82,137.6 114.71,138.5 114.71,140.13 118.07,143.48 122.46,143.48 124.62,141.32 124.62,138.82 125.7,137.74 136.49,137.74 138.32,139.57 143.85,139.57 144.95,138.46 144.95,137.8 144.93,137.78 144.93,137.78 v1(144.81,137.66)
  BOTTOM w0.127: v2(137.05,115.3) 136.78,115.03 U35.U8 ; v1(144.81,137.66) 145.07,137.41 145.07,134.08 150.32,128.82 150.32,123.44 152.41,121.36 152.41,120.1 151.96,119.66 151.96,118.36 151.15,117.55 150.46,117.55 148.7,115.78 145.61,115.78 145.29,115.46 143.52,115.46 143.27,115.21 142.47,115.21 v2(142.14,114.89)
I2C1_SDA_C: length 13.2
  TOP w0.127: R9.1 116.69,175.92 116.29,176.32 116.29,176.9 116.75,177.36 117.35,177.36 117.48,177.24 117.48,176.3 117.72,176.06 Q2.1 118.82,176.06 119.17,176.41 R10.1 119.17,177.68 119.57,178.08 119.57,178.4 120.2,179.03 121.18,179.03 v1(121.67,179.52) 122.16,179.03 123.18,179.03 123.48,178.73 R5.1
I2C_TP_SCL_R: length 30.8
  IN2 w0.14: v1(138.18,18.82) 138.44,18.82 138.56,18.94 138.56,19.17 138.41,19.32 137.12,19.32 136.89,19.1 136.89,18.9 136.9,18.9 136.99,18.82 v1(137.14,18.82)
  BOTTOM w0.127: R410.1 136.45,16.77 136.45,16.47 136,16.02 135.72,16.02 135.72,15.67 135.86,15.53 Q43.3 137.33,15.53 137.46,15.66 R403.2 137.46,16.72 138.23,17.5 138.23,18.77 v1(138.18,18.82) ; v1(137.14,18.82) 136.86,19.1 136.86,19.86 135.95,20.77 128.38,20.77 127.08,19.48 127.08,15.72 126.3,14.93 123.77,14.93 123.64,15.06 123.64,15.19 124,15.55 CN17.3
I2C_TP_SDA_R: length 32.4
  IN2 w0.14: v1(136.35,18.82) 136.59,19.06 136.59,19.22 136.99,19.62 138.53,19.62 138.86,19.29 138.86,18.98 138.97,18.87 v1(139.22,18.87)
  BOTTOM w0.127: Q43.6 140.26,14.23 140.35,14.14 R409.1 R405.2 140.99,16.39 139.22,18.16 v1(139.22,18.87) ; v1(136.35,18.82) 136.58,19.04 136.58,19.74 135.83,20.49 128.49,20.49 127.36,19.36 127.36,15.61 126.41,14.66 123.65,14.66 123.36,14.95 123.36,15.19 123,15.55 CN17.4
I2CA_SCL: length 7.7
  BOTTOM w0.102: 184.74,119.79 184.74,120.48 184.33,120.89 U3002.R4
  BOTTOM w0.127: 182.78,115.59 v1(182.61,115.41) 182.43,115.23 R4208.2
  BOTTOM w0.14: 184.74,119.79 184.74,118.58 184.36,118.2 184.36,117.16 182.78,115.59
I2CA_SDA: length 3.2
  TOP w0.127: v1(183.88,122.39) 183.88,122.25 183.42,121.79 183.42,121.41 v1(182.94,120.92) R4209.2
  BOTTOM w0.102: U3002.R5 v1(183.88,122.39)
I2CB_SCL: length 10.6
  BOTTOM w0.102: 185.53,118.96 185.53,120.46 185.25,120.74 184.97,120.74 184.74,120.97 184.74,123.23 U3002.R7
  BOTTOM w0.14: 185.53,118.96 185.53,118.58 184.99,118.05 184.99,117.22 184.88,117.1 184.88,116.75 183.88,115.75 v1(183.88,115.31) 183.88,115.17 R4337.1
I2CB_SDA: length 2.5
  TOP w0.14: R4338.1 183.43,122.17 183.43,122.67 v1(183.94,123.19)
  BOTTOM w0.102: v1(183.94,123.19) 184.33,122.8 U3002.R6
I2CC_SCL: length 8.7
  BOTTOM w0.102: U3002.R2 184.33,119.31 183.95,118.94
  BOTTOM w0.127: 182.3,112.41 182.42,112.3 R4339.1
  BOTTOM w0.14: 183.95,118.94 183.95,117.99 183.89,117.92 183.89,117.41 181.67,115.19 v1(181.67,114.55) 181.67,113.05 182.3,112.41
I2CC_SDA: length 9.5
  BOTTOM w0.102: U3002.R3 184.33,120.03 183.85,119.55 183.85,119.22 183.65,119.01
  BOTTOM w0.127: R4340.1 181.29,112.41
  BOTTOM w0.14: 183.65,119.01 183.65,117.54 181.16,115.06 v1(181.16,113.3) 181.16,112.55 181.29,112.41
ICMNT: length 322.2
  TOP w0.127: v1(183.37,177.01) v1(185.3,178.94) 186.72,180.36 v1(186.72,180.89) ; v1(153.83,184.53) 153.83,185.49 153.93,185.59 153.93,186.86 PC3.2 153.98,187.32 153.99,187.33 PR170.1
  IN1 w0.14: v1(153.83,184.53) 153.83,183.33 154.54,182.62 154.54,179.67 157.46,176.75 159.65,176.75 161.47,174.92 176.92,174.92 177.96,175.97 180.73,175.97 181.54,176.78 183.14,176.78 v1(183.37,177.01)
  IN2 w0.14: v1(170.91,25.1) 170.97,25.1 171.2,25.32 171.84,25.32 174.17,27.66 177.15,27.66 178.64,29.15 180.56,29.15 180.86,29.45 184.78,29.45 185.36,30.02 185.36,31.32 185.53,31.49 186.05,31.49 188.2,33.64 190.37,33.64 194.5,37.77 200.44,37.77 200.59,37.62 205.66,37.62 205.95,37.91 207.4,37.91 209.26,39.77 214.13,39.77 216.36,42.01 216.36,50.72 216.52,50.88 216.52,52.62 215.94,53.2 215.94,59.92 218.98,62.96 218.98,66.01 221.34,68.37 221.34,86.99 218.88,89.45 218.88,95.12 222.94,99.18 227.53,99.18 229.5,101.15 229.5,105.03 230.89,106.43 230.89,112.97 228.77,115.1 228.77,159.32 225.81,162.28 225.81,166.43 232.82,173.44 232.82,188.92 229.39,192.35 211.08,192.35 209.51,190.77 206.92,190.77 206.12,191.57 202.55,191.57 194.29,183.31 192.35,183.31 189.99,180.94 186.77,180.94 v1(186.72,180.89)
  BOTTOM w0.127: v1(170.91,25.1) 170.82,25.19 170.72,25.19 169.47,26.45 C516.2 169.47,28.56 170.7,29.8 U45.67
ILIM_HI: length 2.3
  TOP w0.127: U22.16 20.88,27.24 R377.1 20.96,27.38 20.38,27.96 v1(20.25,27.96)
ILIM_LO: length 2.7
  TOP w0.127: U22.15 20.94,26.74 21.09,26.59 v1(21.39,26.59) 21.98,27.17 R376.2
IMVP_PWRGD: length 68.8
  TOP w0.127: v1(132.26,172.74) 132.39,172.87 PR30.1
  IN2 w0.14: v1(132.26,172.74) 132.14,172.74 131.53,173.35 131.53,175.61 128.92,178.21 119.63,178.21 115.42,174.01 115.42,173.09 112.06,169.73 112.06,168.79 111.36,168.08 110.45,166.22 110.02,165.29 109.99,165.21 109.86,164.95 109.6,164.47 108.85,162.86 108.85,162.65 108.5,162.06 106.33,157.09 106.33,153.3 103.45,150.42 103.45,144.56 99.42,140.53 v1(99.42,139.49)
  BOTTOM w0.127: PR197.2 132.92,173.12 132.54,172.74 v1(132.26,172.74) ; R478.1 99.35,139.42 v1(99.42,139.49) 99.42,140.31 v1(99.8,140.69) 100.38,141.27 100.97,141.27 101.12,141.12 U33.2
IMVP_PWRGD_3V: length 354.4
  TOP w0.254: U8.1 184.62,35.31 v1(184.66,35.35) 185.1,35.79 R113.2
  IN1 w0.254: v1(184.66,35.35) 184.66,34.16 183.89,33.38 183.31,33.38 182.55,32.63 175.74,32.63 170.92,27.8 167,27.8 166.81,28 157.3,28 150.8,21.5 126.18,21.5 125.9,21.5 125.72,21.32 117.42,21.32 113.4,25.34 106.87,25.34 104.3,27.91 89.21,27.91 80.59,19.29 79.97,19.29 79.17,20.1 72.53,20.1 68.03,15.6 60.8,15.6 59.85,16.56 43.41,16.56 v1(43.39,16.58) ; v1(32.42,15.83) 32.42,15.97 29.9,18.49 28.94,18.49 28.05,19.37 28.05,22.9 28.57,23.42 28.57,27 31.65,30.08 31.65,34.84 33.64,36.82 33.64,51.51 33.06,52.08 33.06,53.19 25.84,60.42 25.84,64.54 30.04,68.73 30.04,69.19 32.08,71.24 33.97,71.24 35.39,72.66 35.39,72.71 35.43,72.75 35.43,74.74 35.93,75.25 36.57,75.25 36.85,75.25 37.85,76.25 37.85,77.76 36.61,79 36.61,82.09 36.96,82.44 37.27,82.44 38.23,83.41 38.23,85.08 41.23,88.08 41.23,109.14 49.59,117.49 61.27,117.49 62.11,118.33 67.98,118.33 70.93,121.29 72.84,121.29 81.29,129.73 81.87,130.27 82.08,130.42 82.24,130.48 82.3,130.5 83.76,131.01 83.89,131.09 84.35,131.41 85.72,132.32 87.28,133.38 87.28,133.38 87.42,133.47 89.71,133.47 92.61,136.37 v1(94.14,136.37)
  BOTTOM w0.254: U33.4 101.77,138.99 101.63,139.14 100.21,139.14 100.01,138.93 100.01,138.27 99.77,138.03 R478.2 R485.2 97.8,137.43 96.07,137.43 Q31.2 95,136.37 v1(94.14,136.37) ; v1(32.42,15.83) 42.64,15.83 v1(42.83,16.02) v1(43.39,16.58)
INT_AMIC-VREFO: length 5
  TOP w0.203: v1(207.07,27.88) 206.03,27.88 v1(205.87,28.04)
  BOTTOM w0.203: v1(205.87,28.04) 205.8,28.11 U23.27 ; v1(207.07,27.88) 207.5,27.88 208.01,28.39 R397.2 C534.1
INT_HDMI_HPD: length 301.2
  TOP w0.114: R718.2 R722.2 26.98,54.86 26.73,55.11 Q41.1 27.46,55.77 28.63,54.6 28.63,40.84 28.33,40.53 v1(28.33,37.41) 28.33,32.23 27.35,31.25 v1(27.35,29.96)
  IN2 w0.114: v1(27.35,29.96) 29.9,27.41 29.9,25.83 30.51,25.22 30.51,24.05 37.52,17.04 45.72,17.04 46.19,17.51 47.68,17.51 47.99,17.83 49.32,17.83 51.03,19.53 57.84,19.53 57.9,19.47 58.24,19.47 58.3,19.53 63.94,19.53 64.55,20.14 64.55,21.98 66.78,24.21 68.88,24.21 70.73,26.06 73.62,26.06 75.13,27.58 78.66,27.58 86.36,35.28 111.23,35.28 114.97,31.54 117.06,31.54 118.25,30.35 142.96,30.35 144.2,31.59 149.41,31.59 162.92,45.1 164.93,45.1 165.54,45.71 169.19,45.71 170.2,44.7 170.68,44.7 171.59,45.62 171.59,49.37 172.82,50.6 172.82,54.37 173.13,54.68 173.13,60.15 172.65,60.63 172.65,61.62 166.78,67.49 166.78,70.31 166.48,70.6 166.48,76.21 166.22,76.47 166.22,77.46 166.63,77.87 166.63,79.63 166.53,79.73 166.53,82.1 166.25,82.38 166.25,84 167.02,84.77 167.02,85.75 167.33,86.06 167.33,89.23 167.51,89.41 167.51,89.95 167.51,89.96 167.51,90.25 167.7,90.43 167.7,95.29 167.63,95.36 167.63,104.91 164.01,108.53 164.01,109.62 158.27,115.36 157.03,115.36 155.39,117 147.38,117 146.77,117.61 139.11,117.61 138.84,117.88 136.96,117.88 136.47,117.39 v2(136.47,117.19)
  BOTTOM w0.114: v2(136.47,117.19) 136.47,117.34 136.13,117.69 U35.L9
INT_HDMICLK+: length 150.6
  TOP w0.114: C389.1 25.97,51.2 26.24,51.2 v1(26.45,51)
  IN2 w0.114: v1(26.45,51) 26.68,51.23 27.41,51.23 27.9,51.71 27.9,57.8 29.37,59.28 29.37,62.14 31.25,64.02 38.17,64.02 38.63,63.56 39.57,63.56 40.51,64.5 40.51,64.84 40.27,65.07 40.27,65.23 40.55,65.51 40.71,65.51 40.95,65.28 41.29,65.28 41.69,65.68 41.69,66.02 41.46,66.26 41.46,66.42 41.74,66.7 41.9,66.7 42.13,66.46 42.47,66.46 44.29,68.28 44.83,68.28 46.51,69.97 48.52,71.98 48.52,77.72 45.27,80.97 45.27,99.92 46.06,100.71 46.06,101.05 45.44,101.68 45.44,101.84 45.72,102.12 45.88,102.12 46.5,101.49 46.85,101.49 47.64,102.29 47.64,103.33 47.64,104.33 54.09,110.78 73.12,110.78 81.38,119.04 82.46,119.04 84.5,121.09 85.39,121.09 86.61,122.31 88.11,122.31 90.4,124.59 93.64,124.59 93.76,124.48 93.76,124.21 94,123.97 94.57,123.97 94.81,124.21 94.81,124.48 94.93,124.59 95.32,124.59 95.44,124.48 95.44,124.21 95.68,123.97 96.25,123.97 96.49,124.21 96.49,124.48 96.6,124.59 97.2,124.59 99.12,122.68 106.79,122.68 108.31,121.15 108.62,121.15 108.93,120.84 108.93,120.44 v2(109.35,120.02)
  BOTTOM w0.114: U35.G56 109.02,119.69 v2(109.35,120.02)
INT_HDMICLK+_C: length 5.6
  TOP w0.102: U18.10 15.85,49.53 14.95,50.43 R303.1 v1(13.81,50.43)
  BOTTOM w0.102: CN12.10 11.99,50.85 12.57,50.85 12.68,50.74 13.6,50.74 13.81,50.53 v1(13.81,50.43)
INT_HDMICLK+_C_R: length 4.1
  TOP w0.114: C389.2 24.46,51.18 24.36,51.18 22.86,49.67 22.24,49.67 22.1,49.53 U18.31
INT_HDMICLK-: length 150.6
  TOP w0.114: v1(26.47,51.66) 26.23,51.42 26.01,51.42 C387.1
  IN2 w0.114: v2(109.39,120.66) 109.24,120.66 109.15,120.75 109.15,120.93 108.71,121.37 108.4,121.37 106.88,122.89 99.21,122.89 97.29,124.81 96.51,124.81 96.27,124.57 96.27,124.3 96.16,124.19 95.77,124.19 95.65,124.3 95.65,124.57 95.41,124.81 94.84,124.81 94.6,124.57 94.6,124.3 94.48,124.19 94.09,124.19 93.97,124.3 93.97,124.57 93.73,124.81 90.31,124.81 88.02,122.52 86.52,122.52 85.3,121.3 84.41,121.3 82.37,119.26 81.29,119.26 73.03,110.99 54,110.99 47.43,104.42 47.43,103.24 47.43,102.38 46.76,101.71 46.59,101.71 45.97,102.34 45.63,102.34 45.22,101.93 45.22,101.59 45.85,100.96 45.85,100.8 45.05,100.01 45.05,80.88 48.3,77.63 48.3,72.07 44.74,68.5 44.2,68.5 42.38,66.68 42.22,66.68 41.99,66.92 41.65,66.92 41.24,66.51 41.24,66.17 41.48,65.93 41.48,65.77 41.2,65.49 41.04,65.49 40.8,65.73 40.46,65.73 40.05,65.32 40.05,64.98 40.29,64.75 40.29,64.59 39.48,63.77 38.72,63.77 38.26,64.23 31.16,64.23 29.15,62.23 29.15,59.37 27.68,57.89 27.68,51.8 27.32,51.44 26.69,51.44 v1(26.47,51.66)
  BOTTOM w0.114: v2(109.39,120.66) 108.95,120.66 108.89,120.6 U35.F56
INT_HDMICLK-_C: length 5.6
  TOP w0.102: v1(13.73,51.21) R303.2 14.58,51.21 15.76,50.03 U18.9
  BOTTOM w0.102: CN12.12 11.99,51.15 12.69,51.15 12.8,51.04 13.56,51.04 v1(13.73,51.21)
INT_HDMICLK-_C_R: length 4.1
  TOP w0.114: U18.32 22.1,50.03 22.24,49.89 22.77,49.89 24.28,51.39 24.37,51.39 C387.2
INT_HDMITX0N: length 156.4
  TOP w0.114: v1(26.38,45.63) 26.1,45.36 25.69,45.36 25.59,45.45 C398.1
  IN2 w0.114: v1(26.38,45.63) 26.38,45.43 26.55,45.26 26.8,45.26 26.99,45.45 26.99,45.95 26.79,46.16 25.8,46.16 24.78,47.17 24.78,51.95 26.14,53.31 26.14,58.54 27.73,60.13 27.73,62.82 30.57,65.65 32.92,65.65 33.57,66.3 35.17,66.3 35.82,66.95 38.28,66.95 39.2,67.86 40.36,67.86 42.92,70.43 42.92,71.63 42.59,71.96 42.59,75.55 42.96,75.91 42.96,78.31 43.45,78.81 43.45,103.49 52.42,112.46 72.48,112.46 85.25,125.23 87.67,125.23 89.44,126.99 95.03,126.99 95.59,126.44 99.5,126.44 100.72,125.21 103.84,125.21 104.74,124.31 107.66,124.31 109.16,122.82 110.76,122.82 111.22,122.36 111.22,121.17 110.95,120.9 110.95,120.75 111.04,120.66 v2(111.19,120.66)
  BOTTOM w0.114: U35.F53 110.72,120.59 110.82,120.7 111.15,120.7 v2(111.19,120.66)
INT_HDMITX0N_C: length 10.5
  TOP w0.102: v1(13.79,45.88) R312.2 14.9,45.88 16.06,47.03 U18.15
  BOTTOM w0.102: v1(13.79,45.88) 13.56,45.64 11.55,45.64 10.97,46.23 10.97,49.06 10.03,50 CN12.9
INT_HDMITX0N_C_R: length 4.6
  TOP w0.114: U18.26 22.1,47.03 22.24,46.89 22.45,46.89 23.15,46.18 23.89,46.18 ; 23.89,46.18 v1(23.89,46.18) ; 23.89,46.18 23.89,45.44 23.99,45.35 24.42,45.35 C398.2
INT_HDMITX0P: length 156.3
  TOP w0.114: C405.1 25.59,44.98 25.76,45.14 26.07,45.14 v1(26.38,44.83)
  IN2 w0.114: v1(26.38,44.83) 26.58,45.04 26.89,45.04 27.21,45.36 27.21,46.04 26.88,46.37 25.89,46.37 25,47.26 25,51.86 26.36,53.22 26.36,58.45 27.95,60.04 27.95,62.73 30.66,65.44 33.01,65.44 33.66,66.09 35.26,66.09 35.91,66.73 38.37,66.73 39.29,67.65 40.45,67.65 43.14,70.34 43.14,71.72 42.81,72.05 42.81,75.46 43.17,75.83 43.17,78.22 43.67,78.72 43.67,103.4 52.51,112.24 72.57,112.24 85.34,125.01 87.76,125.01 89.53,126.78 94.94,126.78 95.5,126.22 99.41,126.22 100.63,125 103.75,125 104.65,124.1 107.57,124.1 109.07,122.6 110.67,122.6 111,122.27 111,121.25 110.72,120.98 110.72,120.4 v2(111.18,119.94)
  BOTTOM w0.114: v2(111.18,119.94) 110.92,119.69 U35.G53
INT_HDMITX0P_C: length 10.6
  TOP w0.102: U18.16 15.97,46.53 R312.1 v1(13.82,45.1)
  BOTTOM w0.102: v1(13.82,45.1) 13.82,45.26 13.73,45.35 11.43,45.35 10.67,46.11 10.67,48.94 10.42,49.19 10.18,49.19 10,49.02 CN12.7
INT_HDMITX0P_C_R: length 4.6
  TOP w0.114: U18.25 22.1,46.53 22.24,46.67 22.36,46.67 23,46.03 23,45.29 ; 23,45.29 v1(22.99,45.28) ; 23,45.29 23.74,45.29 23.9,45.13 24.41,45.13 C405.2
INT_HDMITX1N: length 150
  TOP w0.114: v1(26.35,47.66) 26.13,47.44 25.69,47.44 25.59,47.53 C406.1
  IN2 w0.114: v2(108.44,120.66) 108.26,120.48 107.97,120.48 107.67,120.78 107.31,120.78 106.42,121.67 102.89,121.67 102.39,122.17 98.61,122.17 98.32,121.88 97.17,121.88 95.63,123.43 91.74,123.43 91.54,123.63 90.14,123.63 88.32,121.81 86.82,121.81 85.57,120.57 84.68,120.57 82.66,118.55 81.7,118.55 73.41,110.26 54.27,110.26 48.14,104.12 48.14,103.53 48.14,103.53 48.14,100.94 45.79,98.59 45.79,81.16 49.09,77.86 49.09,71.13 48.01,70.05 47.3,70.05 44.99,67.74 44.48,67.74 39.71,62.96 37.83,62.96 37.52,62.66 36.07,62.66 35.96,62.77 35.96,63.25 35.72,63.49 35.14,63.49 34.9,63.25 34.9,62.77 34.79,62.66 34.39,62.66 34.28,62.77 34.28,63.25 34.04,63.49 33.47,63.49 33.23,63.25 33.23,62.77 33.11,62.66 30.59,62.66 29.86,61.93 29.86,59.06 28.4,57.6 28.4,47.64 28.1,47.34 26.67,47.34 v1(26.35,47.66)
  BOTTOM w0.114: v2(108.44,120.66) 108.09,120.66 107.98,120.77 U35.E58
INT_HDMITX1N_C: length 5.7
  TOP w0.102: v1(13.72,47.77) 13.84,47.65 R314.2 14.62,47.57 15.33,47.57 15.78,48.03 U18.13
  BOTTOM w0.102: CN12.6 11.99,48.15 12.39,48.15 13.11,47.43 13.38,47.43 v1(13.72,47.77)
INT_HDMITX1N_C_R: length 3.7
  TOP w0.114: U18.28 22.1,48.03 22.24,47.89 22.95,47.89 23.49,47.35 24.39,47.35 C406.2
INT_HDMITX1P: length 150
  TOP w0.114: C407.1 25.59,47.07 25.74,47.23 25.99,47.23 v1(26.35,46.87)
  IN2 w0.114: v2(108.43,120.01) 108.17,120.26 107.88,120.26 107.58,120.57 107.22,120.57 106.33,121.45 102.8,121.45 102.3,121.95 98.7,121.95 98.41,121.66 97.08,121.66 95.54,123.21 91.65,123.21 91.45,123.41 90.23,123.41 88.41,121.6 86.91,121.6 85.66,120.35 84.77,120.35 82.75,118.33 81.79,118.33 73.5,110.04 54.36,110.04 48.35,104.03 48.35,103.62 48.35,103.62 48.35,100.85 46.01,98.5 46.01,81.25 49.31,77.95 49.31,71.04 48.1,69.83 47.39,69.83 45.08,67.52 44.57,67.52 39.8,62.75 37.92,62.75 37.61,62.44 35.98,62.44 35.74,62.68 35.74,63.16 35.63,63.28 35.23,63.28 35.12,63.16 35.12,62.68 34.88,62.44 34.3,62.44 34.06,62.68 34.06,63.16 33.95,63.28 33.56,63.28 33.44,63.16 33.44,62.68 33.2,62.44 30.68,62.44 30.08,61.84 30.08,58.97 28.62,57.51 28.62,47.56 28.19,47.12 26.62,47.12 26.58,47.09 26.57,47.09 v1(26.35,46.87)
  BOTTOM w0.114: v2(108.43,120.01) 108.09,120.34 U35.F58
INT_HDMITX1P_C: length 5.7
  TOP w0.102: U18.14 15.7,47.53 15.45,47.28 14.94,47.28 R314.1 v1(13.76,46.87)
  BOTTOM w0.102: CN12.4 11.99,47.85 12.27,47.85 12.99,47.14 13.49,47.14 v1(13.76,46.87)
INT_HDMITX1P_C_R: length 3.7
  TOP w0.114: U18.27 22.1,47.53 22.24,47.67 22.86,47.67 23.4,47.14 24.43,47.14 C407.2
INT_HDMITX2N: length 150.2
  TOP w0.114: v1(26.33,49.72) 26.07,49.46 25.8,49.46 25.59,49.67 C408.1
  IN2 w0.114: v1(26.33,49.72) 26.61,49.44 26.76,49.44 26.87,49.54 26.87,50.02 26.66,50.22 26.08,50.22 25.65,50.65 25.65,51.8 26.87,53.02 26.87,58.1 28.44,59.67 28.44,62.52 30.86,64.94 38.66,64.94 44.56,70.84 46.03,70.84 47.47,72.27 47.47,77.45 44.24,80.68 44.24,102.24 53.72,111.72 72.74,111.72 73.19,112.16 81.17,120.14 82.12,120.14 84.28,122.3 85.1,122.3 85.45,122.65 85.45,123.34 85.83,123.72 88.07,123.72 89.89,125.54 99.32,125.54 101.26,123.6 107.28,123.6 108.8,122.09 109.61,122.09 109.93,121.77 109.93,121.35 110.01,121.27 v2(110.29,121.27)
  BOTTOM w0.114: v2(110.29,121.27) 110.29,121.28 110.14,121.43 109.89,121.43 109.81,121.35 U35.E55
INT_HDMITX2N_C: length 10
  TOP w0.102: v1(13.81,49.43) R315.2 14.74,49.22 15.45,49.22 15.64,49.03 U18.11
  IN2 w0.102: CN12.3 10.45,46.55 10.59,46.55 11.24,45.9 12.18,45.9 12.5,46.22 12.5,48.71 12.94,49.15 13.53,49.15 v1(13.81,49.43)
INT_HDMITX2N_C_R: length 4.3
  TOP w0.114: U18.30 22.1,49.03 22.24,48.89 22.91,48.89 23.26,49.23 v1(23.93,49.91) 23.93,49.68 24.22,49.38 24.39,49.38 C408.2
INT_HDMITX2P: length 150.2
  TOP w0.114: v1(26.33,48.92) 26,49.25 25.76,49.25 25.59,49.08 C411.1
  IN2 w0.114: v2(110.28,120.62) 109.71,121.18 109.71,121.68 109.52,121.88 108.71,121.88 107.19,123.39 101.17,123.39 99.23,125.33 89.98,125.33 88.27,123.62 88.16,123.5 85.92,123.5 85.67,123.25 85.67,122.56 85.18,122.08 84.37,122.08 82.21,119.92 81.25,119.92 73.34,112 72.83,111.5 53.81,111.5 44.46,102.15 44.46,80.77 47.68,77.54 47.68,72.18 46.12,70.62 44.65,70.62 38.75,64.73 30.95,64.73 28.66,62.43 28.66,59.58 27.08,58.01 27.08,52.93 25.86,51.71 25.86,50.74 26.17,50.44 26.75,50.44 27.08,50.11 27.08,49.45 26.85,49.22 26.62,49.22 v1(26.33,48.92)
  BOTTOM w0.114: v2(110.28,120.62) 110,120.34 U35.F55
INT_HDMITX2P_C: length 10
  TOP w0.102: U18.12 15.73,48.53 15.5,48.76 15.33,48.93 14.81,48.93 R315.1 v1(13.79,48.65)
  IN2 w0.102: CN12.1 10.27,46.27 10.47,46.27 11.13,45.62 12.29,45.62 12.78,46.11 12.78,48.6 13.06,48.87 13.57,48.87 v1(13.79,48.65)
INT_HDMITX2P_C_R: length 4.2
  TOP w0.114: C411.2 24.43,49.17 24.14,49.17 23.93,48.97 v1(23.93,48.64) 23.57,49 23.33,49 23,48.67 22.24,48.67 22.1,48.53 U18.29
INTRUDER#: length 36.7
  TOP w0.076: 132.86,106.17 132.84,106.19 131.65,106.19 v2(131.33,106.51)
  TOP w0.127: R249.1 130.1,74.83 v1(130.1,75.46) 130.1,76.91 129.52,77.49 129.52,86.3 132.9,89.68 132.9,97.84 134.07,99 134.07,103.14 133.53,103.68 133.53,105.66 133.12,106.07 132.96,106.07 132.86,106.17
  BOTTOM w0.127: v2(131.33,106.51) 131.69,106.15 U35.AP16
IOAC_LAN_WAKE#: length 223.4
  TOP w0.127: v1(45.47,77.08) 45.68,76.87 R715.2
  IN1 w0.14: v1(35.21,44.01) 34.79,44.44 34.79,51.93 33.53,53.18 33.53,56.36 34.91,57.73 34.91,60.66 36.25,62 36.25,63.23 37.17,64.16 37.48,64.16 38.62,65.3 39.22,65.3 42.83,68.91 42.83,69.57 43.11,69.85 43.11,75.66 44.53,77.08 v1(45.47,77.08) ; v1(174.17,38.12) 172.83,36.77 172.83,36.76 170.08,34.01 170.06,34.01 169.57,33.52 167.88,33.52 167.57,33.22 164.74,33.22 164.23,32.71 155.2,32.71 147.07,24.58 124.56,24.58 122.43,26.72 119.54,26.72 118.09,25.27 115.55,25.27 114.03,26.79 107.47,26.79 104.88,29.38 88.45,29.38 80.68,21.61 71.87,21.61 67.38,17.12 65.45,17.12 64.56,18.01 48.39,18.01 45.52,20.87 43.29,20.87 41.2,18.79 39.58,18.79 37.98,20.39 37.98,27.53 39.55,29.1 39.55,31.2 39,31.76 39,40.89 39.05,40.94 v1(39.05,41.12)
  IN2 w0.14: v1(35.21,44.01) 36.58,44.01 39.05,41.55 v1(39.05,41.12)
  BOTTOM w0.127: v1(174.17,38.12) 173.85,37.8 U45.87
IOAC_RST#: length 429.2
  TOP w0.127: v1(48.6,13.15) 48.65,13.2 48.65,15.13 48.32,15.46 48.32,16.38 49.64,17.7 49.64,23.28 47.86,25.06 47.86,26.13 44.12,29.86 37.53,29.86 36.1,31.3 v1(36.1,37.18) 36.1,41.85 31.96,45.99 31.96,54.25 30.89,55.32 30.89,57.25 31.71,58.06 32.87,58.06 33.41,57.53 35.41,57.53 37.39,59.51 37.39,61.41 35.24,63.57 R11260.1
  IN2 w0.14: v1(202.22,180.03) 203.93,178.31 203.93,173.86 204.08,173.71 204.08,172.06 204.53,171.62 204.53,169.77 204.94,169.36 204.94,166.31 205.96,165.3 205.96,163.88 206.4,163.44 206.4,162.36 208.57,160.19 214.61,160.19 215.58,159.22 220.03,159.22 223.75,155.49 223.75,109.98 217.66,103.88 217.66,103.58 214.99,100.91 214.86,100.91 213.24,99.28 213.24,85.11 216.9,81.45 216.9,71.01 216.11,70.23 216.11,68.83 215.45,68.17 215.45,66.69 214.03,65.28 214.03,62.63 212.28,60.88 212.28,59.88 211.66,59.26 211.66,55.11 212.4,54.37 212.4,47.49 208.24,43.33 206.84,43.33 206.23,42.72 206.23,42.15 205.6,41.52 203.83,41.52 203.06,42.29 202.19,42.29 200.87,43.61 194.31,43.61 190.12,47.8 189.11,47.8 188.75,47.44 188.13,47.44 187.05,46.37 187.05,39.23 184.79,36.97 182.17,36.97 181.47,37.68 179.04,37.68 178.47,38.24 177.49,38.24 177.09,37.83 176.06,37.83 175.58,37.36 v1(174.83,37.36) 173.49,36.01 172.84,36.01 170.58,33.75 169.95,33.75 168.5,32.3 167.99,32.3 166.07,30.38 159.05,30.38 153.8,25.13 151.55,25.13 151.13,24.71 125.12,24.71 122.86,22.44 113.6,22.44 111.49,24.56 111.49,25.27 110.11,26.65 109.15,26.65 108.9,26.9 108.9,28.35 106.22,31.03 88.68,31.03 81.17,23.53 77.91,23.53 76.47,22.09 72.73,22.09 69.3,18.65 69.3,17.06 66.5,14.27 60.94,14.27 58.86,12.19 55.46,12.19 54.03,13.61 53.4,13.61 52.69,12.9 48.85,12.9 v1(48.6,13.15)
  BOTTOM w0.127: v1(202.22,180.03) 202.14,180.11 R680.1 ; v1(174.83,37.36) 174.77,37.29 172.89,37.29 172.6,37 U45.85
IOAC_WLAN_WAKE#: length 198
  TOP w0.127: v1(179.12,178.69) R243.1 180.27,179.07 v1(180.27,179.55)
  IN1 w0.14: v1(158.98,134.41) 158.93,134.46 158.38,134.46 156.04,132.13 156.04,124.85 167.35,113.54 167.35,112.41 170.82,108.94 170.82,106.73 168.74,104.65 168.74,96.79 167.37,95.41 167.37,91.95 165.39,89.97 165.39,84.66 165.97,84.07 166,84.07 166.74,83.32 166.74,83.3 168.05,81.99 168.05,81.86 169.27,80.65 169.27,76.42 169.27,75.84 169.63,75.48 169.63,72.73 170.41,71.94 170.41,70.37 174.78,66.01 174.78,64.22 174.78,64.22 174.78,63.53 174.78,61.45 175.18,61.05 175.18,56.65 175.77,56.06 175.77,55.87 176.39,55.25 176.39,55.25 178.31,53.32 178.31,52.6 178.87,52.04 180.04,52.04 180.88,51.2 181.84,51.2 182.68,52.04 189.31,52.04 v1(189.77,52.5)
  IN2 w0.14: v1(182.94,37.43) 182.94,37.51 183.44,38.02 185.42,38.02 186.77,39.37 186.77,46.48 188.14,47.85 188.14,47.85 188.42,48.13 188.42,48.53 188.37,48.58 188.37,51.1 v1(189.77,52.5) ; v1(158.98,134.41) 158.98,134.82 163.76,139.59 163.76,142.97 164.01,143.23 164.01,147.85 164.75,148.58 164.75,157.88 161.8,160.83 161.8,161.23 162.21,161.64 162.21,162.05 v1(162.77,162.61)
  BOTTOM w0.127: v1(180.27,179.55) 180.12,179.39 179.36,179.39 179.27,179.31 Q23.6 179.27,178.06 179.51,177.82 180.14,177.82 180.4,177.57 180.4,176.23 179.55,175.38 R244.2 178.34,174.17 178.34,174.11 174.77,170.55 168.63,170.55 167.52,169.44 166.81,169.44 163.51,166.14 163.51,163.34 v1(162.77,162.61) ; U45.16 185.79,35.4 184.92,36.27 184.11,36.27 v1(182.94,37.43)
IRQ_SERIRQ: length 125.2
  IN1 w0.14: v1(177.08,36.28) 177.25,36.45 177.25,38.05 177.57,38.37 177.57,40.09 178.44,40.96 178.44,42.75 177.13,44.06 176.37,44.06 176.1,44.33 176.1,45.47 175.84,45.72 175.84,47.09 174.62,48.32 174.62,53.51 172.94,55.18 172.94,60.03 172.57,60.4 172.57,63.47 171.65,64.39 171.65,64.39 171.05,64.99 v1(171.05,65.81) 170.47,65.81 167.41,68.86 167.41,70.96 167.17,71.21 166.79,71.21 166.4,71.6 166.4,72.64 166.3,72.74 166.3,79.39 164.94,80.75 164.94,81.92 162.95,83.92 162.95,90.42 v1(162.08,91.28)
  BOTTOM w0.079: 135.03,101.16 134.91,101.29 134.91,101.53 134.96,101.58 134.96,101.89 134.96,101.89 134.96,102.06 U35.AY11
  BOTTOM w0.127: v1(171.05,65.81) 171.05,73.15 170.55,73.64 169.44,73.64 169.23,73.44 169.23,73.43 169.18,73.38 169.18,73.05 169.09,72.96 U44.27 ; 135.03,101.16 135.03,100.71 136.28,99.46 139.12,99.46 139.63,98.95 144.58,98.95 144.84,99.21 148.52,99.21 151.34,96.39 151.34,92.58 151.57,92.35 151.58,92.35 R629.2 153.44,90.71 153.73,90.42 153.73,89.53 154.48,88.77 156.4,88.77 158.91,91.28 v1(161.4,91.28) v1(162.08,91.28) ; v1(177.08,36.28) 178.34,36.28 178.78,36.72 180.57,36.72 181.82,37.97 181.82,38.53 184.46,41.17 185.43,41.17 185.87,40.72 185.87,40.22 186.29,39.8 U45.5
ISEN1_B: length 11.9
  TOP w0.203: PU1.9 140.6,173.82 141.79,172.64 v1(142.63,172.64) 142.65,172.64 143.06,172.23 v1(143.06,172.03) 143.08,172.05 143.08,171.48 PC18.1
  IN1 w0.305: v1(141.08,167.48) 141.08,168.98 143.06,170.96 v1(143.06,172.03)
  BOTTOM w0.305: PC18.1 143.19,171.9 v1(143.06,172.03) ; v1(141.08,167.48) 141.08,167.53 141.18,167.43 141.18,167.36 141.64,166.9 141.64,166.68 PR19.1
ISEN2_B: length 10.1
  TOP w0.203: PU1.10 141,173.93 141.23,173.71 v1(141.66,173.71) 141.99,173.38 142.67,173.38 143.77,172.28 v1(143.77,172.03)
  TOP w0.305: PC17.1 144.21,171.37 145.13,171.37 PR6301.1
  TOP w0.381: v1(143.77,172.03) 144.2,171.6 PC17.1
  BOTTOM w0.305: PR18.2 143.21,172.89 143.62,172.49 143.62,172.18 v1(143.77,172.03)
  BOTTOM w0.381: PR189.1 143.8,169.56 143.8,172 v1(143.77,172.03)
ISL95857_COMP_A: length 5.5
  TOP w0.203: PU1.16 142.64,177.12 v1(142.7,177.18) 143.41,177.18 v1(143.67,176.93) 143.67,176.62 PR199.1
  BOTTOM w0.381: v1(143.67,176.93) 142.45,176.93 142.23,177.15 PC24.2
ISL95857_COMP_B: length 4.6
  TOP w0.203: PU1.4 138.6,173.24 v1(138.33,172.97) 137.45,172.08 v1(137.45,171.98)
  TOP w0.305: v1(137.45,171.98) 136.84,171.37 PC21.2
  BOTTOM w0.305: v1(137.45,171.98) 137.39,171.98 137.34,171.93 137.34,171.93 PR195.1
ISL95857_COMP_C: length 7.5
  TOP w0.203: PU1.24 139.8,180.51 140.29,180.99 v1(140.54,180.99)
  TOP w0.381: PR216.1 142.42,181.88 v1(142.06,181.52) 141.64,181.1 140.65,181.1 v1(140.54,180.99)
  BOTTOM w0.381: v1(140.54,180.99) 139.93,180.99 138.54,179.6 PC37.2
ISL95857_FB_A: length 7.9
  TOP w0.203: PU1.17 142.34,177.52 142.87,178.05 143.41,178.05 144.35,177.12 PR36.1
  TOP w0.254: v1(147.91,175.43) 147.56,175.78 147.56,175.87 PR34.1 147.27,176.17 146.72,176.72 PR201.1 145.94,176.45 144.76,176.45 144.35,176.86 PR36.1
ISL95857_FB_B: length 5.6
  TOP w0.203: v1(138.31,171.98) 138.31,172.21 139,172.9 PU1.5
  TOP w0.305: v1(138.31,171.98) 137.8,171.47 PR24.1 137.83,171.38 PR23.1
  BOTTOM w0.305: v1(138.31,171.98) 137.8,171.47 PR24.1
ISL95857_FB_C: length 8.3
  TOP w0.203: v1(140.72,181.68) 140.49,181.68 139.4,180.59 PU1.25
  TOP w0.305: v1(140.72,181.68) 141.36,182.32 PR44.1
  BOTTOM w0.381: v1(140.72,181.68) 140.82,181.68 141.36,182.21 PR44.1 PR45.1 142.58,182.43 142.99,182.84 142.99,183.21 143.24,183.46 v1(144,183.46)
ISL95857_FCCM_A: length 1.7
  TOP w0.203: v1(141.84,179.65) 141.63,179.43 PU1.21
  BOTTOM w0.203: v1(141.84,179.65) 141.65,179.84 PR42.1
ISL95857_FCCM_B: length 3.9
  TOP w0.203: v1(142.63,174.06) 142.63,174.61 142.12,175.12 PU1.11
  BOTTOM w0.203: PR26.2 142.92,174.06 v1(142.63,174.06)
ISL95857_FCCM_C: length 1.4
  TOP w0.127: PR46.1 137.47,180.26 137.8,179.93 PU1.29
ISL95857_IMON_A: length 5.3
  TOP w0.203: PU1.14 142.55,176.32 143.29,175.58 v1(143.47,175.58) 143.54,175.58 144.18,174.95 PC23.1
  BOTTOM w0.305: v1(143.47,175.58) v1(142.45,175.58) 141.85,176.18 PR202.1
ISL95857_IMON_B: length 4.1
  TOP w0.203: PU1.2 137.8,173.88 v1(137.32,173.4)
  BOTTOM w0.305: v1(135.63,174.23) PC22.1 136.51,174.25 PR198.1
  BOTTOM w0.381: PR198.1 137.5,173.55 137.32,173.37 v1(137.32,173.4)
ISL95857_IMON_C: length 2.9
  TOP w0.203: PU1.23 140.2,180.2 v1(140.37,180.36)
  BOTTOM w0.381: PR207.1 PC36.1 140.47,180.26 v1(140.37,180.36)
ISL95857_ISUMN_A: length 7.4
  TOP w0.203: PU1.20 142.1,178.72 142.5,179.12 142.5,180.87 143.82,182.19 v1(144.13,182.19) 145.21,182.19 PC34.2
  TOP w0.305: PC34.2 145.54,182.52 PR211.1
ISL95857_ISUMN_B: length 4.7
  TOP w0.203: PU1.8 140.2,173.56 v1(140.34,173.4) v1(141.74,172.03)
  TOP w0.305: PC19.1 142.13,171.54 141.74,171.93 v1(141.74,172.03)
  BOTTOM w0.305: v1(141.74,172.03) 141.74,171.35 PR192.2
ISL95857_ISUMN_C: length 6.3
  TOP w0.203: v1(138.13,180.26) 138.2,180.19 PU1.28
  TOP w0.381: v1(138.13,180.26) 138.23,180.36 v1(138.23,182.04) 138.23,182.31 PR220.1
  BOTTOM w0.381: v1(138.13,180.26) 138.31,180.44 138.31,182.23 PR220.1
ISL95857_NTC_A: length 20.1
  TOP w0.203: PU1.15 142.41,176.72 142.48,176.65 142.91,176.65 v1(143.21,176.35)
  IN1 w0.203: v1(143.21,176.35) 139.63,172.77 139.63,171.67 139.07,171.11 137.85,171.11 136.77,170.03 136.73,170.03 136.44,169.74 136.44,169.7 136.3,169.56 136.3,166.21 137.31,165.21 137.31,165.12 v1(137.58,164.85)
  BOTTOM w0.203: v1(137.58,164.85) 137.66,164.77 v1(137.66,163.77) PR235.1
  BOTTOM w0.305: PR236.1 137.63,162.53 137.66,162.55 PR235.1
ISL95857_NTC_B: length 19.9
  TOP w0.203: v1(126.98,164.74) 127.11,164.74 127.87,165.5 v1(127.87,166.31) 127.87,167.3 130.56,170 135.97,170 136.3,170.33 136.3,171.62 138.2,173.52 PU1.3
  BOTTOM w0.203: PR227.1 126.45,164.21 v1(126.98,164.74)
  BOTTOM w0.305: PR226.1 PR227.1
ISL95857_PROG1: length 3.5
  TOP w0.203: v1(135.72,178.84) 135.72,178.68 136.08,178.32 PU1.32
  BOTTOM w0.203: v1(135.72,178.84) 135.72,178.68 136.21,178.19 PR203.1 v1(136.84,178.92)
ISL95857_PROG2: length 1.5
  TOP w0.203: PU1.31 136.37,178.72 136.25,178.84 136.25,179.22 135.96,179.51 PR206.1
ISL95857_PSYS: length 1.3
  TOP w0.203: PU1.1 136.9,174.41 136.51,174.01 PR25.1
ISL95857_PWM1_B: length 4.2
  TOP w0.203: PR27.2 v1(143.21,173.77) 143.16,173.82 143.16,174.54 142.18,175.52 PU1.12
ISL95857_PWM2_B: length 3.6
  TOP w0.203: PR29.2 144.04,173.96 143.62,174.38 143.62,174.62 142.32,175.92 PU1.13
ISL95857_PWM_A: length 2.4
  TOP w0.203: v1(141,180.51) 141,180.31 140.82,180.13 140.82,180.13 140.6,179.91 PU1.22
  BOTTOM w0.203: v1(141,180.51) 141,180.82 141.56,181.38 PR43.1
ISL95857_PWM_C: length 2
  TOP w0.127: PU1.30 137.4,179.87 137.32,179.95 v1(136.71,179.95) 136.51,180.16 PR47.1
ISL95857_RTN_A: length 13.4
  TOP w0.203: PC27.2 v1(143.59,179.32) 143.59,179.24 142.27,177.92 PU1.18
  TOP w0.305: v1(146.98,175.5) 147.43,175.05 147.43,173.92 PR38.1 147.4,173.87 PC29.2 PR39.1
  TOP w0.381: v1(144.46,179.95) 144.35,179.84 PC27.2
  BOTTOM w0.305: v1(146.98,175.5) 146.84,175.64 146.84,176.27 145.8,177.31 145.8,178.61 v1(144.46,179.95)
ISL95857_RTN_B: length 11.6
  TOP w0.203: PC10.2 138.93,167.79 139.58,168.44 v1(139.58,172.36) 139.4,172.54 PU1.6
  TOP w0.305: PR181.2 135.62,166.53 PC12.2 136.43,166.47 136.71,166.19 137.82,166.19 PR180.1 138.15,166.69 138.93,167.47 PC10.2
ISL95857_RTN_C: length 12.7
  TOP w0.203: 140.34,182.1 140.34,182 139.07,180.73 139.07,180.01 139,179.94 PU1.26
  TOP w0.305: PR52.1 143.49,187.47 143.42,187.4 PC44.2 PR49.1 v1(141,187.4) 141,187.4 140.11,186.51 140.11,185.41 140.32,185.21 PC45.2 140.62,185.02 140.62,182.38 140.34,182.1
ISL95857_SCLK: length 3.5
  TOP w0.127: PU1.37 136.22,176.32 v1(134.98,175.08) 134.55,174.64 PR35.2
ISL95857_SDA: length 3.4
  TOP w0.127: PR40.1 134.23,175.57 v1(135.29,176.63) 135.63,176.97 135.8,176.97 135.95,177.12 PU1.35
ISL95857_VCC: length 3.7
  TOP w0.203: PU1.34 135.98,177.52 135.69,177.24 v1(135.24,177.24)
  TOP w0.508: v1(135.24,177.24) 134.93,177.24 134.65,176.96 PR204.2
  BOTTOM w0.508: PC32.1 136.01,177.24 v1(135.24,177.24)
ISL95857_VIN: length 4.5
  TOP w0.203: v1(135.57,178.02) 135.67,177.92 PU1.33
  TOP w0.381: v1(134.02,178.35) 134.28,178.09 PC35.1 135.5,178.09 v1(135.57,178.02)
  BOTTOM w0.508: v1(135.57,178.02) 135.54,178 134.83,178 134.39,177.56 PR212.1
ISL95857_VR_EN: length 5.5
  TOP w0.127: PR28.2 133.92,172.06 134.45,172.59 135.45,172.59 v1(135.47,172.56) 135.47,172.83 135.3,173 135.3,173.44 135.92,174.05 135.92,174.87 136.17,175.12 PU1.40
ISL95857_VR_HOT: length 3.9
  TOP w0.127: PR32.2 134.37,173.76 135.44,174.82 135.44,175.15 136.21,175.91 136.68,175.91 PU1.38
ISL95857_VR_READY: length 4.2
  TOP w0.127: PU1.39 136.14,175.52 135.67,175.05 135.67,174.44 v1(135.01,173.78) 134.09,172.87 PR30.2
ISOLATEB: length 8.2
  TOP w0.127: U15.31 38.1,69.05 37.69,68.64 37.69,68.26 37.55,68.11 v1(37.55,65.68) 37.55,64.82 R11262.1 37.25,64.52 37.67,64.14 37.67,63.06 37.67,62.49 R11263.2
ISUMN_A: length 47.3
  TOP w0.305: PR208.1 148.15,185.49 v1(147.45,185.49) 147.3,185.49 147.16,185.35 PC33.1 147.16,184.5 147.4,184.25 PR41.2 ; PR41.2 147.55,183.42 147.91,183.05 v1(148.01,183.05) ; PR41.2 147.33,183.48 PR211.2 ; v1(146.64,178.43) 147.06,178.85 PR214.1 146.49,179.84 PC31.1 146.46,180.68 PC30.2
  IN1 w0.203: v1(146.64,178.43) 146.18,178.43 145.04,177.29 145.04,174.19 145.57,173.65 145.57,171.52 144.18,170.12 144.18,168.73 143.29,167.84 143.29,166.87 140.26,163.85 137.67,163.85 133.97,160.14 133.97,153.59 v1(134.17,153.39)
  BOTTOM w0.203: v1(148.01,183.05) 148.01,179.8 v1(146.64,178.43) ; PR243.2 134.17,152.91 v1(134.17,153.39)
ISUMN_B: length 53.9
  TOP w0.305: PR21.1 141.35,169.12 140.98,169.48 PR22.1 140.98,171.37 PC20.2 141,172 v1(141.03,172.03) ; PR21.1 140.82,168.28 PC14.1 ; PR21.1 141.35,168.51 141.79,168.07 v1(142.07,168.07) 143.06,168.07 143.49,168.5 143.49,170.29 PC18.2 PC17.2
  IN2 w0.203: v1(116.13,151.99) 116.06,152.06 116.06,153.69 118.5,156.13 118.5,159.76 118.99,160.25 118.99,160.59 120.58,162.17 123.2,162.17 124.72,163.7 128.94,163.7 131.25,166.01 131.25,167.53 133.25,169.54 134.8,169.54 135.39,170.12 137.24,170.12 137.95,170.83 139.83,170.83 v1(141.03,172.03)
  BOTTOM w0.203: v1(116.13,151.99) 116.05,152.07 PR241.1
  BOTTOM w0.305: PC134.2 141.05,172.15 141.03,172.13 v1(141.03,172.03) 141.03,171.28 PR192.1 141.07,171.13 140.45,170.51 PR182.1 140.38,169.87 139.86,169.87 139.27,169.29 PR17.1
ISUMN_C: length 57.6
  TOP w0.305: PR220.2 137.88,183.52 PC39.1
  TOP w0.381: PC39.1 138.96,181.82 v1(138.92,181.78)
  IN2 w0.203: v1(146.87,152.98) 146.77,152.98 146.37,153.37 146.37,161.45 151.69,166.77 151.69,183.46 150.07,185.08 143.69,185.08 141.51,182.9 139.3,182.9 138.87,182.47 138.87,181.83 v1(138.92,181.78)
  BOTTOM w0.254: PR242.2 147.44,152.62 147.33,152.62 147,152.95 146.95,152.95 146.92,152.98 v1(146.87,152.98)
  BOTTOM w0.381: PR221.1 138.14,187.4 138.64,186.9 v1(138.64,186.35) 138.64,185.81 PC43.1 PR48.2 138.39,184.49 138.39,183.87 138.84,183.41 PC38.2 PC39.1 138.96,181.82 v1(138.92,181.78)
ISUMP_A: length 12.7
  TOP w0.203: PC30.1 145.28,181.71 143.81,181.71 142.86,180.76 142.86,178.99 142.19,178.32 PU1.19
  TOP w0.305: PC30.1 146.46,181.46 PC31.2 146.52,181.45 147.5,181.45 PR205.2 148.17,182.13 PR215.1
  TOP w0.381: PR215.1 148.75,182.77 148.62,182.9 148.62,183.31 v1(148.16,183.76) PR208.2
ISUMP_B: length 11.5
  TOP w0.203: v1(140.24,172.08) 140.24,172.54 139.8,172.97 PU1.7
  TOP w0.305: v1(140.26,169.06) 140.26,169.16 140.06,169.36 v1(140.06,169.67) 140.06,170.23 PR22.2 140.22,170.39 PC20.1 140.24,171.41 v1(140.24,172.08)
  BOTTOM w0.305: v1(140.26,169.06) 140.26,169.01 140.48,168.79 PR190.1 140.3,168.04 139.37,168.04 138.88,167.56 PR20.1 ; PR193.2 139.34,170.6 140.24,171.5 v1(140.24,172.08) 140.27,172.11 PC134.1
ISUMP_C: length 8.7
  TOP w0.203: PU1.27 138.6,180 138.74,180.14 138.74,180.86 139.71,181.83 139.71,182.41 PC39.2
  TOP w0.381: v1(140.06,184.03) 139.76,183.73 139.76,183.42 PR218.2 PC39.2
  BOTTOM w0.381: v1(139.74,181.7) PC39.2 PR218.2 139.76,183.42 139.76,183.73 v1(140.06,184.03) 139.91,184.19 139.91,184.69 PR222.1
JTAG_TCK: length 10
  BOTTOM w0.127: U3002.AM10 170.13,126.15 169.73,125.75 165.92,125.75 162.97,122.8 R4332.2 162.78,121.97 TP4300.1
JTAG_TDI: length 8.5
  BOTTOM w0.127: R4331.2 163.13,126.64 163.13,126.8 TP4303.1
  BOTTOM w0.14: TP4303.1 164.07,126.86 167.41,126.86 167.99,127.44 169.73,127.44 U3002.AM11
JTAG_TDO: length 3.8
  BOTTOM w0.127: U3002.AP12 167.27,127.84 166.75,127.32 166.35,127.32 TP4305.1
JTAG_TMS: length 6.9
  BOTTOM w0.127: U3002.AP11 168,126.51 165.03,126.51 TP4301.1 164.55,125.6 164.04,125.09 162.85,125.09 R4330.2
JTAG_TRST#: length 7.9
  BOTTOM w0.127: R4334.2 163.1,123.82 TP4307.1
  BOTTOM w0.14: U3002.AN11 168.42,126.13 165.92,126.13 164.27,124.48 TP4307.1
KB_BL_LED: length 164.5
  TOP w0.127: v1(214.31,37.43) v1(214.31,38.09) 214.31,38.6 211.38,41.52 208.69,41.52 207.07,43.15 206.33,43.15 205.52,43.96 194.27,43.96 193.43,44.8 193.43,47.1 192.61,47.91 191,47.91 189.87,49.04 189.31,49.04 189.06,49.3 188.55,49.3 187.81,50.03 185.48,50.03 183.94,48.5 182.85,48.5 182.54,48.19 182.01,48.19 181.53,47.71 180.39,47.71 179.95,47.26 v1(179.81,47.26)
  IN1 w0.14: v1(230.59,117.57) 230.05,117.04 230.05,113.48 230.38,113.15 230.38,112.47 229.95,112.03 229.95,105.64 228.81,104.5 228.81,100.52 227.34,99.05 222.64,99.05 218.9,95.32 218.9,89.18 220.38,87.7 220.38,67.02 219.26,65.9 219.26,63.44 219.67,63.03 222.69,63.03 223.22,62.5 225.53,62.5 227.21,60.81 227.21,54.41 v1(226.21,53.41)
  IN2 w0.14: v1(226.21,53.41) 224.19,51.38 221.48,51.38 217.66,47.56 217.66,40.49 214.6,37.43 v1(214.31,37.43)
  BOTTOM w0.127: v1(230.59,117.57) 228.58,117.57 228.28,117.88 228.28,119.65 229.04,120.42 229.04,122.7 226.62,125.11 224.59,125.11 Q19.2 ; v1(179.81,47.26) 179.69,47.14 179.69,45 179.51,44.83 179.51,44.06 179.58,43.99 U45.113
L_SPK+: length 152.2
  IN2 w1.016: 198.18,31.39 196.35,29.56 196.35,27.87 195.08,26.6 195.08,23.31 192.46,20.7 181.46,20.7 181.33,20.7 179.92,19.29 176.14,19.29 173.01,16.15 173.01,12.51 172.35,11.86 163.12,11.86 162.46,12.52 145.73,12.52 144.74,13.51 136.47,13.51 135.67,12.71 127.88,12.71 126.14,10.97 107.73,10.97 103.99,14.7 103.99,20.34 100.89,23.44 91.88,23.44 83.08,14.64 74.31,14.64 73.39,15.56
  vias: v1(73.03,17.22) v1(73.01,16.53) v1(198.98,31.73) v1(199.64,31.73)
L_SPK+_1:
  vias: v1(72.6,13.51) v1(73.26,13.51) v1(77.76,10.26)
L_SPK-: length 147.5
  IN2 w1.016: 75.22,15.79 82.58,15.79 91.39,24.61 101.38,24.61 105.15,20.84 105.15,15.18 108.21,12.12 125.6,12.12 127.36,13.89 135.01,13.89 135.79,14.68 142.98,14.68 143,14.66 145.21,14.66 146.19,13.69 162.98,13.69 163.59,13.08 167.72,13.08 168.42,13.77 168.98,13.77 175.6,20.39 175.61,20.39 175.66,20.44 179.44,20.44 180.85,21.85 180.98,21.85 180.98,21.85 181.37,21.85 181.39,21.86 191.98,21.86 193.83,23.72 193.83,26.99 195.13,28.29 195.13,31.24 196.25,32.35 197.21,32.35
  vias: v1(74.2,17.19) v1(74.22,16.53) v1(199,32.52) v1(199.66,32.52)
L_SPK-_1:
  vias: v1(74.02,13.74) v1(74.53,13.33) v1(77.76,11.73)
LAN_MCT0: length 2.4
  TOP w0.762: R251.2 23.56,89.2 23.58,89.2 23.58,89.22 v1(23.59,89.22)
  BOTTOM w0.508: U42.24 23.74,88.4 23.59,88.55 v1(23.59,89.22)
LAN_MCT1: length 2.9
  TOP w0.762: R11265.2 22.87,85.49 22.78,85.4 v1(22.37,85.4)
  BOTTOM w0.508: U42.21 v1(22.37,85.4)
LAN_MCT2: length 2.9
  TOP w0.762: v1(22.37,82.4) 22.37,82.39 22.44,82.32 R262.2
  BOTTOM w0.508: U42.18 v1(22.37,82.4)
LAN_MCT3: length 3
  TOP w0.762: R269.2 22.89,79.27 22.76,79.4 v1(22.35,79.4)
  BOTTOM w0.508: U42.15 v1(22.35,79.4)
LAN_MX0+: length 38.5
  TOP w0.102: v1(16.6,105.83) 16.31,106.11 16.31,107.08 15.11,108.29 13.68,108.29 13.37,107.97 CN11.1
  BOTTOM w0.102: U42.14 23.12,78.4 22.76,78.05 22.46,78.05 18.88,81.63 18.88,96.55 15.42,100 15.42,103.11 16.31,104 16.31,105.54 v1(16.6,105.83)
LAN_MX0-: length 38.5
  TOP w0.102: v1(15.74,105.83) 16.02,106.11 16.02,106.96 14.99,108 13.82,108 13.62,107.79 13.62,107.18 CN11.2
  BOTTOM w0.102: U42.13 23.18,77.4 22.83,77.75 22.34,77.75 18.59,81.51 18.59,96.43 15.13,99.88 15.13,103.23 16.02,104.12 16.02,105.54 v1(15.74,105.83)
LAN_MX1+: length 33
  TOP w0.102: v1(17.14,102.86) 16.9,103.1 16.9,104.19 16.16,104.92 15.17,104.92 14.16,105.93 CN11.3
  BOTTOM w0.102: v1(17.14,102.86) 16.86,102.57 16.86,100.34 20.12,97.08 20.12,82.19 21.27,81.05 22.66,81.05 23.01,81.4 U42.17
LAN_MX1-: length 33
  TOP w0.102: v1(16.28,102.86) 16.53,102.86 16.6,102.93 16.6,104.06 16.04,104.63 14.88,104.63 14.28,104.03 13.95,104.03 13.85,103.93 CN11.6
  BOTTOM w0.102: v1(16.28,102.86) 16.57,102.57 16.57,100.22 19.83,96.96 19.83,82.07 21.14,80.75 22.66,80.75 23.01,80.4 U42.16
LAN_MX2+: length 33.8
  BOTTOM w0.102: CN11.4 13.6,104.66 13.6,104.21 13.73,104.07 14.29,104.07 14.75,104.53 14.75,106.15 15.55,106.95 16.77,106.95 18.26,105.47 18.26,104.91 v1(18.75,104.41) 18.26,103.92 18.26,100.6 21.29,97.56 21.29,84.83 22.08,84.05 22.66,84.05 23.01,84.4 U42.20
LAN_MX2-: length 33.8
  BOTTOM w0.102: U42.19 23.01,83.4 22.66,83.75 21.95,83.75 21,84.71 21,97.44 17.96,100.48 17.96,103.93 v1(17.48,104.41) 17.96,104.9 17.96,105.35 16.65,106.66 15.67,106.66 15.04,106.03 15.04,104.41 14.41,103.78 12.86,103.78 CN11.5
LAN_MX3+: length 25
  TOP w0.102: v1(21.08,100.4) 20.8,100.68 20.8,100.95 20.38,101.37 15.57,101.37 14.94,102 13.56,102 13.42,101.85 CN11.7
  BOTTOM w0.102: v1(21.08,100.4) 20.8,100.11 20.8,99.8 22.54,98.06 22.54,87.22 22.71,87.05 22.87,87.05 23.23,87.4 U42.23
LAN_MX3-: length 25
  TOP w0.102: v1(20.22,100.4) 20.5,100.68 20.5,100.83 20.26,101.07 15.45,101.07 14.82,101.7 13.73,101.7 13.57,101.54 13.57,101.11 CN11.8
  BOTTOM w0.102: v1(20.22,100.4) 20.5,100.11 20.5,99.68 22.24,97.94 22.24,87.1 22.59,86.75 22.87,86.75 23.23,86.4 U42.22
LAN_XTAL2: length 5.7
  TOP w0.14: U15.45 41.73,73.66 41.79,73.6 42.01,73.6 42.22,73.81 42.48,73.81 C4605.2 43.27,74.02 44.97,74.02 45.14,74.19 45.14,74.59 Y1.3
LAN_XTALI: length 6.2
  TOP w0.14: U15.44 41.73,73.26 41.79,73.33 42.12,73.33 42.33,73.54 42.62,73.54 C4606.2 43.24,73.18 43.81,73.75 45.48,73.75 Y1.1
LANE0_N: length 2.2
  TOP w0.114: U13.6 26.35,68.95 26.44,68.85 26.49,68.85 27,69.36 27.23,69.36 C331.2
LANE0_P: length 2.2
  TOP w0.114: U13.5 26.36,68.55 26.45,68.64 26.58,68.64 27.09,69.15 27.31,69.15 C335.2
LANE1_N: length 5.2
  TOP w0.102: 27.85,71.9 28.29,71.46 28.57,71.46 C315.2
  TOP w0.114: 27.85,71.9 v1(27.79,71.97) 27.79,71.96 27.23,71.39 27.09,71.39 26.64,70.94 26.64,69.71 26.59,69.65 26.44,69.65 26.34,69.75 U13.8
LANE1_P: length 5.2
  TOP w0.102: C329.2 28.5,71.26 28.36,71.26 v1(27.79,70.7)
  TOP w0.114: U13.7 26.33,69.35 26.42,69.44 26.68,69.44 26.85,69.62 26.85,70.85 27.18,71.18 27.31,71.18 v1(27.79,70.7)
LANPWR#: length 215.8
  TOP w0.127: v1(49.18,13.46) 49.18,14.96 48.57,15.57 48.57,16.27 49.89,17.59 49.89,23.39 48.11,25.17 48.11,26.23 44.03,30.32 41.54,30.32 v1(41.03,30.83) ; v1(49.99,64.28) 50.04,64.23 50.93,64.23 v1(50.98,64.28) 51.14,64.43 51.14,70.31 R259.1 R260.2
  IN1 w0.14: v1(49.99,64.28) 48.16,62.45 45.36,62.45 44.91,62.9 44.91,63.32 44.45,63.78 43.1,63.78 39.3,59.98 39.3,53.75 39.95,53.1 39.95,41 40.33,40.62 40.33,34.61 39.86,34.13 39.86,33.34 40.01,33.19 40.44,33.19 40.77,32.86 40.77,31.94 40.54,31.71 40.54,31.32 v1(41.03,30.83)
  IN2 w0.14: v1(165.84,32.16) 165.55,32.16 164.38,30.98 158.87,30.98 153.57,25.69 151.32,25.69 150.9,25.27 124.13,25.27 122.61,23.74 119.49,23.74 119.17,24.06 119.17,24.4 117.51,26.05 114.78,26.05 113.62,27.21 110.46,27.21 106.36,31.31 88.56,31.31 81.06,23.81 77.79,23.81 76.35,22.37 72.62,22.37 69.02,18.77 69.02,17.18 66.39,14.55 60.76,14.55 58.68,12.47 55.57,12.47 54.15,13.89 53.28,13.89 52.85,13.46 v1(49.18,13.46)
  BOTTOM w0.127: U45.70 170.18,31 169.49,31.69 168.18,31.69 167.52,32.35 166.08,32.35 165.88,32.16 v1(165.84,32.16)
LANVCC: length 2.8
  TOP w0.203: U15.48 41.37,74.86 41.52,75.01 41.52,75.4 v1(41.38,75.53) 41.08,75.84
  TOP w0.508: v1(41.08,77.01) 41.08,75.84
  vias: v1(35.46,77.06) v1(38.18,66.24) v1(38.18,65.58) v1(42.2,81.31) v1(42.53,81.86) v1(43.44,64.29)
LCDVCC:
  vias: v1(114.97,160.19) v3(116.16,160.98) v3(116.92,161.03)
LCDVCC_R:
  vias: v1(116.54,164.87) v3(117.4,164.31) v3(117.68,165.02)
LID#: length 446
  TOP w0.127: R53.2 111.6,152.68 D1.1 111.18,151.66 110.9,151.38 v1(110.9,150.87) ; v1(80.24,19.83) 80.83,19.25 80.83,16.1 79.36,14.62 v1(78.8,14.62) 78.29,14.62 77.7,14.04 77.7,10.61 78.13,10.19 R11129.1 ; v1(36.1,44.6) 37.12,43.58 37.12,41.65 37.75,41.02 v1(37.98,41.02) ; D23.2 14.58,90.1 15.8,88.87 15.8,78.91 v1(15.78,78.89) ; v1(19.95,42.08) 20.22,41.8 21.8,41.8 23.58,43.58 v1(28.02,43.58)
  IN1 w0.14: v1(110.9,150.87) 110.9,149.98 108.06,147.14 108.06,146.7 99.27,137.92 99.27,137.05 98.77,136.56 98.49,136.56 89.41,127.48 84.59,127.48 66.03,108.92 49.19,108.92 45.65,105.38 45.65,84.78 45,84.13 45,80.01 47.63,77.38 47.63,71.71 46.62,70.7 46.62,70.25 43.41,67.05 41.76,67.05 39.46,64.75 38.85,64.75 38.12,64.02 38.12,63.08 35.49,60.45 35.49,57.47 34.09,56.08 34.09,53.55 35.43,52.21 35.43,52.07 35.36,52 35.36,45.33 v1(36.1,44.6) ; v1(37.98,41.02) 38.28,40.71 38.28,29.33 37.09,28.14 37.09,19.83 39.27,17.65 43.61,17.65 44.37,16.89 59.99,16.89 60.92,15.96 67.89,15.96 72.39,20.47 79.61,20.47 v1(80.24,19.83) 80.66,19.83 89.07,28.25 104.44,28.25 107.01,25.67 113.54,25.67 117.47,21.74 124.01,21.74 125.39,23.12 138.35,23.12 139.35,22.12 148.42,22.12 156.52,30.22 157.28,30.22 157.66,29.84 169.25,29.84 169.85,29.24 171.06,29.24 175.34,33.52 179.38,33.52 179.94,34.08 179.94,39.92 180.57,40.56 180.57,40.8 182.61,42.83 182.61,45.26 182.8,45.45 182.8,46.85 183.27,47.31 v1(183.27,49.12) ; v1(15.78,78.89) 15.78,78.3 17.58,76.5 17.58,75.1 18.75,73.93 20.12,73.93 21.24,72.82 21.24,70.33 19.74,68.83 19.74,58.41 20.55,57.6 20.55,45.03 19.95,44.42 v1(19.95,42.08)
  IN2 w0.14: v1(36.1,44.6) 29.04,44.6 v1(28.02,43.58)
  BOTTOM w0.127: v1(183.27,49.12) 182.89,48.74 182.89,48.47 R460.2
