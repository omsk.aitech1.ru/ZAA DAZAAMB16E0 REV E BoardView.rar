# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMB_DQ36: length 20.2
  IN2 w0.102: 208.99,138.27 208.99,138.48 208.99,138.48 208.99,138.81 208.99,139.28 208.99,139.28 208.99,139.61 208.99,139.84 v2(209.4,140.25)
  IN2 w0.14: v1(193.91,135.74) 194.84,135.74
  IN2 w0.17: 208.99,138.27 208.99,138.21 208.77,137.99 208.77,137.33 208.59,137.15 207.94,137.15 207.12,136.34 201.76,136.34 201.12,135.71 197.29,135.71 196.91,135.33 195.25,135.33 194.84,135.74
  BOTTOM w0.127: U3002.D21 193.53,135.35 v1(193.91,135.74)
  BOTTOM w0.152: v2(209.4,140.25) 209.8,140.65 U4.N4
VMB_DQ37: length 21.4
  IN2 w0.14: v2(193.15,135.74) 193.67,135.22
  IN2 w0.17: v2(209.4,138.65) 209.4,138.09 209.15,137.84 209.15,137.18 208.51,136.54 208.08,136.54 206.61,135.07 201.22,135.07 200.36,134.21 198,134.21 197.01,133.22 196.53,133.22 194.52,135.22 193.67,135.22
  BOTTOM w0.127: v2(193.15,135.74) 192.75,135.34 U3002.E21
  BOTTOM w0.152: U4.N2 209.8,139.05 v2(209.4,138.65)
VMB_DQ38: length 27.1
  IN2 w0.102: v2(210.2,140.25) 210.6,139.85 210.6,138.27
  IN2 w0.14: 194.11,134.57 192.69,134.57 v2(191.47,135.79)
  IN2 w0.17: 210.6,138.27 210.6,136.9 207.93,134.23 201.61,134.23 200.74,133.37 198.46,133.37 197.52,132.43 196.25,132.43 194.11,134.57
  BOTTOM w0.127: U3002.G21 v2(191.47,135.79)
  BOTTOM w0.152: U4.M4 210.53,140.65 210.2,140.31 v2(210.2,140.25)
VMB_DQ39: length 23.5
  IN2 w0.14: v2(192.29,135.75) 193.11,134.94
  IN2 w0.17: v2(210.2,138.65) 210.2,137.29 207.57,134.66 201.45,134.66 200.62,133.83 198.3,133.83 197.31,132.84 196.37,132.84 194.27,134.94 193.11,134.94
  BOTTOM w0.127: U3002.F21 v2(192.29,135.75) ; v2(210.2,138.65) 210.6,139.05 U4.M2
VMB_DQ40: length 19.1
  IN2 w0.14: v2(191.47,140.76) 192.27,139.97 194.35,139.97 194.95,140.57 196.68,140.57
  IN2 w0.17: 196.68,140.57 197.43,141.32 198.8,141.32 201.11,143.63 204.18,146.71 206.14,146.71 v2(206.2,146.65)
  BOTTOM w0.127: U3002.G27 191.45,140.76 v2(191.47,140.76)
  BOTTOM w0.152: U4.U11 v2(206.2,146.65)
VMB_DQ41: length 16.5
  IN2 w0.14: v1(193.91,140.76) 194.1,140.76 194.66,141.32
  IN2 w0.17: 194.66,141.32 195.28,141.32 196.09,142.13 197.97,142.13 204.09,148.25 v2(206.2,148.25)
  BOTTOM w0.127: U3002.D27 193.91,140.72 v1(193.91,140.76)
  BOTTOM w0.152: v2(206.2,148.25) U4.U13
VMB_DQ42: length 19.8
  IN2 w0.14: 195.11,140.2 194.5,139.6 191.78,139.6 v1(191.42,139.95)
  IN2 w0.17: v2(207,146.65) 206.52,146.17 204.3,146.17 198.98,140.85 197.58,140.85 196.93,140.2 195.11,140.2
  BOTTOM w0.127: U3002.G26 191.42,139.94 v1(191.42,139.95)
  BOTTOM w0.152: v2(207,146.65) U4.T11
VMB_DQ43: length 18.5
  IN2 w0.102: 205.9,147.82 205.92,147.85 206.6,147.85 v2(207,148.25)
  IN2 w0.14: v2(193.15,140.76) 193.58,140.34 194.2,140.34 194.81,140.95
  IN2 w0.17: 194.81,140.95 195.47,140.95 196.35,141.83 198.56,141.83 204.55,147.82 205.9,147.82
  BOTTOM w0.127: v2(193.15,140.76) 193.15,140.76 U3002.E27
  BOTTOM w0.152: v2(207,148.25) U4.T13
VMB_DQ44: length 23.6
  IN2 w0.102: 208.99,149.35 208.99,149.21 208.99,149.21 208.99,148.88 208.99,148.41 208.99,148.41 208.99,148.08 208.99,147.61 208.99,147.61 208.99,147.28 208.99,147.05 v2(209.4,146.65)
  IN2 w0.17: v2(193.12,142.42) 193.17,142.46 194.59,142.46 196.35,144.22 197.31,144.22 203.36,150.26 208.21,150.26 208.99,149.48 208.99,149.35
  BOTTOM w0.102: U3002.E29 192.75,142.04 v2(193.12,142.42)
  BOTTOM w0.152: v2(209.4,146.65) U4.N11
VMB_DQ45: length 23.9
  IN2 w0.102: 209.79,149.34 209.79,148.64 v2(209.4,148.25)
  IN2 w0.14: 193.8,142.77 193.7,142.87 192.69,142.87 v2(192.33,142.51)
  IN2 w0.17: 209.79,149.34 208.44,150.69 203.21,150.69 197.2,144.69 196.31,144.69 194.39,142.77 193.8,142.77
  BOTTOM w0.102: v2(192.33,142.51) 191.91,142.09 U3002.F29
  BOTTOM w0.152: v2(209.4,148.25) U4.N13
VMB_DQ46: length 26.9
  IN2 w0.102: v2(210.2,146.65) 211.4,147.85 211.4,149.35
  IN2 w0.14: v2(193.1,143.4) 193.4,143.71 194.29,143.71
  IN2 w0.17: 211.4,149.35 209.28,151.48 202.82,151.48 196.97,145.63 196.21,145.63 194.29,143.71
  BOTTOM w0.102: v2(193.1,143.4) 192.73,143.03 U3002.E30
  BOTTOM w0.152: v2(210.2,146.65) U4.M11
VMB_DQ47: length 23
  IN2 w0.102: 210.6,149.27 210.6,148.65 v2(210.2,148.25)
  IN2 w0.17: v2(193.99,143.28) 194.42,143.28 196.3,145.16 197.08,145.16 203,151.07 208.79,151.07 210.6,149.27
  BOTTOM w0.102: v2(193.99,143.28) 193.55,142.84 U3002.D30
  BOTTOM w0.152: v2(210.2,148.25) U4.M13
VMB_DQ48: length 33.4
  BOTTOM w0.127: U3002.A32 196.07,144.54
  BOTTOM w0.152: 196.07,144.54 196.78,145.25 196.78,145.46 203.49,152.17 218.24,152.17 220.68,149.73 220.68,146.98 219.94,146.25 U4.A11
VMB_DQ49: length 31.6
  BOTTOM w0.127: U3002.C31 194.7,144.07 195.61,144.07 195.7,143.98 196.19,143.98 196.33,144.12 197.02,144.12
  BOTTOM w0.152: U4.A13 219.86,148.31 219.86,149.44 217.91,151.38 203.82,151.38 197.62,145.18 197.62,144.71 197.02,144.12
VMB_DQ50: length 37.6
  BOTTOM w0.127: 196.36,145.23 196.06,144.93 194.72,144.93 U3002.C32
  BOTTOM w0.152: 196.36,145.23 196.36,145.6 203.33,152.57 218.41,152.57 221.11,149.86 221.11,146.78 220.16,145.83 219.01,145.83 U4.B11
VMB_DQ51: length 33.1
  BOTTOM w0.102: U3002.B32 195.44,144.54 195.79,144.2 196.11,144.2 196.24,144.33
  BOTTOM w0.127: 196.24,144.33 196.39,144.49 196.68,144.49
  BOTTOM w0.152: U4.B13 219,147.44 219.64,147.44 220.27,148.08 220.27,149.58 218.08,151.77 203.66,151.77 197.21,145.33 197.21,145.02 196.68,144.49
VMB_DQ52: length 26.8
  BOTTOM w0.127: U3002.D29 193.97,141.6 195.45,141.6 195.57,141.48 196.16,141.48 196.38,141.7 196.81,141.7 197.06,141.45 198.07,141.45
  BOTTOM w0.152: U4.E11 216.59,145.86 216.59,145.26 216.69,145.16 216.69,144.6 216.11,144.01 201.25,144.01 198.79,141.55 198.18,141.55 198.07,141.45
VMB_DQ53: length 25.1
  BOTTOM w0.127: U3002.A29 196.05,142.16 196.32,142.16 196.37,142.21 197.75,142.21
  BOTTOM w0.152: 197.75,142.21 v1(203.07,147.53) 205.04,149.5 214.36,149.5 214.99,148.86 214.99,147.67 215.19,147.47 215.81,147.47 U4.E13
VMB_DQ54: length 26.8
  BOTTOM w0.127: 197.48,142.59 196.33,142.59 196.18,142.44 194.73,142.44 U3002.C29
  BOTTOM w0.152: 197.48,142.59 v1(203.69,148.81) 204.79,149.9 215.58,149.9 215.83,149.65 215.83,148.28 U4.F13
VMB_DQ55: length 23.7
  BOTTOM w0.102: U3002.B29 195.44,142.04 195.79,141.7 196.07,141.7 196.3,141.93 197.09,141.93 197.14,141.88
  BOTTOM w0.127: 197.14,141.88 198.1,141.88
  BOTTOM w0.152: U4.F11 215.75,145.89 215.75,144.85 215.32,144.42 201.07,144.42 198.63,141.98 198.2,141.98 198.1,141.88
VMB_DQ56: length 31.2
  BOTTOM w0.127: 196.29,135.55 196.13,135.71 195.64,135.71 195.27,135.34 U3002.B21
  BOTTOM w0.152: U4.A4 220.62,139.43 220.62,137.52 217.61,134.52 205.28,134.52 204.02,135.78 197.71,135.78 197.48,135.55 196.29,135.55
VMB_DQ57: length 28.8
  BOTTOM w0.127: U3002.C23 194.7,136.67 195.28,136.67 195.28,136.67 195.74,136.67 195.74,136.67
  BOTTOM w0.152: U4.A2 219.82,138.62 219.82,137.95 217.19,135.31 205.74,135.31 204.07,136.98 v1(203.64,136.98) 198.25,136.98 197.95,136.67 195.74,136.67
VMB_DQ58: length 32.9
  BOTTOM w0.127: U3002.A21 196,135.26 197.85,135.26
  BOTTOM w0.152: U4.B4 219.01,141.07 220.38,141.07 221.01,140.43 221.01,137.31 217.83,134.12 205.07,134.12 203.93,135.26 v1(203.54,135.26) 197.85,135.26
VMB_DQ59: length 32.2
  BOTTOM w0.127: U3002.C21 194.33,135.03 194.45,134.91 194.69,134.91 194.75,134.97 194.75,135.56 194.93,135.74 195.21,135.74 195.41,135.94 196.21,135.94 196.21,135.94 196.23,135.94 196.33,135.83 197.03,135.83
  BOTTOM w0.152: U4.B2 219.01,139.47 219.77,139.47 220.22,139.01 220.22,137.76 217.37,134.91 205.47,134.91 204.17,136.21 197.41,136.21 197.03,135.83
VMB_DQ60: length 22.9
  BOTTOM w0.102: 196.75,138.25 196.55,138.25 196.3,138.5 195.56,138.5 195.13,138.07 U3002.B24
  BOTTOM w0.152: 196.75,138.25 197.11,138.25 197.72,138.86 205.03,138.86 206.71,137.18 214.23,137.18 214.99,137.94 214.99,138.64 U4.F2
VMB_DQ61: length 25.4
  BOTTOM w0.102: 195.51,137.99 195.51,137.56 195.38,137.43 194.62,137.43 194.33,137.73 U3002.C24
  BOTTOM w0.127: 195.51,137.99 195.75,138.22 196.23,138.22 196.59,137.87
  BOTTOM w0.152: U4.E2 215.78,138.63 215.78,137.46 215.09,136.77 206.51,136.77 204.83,138.45 197.87,138.45 197.29,137.87 196.59,137.87
VMB_DQ62: length 23.6
  BOTTOM w0.127: U3002.B26 195.41,139.54 195.79,139.92
  BOTTOM w0.152: U4.E4 216.2,140.71 215.94,140.96 215.93,140.96 215.78,141.12 215.78,142.16 215.53,142.41 205.9,142.41 203.4,139.92 v1(203,139.92) 195.79,139.92
VMB_DQ63: length 23.2
  BOTTOM w0.152: U3002.C26 194.34,139.54 194.59,139.29 194.82,139.29 194.96,139.15 196.09,139.15 196.41,139.46 v1(201.81,139.46) 203.63,139.46 206.1,141.93 214.66,141.93 215.02,141.57 215.02,141.09 215.4,140.71 U4.F4
VMB_WCK01: length 19.8
  IN2 w0.14: v2(192.29,124.1) 192.76,124.57 193.99,124.57 194.28,124.28 195.55,124.28 196.63,123.21 198.71,123.21 199.73,124.23 207.95,124.23 208.74,125.02 208.74,125.44 v2(208.58,125.6)
  BOTTOM w0.14: U3.D4 208.58,125.6 v2(208.58,125.6)
  BOTTOM w0.178: U3002.F8 192.29,124.13 v2(192.29,124.1)
VMB_WCK01#: length 19.8
  IN2 w0.14: v2(209.38,125.6) 209.26,125.72 209.12,125.72 209,125.6 209,124.91 208.06,123.97 199.83,123.97 198.82,122.96 196.52,122.96 195.45,124.03 194.18,124.03 193.89,124.32 193.22,124.32 193.15,124.25 v1(193.15,124.1)
  BOTTOM w0.152: v2(209.38,125.6) U3.D5
  BOTTOM w0.178: U3002.E8 192.73,124.52 v1(193.15,124.1)
VMB_WCK23: length 24.2
  BOTTOM w0.14: U3.P4 217.43,125.55 217.43,124.58 216.27,123.41 205.11,123.41 204.33,122.63 197.07,122.63 196.59,122.16 196.05,122.16 U3002.A5
VMB_WCK23#: length 24.2
  BOTTOM w0.14: U3.P5 217.11,125.2 217.19,125.11 217.19,124.7 216.16,123.67 205.01,123.67 204.22,122.89 196.98,122.89 196.49,122.4 195.64,122.4 195.51,122.53 195.51,122.83 195.64,122.96 195.81,122.96 U3002.A6
VMB_WCK45: length 24.3
  IN2 w0.14: v1(193.96,138.28) 193.96,138.61 194.1,138.75 194.97,138.75 195.56,139.34 197.11,139.34 197.64,139.87 199.42,139.87 202.37,142.82 205.29,142.82 205.58,143.11 205.58,143.43 205.71,143.56 205.97,143.56 206.1,143.43 206.1,143.11 206.39,142.82 206.84,142.82 207.13,143.11 207.13,144.62 207.26,144.75 207.52,144.75 207.65,144.62 207.65,143.11 207.94,142.82 208.46,142.82 208.97,142.31 208.97,141.24 208.77,141.04 v2(208.62,141.04)
  BOTTOM w0.14: U4.P4 209,140.67 v2(208.62,141.04)
  BOTTOM w0.178: v1(193.96,138.28) U3002.D24
VMB_WCK45#: length 24.3
  IN2 w0.14: v2(193.94,139.14) 194.07,139 194.87,139 195.46,139.59 197,139.59 197.54,140.13 199.32,140.13 202.26,143.07 205.19,143.07 205.32,143.21 205.32,143.53 205.6,143.81 206.08,143.81 206.35,143.53 206.35,143.21 206.49,143.07 206.73,143.07 206.87,143.21 206.87,144.73 207.15,145 207.63,145 207.9,144.73 207.9,143.21 208.04,143.07 208.57,143.07 209.3,142.34 209.3,141.14 v2(209.4,141.05)
  BOTTOM w0.14: v2(209.4,141.05) U4.P5
  BOTTOM w0.178: U3002.D25 193.94,139.1 v2(193.94,139.14)
VMB_WCK67: length 25.4
  BOTTOM w0.102: 196.34,140.62 196.32,140.62 196.31,140.64 196.24,140.64 196.19,140.68 195.39,140.68 195.35,140.64 195.18,140.64 195.13,140.59 U3002.B27
  BOTTOM w0.14: 196.34,140.62 199.35,140.62 201.81,143.07 216.16,143.07 216.64,142.59 216.64,141.22 216.77,141.09 217,141.09 217.13,140.96 217.13,140.77 217,140.65 U4.D4
VMB_WCK67#: length 25.4
  BOTTOM w0.102: 196.34,140.87 196.31,140.9 195.32,140.9 195.27,140.85 195.08,140.85 194.57,140.34 U3002.C27
  BOTTOM w0.14: U4.D5 216.9,141.55 216.9,142.69 216.27,143.33 201.7,143.33 199.25,140.87 196.34,140.87
VR_SVID_ALERT#_VCORE: length 76
  TOP w0.127: v1(104.63,150.16) 104.63,152.65 104.97,152.99 105.59,153.62 105.59,154.77 107.68,159.46 107.68,160.1 109.72,162.15 110.18,162.15 112.72,164.69 113.93,164.69 115.65,166.42 117.94,166.42 118.73,165.63 121.11,165.63 124.39,168.9 124.39,171.09 129.3,176 131.67,176 v1(132.14,175.53) 132.52,175.15 134.42,175.15 135.99,176.72 PU1.36
  BOTTOM w0.127: R552.2 R134.2 95.04,131.59 94.42,131.59 92.56,133.45 92.56,136.25 95.15,138.83 96.08,138.83 101.57,144.32 101.57,145.85 104.63,148.9 v1(104.63,150.16)
VREF_CA_DIMM0: length 1.5
  BOTTOM w0.203: v1(125.39,44.64) 125.47,44.56 JDIM1.164
  vias: v1(125.36,43.68)
VREF_CA_DIMM1: length 11.5
  TOP w0.508: R10935.2 117.11,56.33 117.51,55.93 124.48,55.93 v1(124.85,56.3) v1(125.39,56.84)
  BOTTOM w0.203: JDIM2.164 125.47,56.76 v1(125.39,56.84)
VREF_VMA1_MOS: length 55.9
  TOP w0.254: R1513.1 164.59,165.17 v1(163.56,165.17) v1(162.49,165.17)
  IN1 w0.254: v1(162.49,165.17) 162.74,165.17 167.62,170.05 190.43,170.05 191.62,168.85 200.72,168.85 v1(204.44,165.13)
  BOTTOM w0.254: Q129.3 206.99,160.11 206.99,164.23 206.73,164.49 R1410.1
  BOTTOM w0.305: R1410.1 205.79,165.13 v1(204.44,165.13)
VREF_VMA3_MOS: length 53.5
  IN1 w0.254: v1(216.29,154.25) 220.02,150.51 220.02,143.17 220.81,142.39 220.81,116.5 v1(217.61,113.3)
  BOTTOM w0.254: v1(217.61,113.3) 217.96,112.95 v1(217.96,112.53) 217.46,112.02 R1330.1 ; v1(216.29,154.25) 216.24,154.21 R1297.1 215.58,154.96 215.12,155.42 210.83,155.42 Q115.3
VREFC_VMA1: length 9.9
  IN1 w0.254: v1(204.53,162.83) 203.84,162.15 200.67,162.15 200.33,161.81 v2(199.74,161.81)
  BOTTOM w0.254: R1410.2 R1417.2 205.37,163.22 205.15,163.01 R1416.2 ; U5.J14 199.35,161.42 v2(199.74,161.81) ; R1416.2 204.91,162.45 v1(204.53,162.83) ; R1416.2 C1432.1
VREFC_VMA2: length 8.2
  TOP w0.254: v1(165.55,166.04) R1513.2 R1509.2 R1508.2 C1551.1 165.66,161.94 166.27,162.55 v1(166.38,162.55)
  BOTTOM w0.381: U7.J14 168.67,161.39 168.53,161.26 167.9,161.26 166.6,162.55 v1(166.38,162.55)
VREFC_VMC1: length 9.8
  IN1 w0.254: v1(214.05,113.3) 213.8,113.56 213.8,116.86 213.38,117.27
  IN1 w0.305: 213.38,117.27 v2(213.38,117.6)
  BOTTOM w0.254: C1409.1 213.55,112.8 v1(214.05,113.3) 214.55,112.8 R1337.2 R1331.2 R1330.2 v1(216.97,113.58)
  BOTTOM w0.305: v2(213.38,117.6) U3.J14
VREFC_VMC2: length 9.4
  IN1 w0.254: v1(212.12,153.74) 212.12,151.68 213.4,150.41 v2(213.4,149.05)
  BOTTOM w0.254: v1(212.12,153.74) 212.43,153.43 C1416.1 R1367.2 R1381.2 R1297.2
  BOTTOM w0.305: v2(213.4,149.05) U4.J14
VRON: length 14.8
  IN1 w0.14: v1(160.81,31.49) 165.28,31.49 165.49,31.69 166.15,31.69 166.27,31.82 v1(166.43,31.82)
  BOTTOM w0.127: v1(160.81,31.49) 160.67,31.63 R792.2 159.55,31.63 159.36,31.44 158.4,31.44 158.26,31.58 U50.1 ; U45.69 170.21,30.6 170.06,30.75 R463.1 169.48,31.02 169.09,31.42 168.1,31.42 167.85,31.67 v1(167.27,31.67) 166.58,31.67 v1(166.43,31.82)
VRON_R: length 590
  TOP w0.127: PR136.1 49.51,83.15 v1(49.31,82.95) ; v1(132.26,172.08) 132.49,171.85 PR28.1 ; v1(160.53,28.75) 160.53,28.7 160.84,28.39 160.84,26.99 v1(160.56,26.72) 160.56,26.44 158.5,24.38 v1(158.5,24.05)
  IN1 w0.14: v1(49.31,82.95) 47.55,82.95 46.79,82.19 46.79,81 47.05,80.74 48.08,80.74 49.49,79.34 49.49,69.41 44.51,64.43 42.96,64.43 38,59.48 38,53.31 39.11,52.2 39.11,43.04 37.32,41.24 37.32,38.07 37.7,37.69 37.7,31.53 36.84,30.67 36.84,29.29 36.1,28.55 36.1,18.71 38.44,16.38 40.52,16.38 v1(43.63,13.27)
  IN2 w0.14: v1(43.63,13.27) 44.58,12.31 53.88,12.31 54.86,11.33 59.32,11.33 61.37,13.38 66.81,13.38 70.16,16.73 70.16,18.32 73.09,21.25 76.83,21.25 78.26,22.69 81.53,22.69 89.04,30.2 105.87,30.2 108.06,28 108.06,26.56 108.81,25.81 109.76,25.81 110.65,24.92 110.65,24.21 113.27,21.58 123.2,21.58 125.43,23.82 140.24,23.82 142.14,21.91 151.55,21.91 152.26,22.63 153.66,22.63 157.07,22.63 v1(158.5,24.05) 158.67,23.89 159.55,23.89 162.65,26.99 168.58,26.99 174.85,33.27 182.56,33.27 182.73,33.09 183.92,33.09 184.25,33.42 186.31,33.42 187.75,34.87 190.81,34.87 194.27,38.33 200.67,38.33 200.82,38.18 205.43,38.18 205.72,38.47 207.17,38.47 209.05,40.34 209.6,40.34 210.78,41.52 213.35,41.52 215.8,43.97 215.8,50.97 215.96,51.13 215.96,52.39 215.23,53.12 215.23,55.36 214.36,56.23 214.36,58.13 214.99,58.76 214.99,59.75 217.56,62.33 217.56,64.45 218.22,65.11 218.22,67.01 220.75,69.54 220.75,86.69 218.29,89.16 218.29,95.36 222.69,99.77 227.23,99.77 228.91,101.44 228.91,105.24 230.18,106.51 230.18,111.55 228.13,113.6 228.13,159.04 225.02,162.15 225.02,166.48 232.25,173.7 232.25,188.68 229.57,191.36 211.51,191.36 210.37,190.22 206.69,190.22 205.89,191.01 202.78,191.01 194.52,182.75 192.58,182.75 190.22,180.39 187.57,180.39 187.29,180.11 184.94,180.11 184.26,180.79 179.41,180.79 177.04,183.16 177.04,184.39 176.22,185.21 168,185.21 164.8,188.41 158.68,188.41 156.85,186.58 144.79,186.58 144.15,187.22 140.37,187.22 139.81,186.66 139.81,185.57 138.39,184.14 138.39,181.3 136.66,179.57 135.44,179.57 134.77,178.9 134.77,175.09 136.58,173.27 136.58,172.1 135.57,171.09 134.42,171.09 133.43,172.08 v1(132.26,172.08)
  BOTTOM w0.127: U50.4 156.96,33.11 157.13,32.94 158.8,32.94 159.33,32.41 R792.1 160.78,32.41 161.3,31.9 161.3,31.19 160.56,30.45 160.56,28.77 v1(160.53,28.75) ; PR196.2 132.29,172.1 v1(132.26,172.08)
VSA_SENSE: length 106.5
  TOP w0.076: 126.93,122.4 127.13,122.19 127.13,121.1 127.22,121.01 127.22,120.29 127.16,120.23 127.16,119.65 127.63,119.17 v2(127.63,118.51)
  TOP w0.127: PR50.2 145.46,186.72 148.36,186.72 149.03,186.04 149.03,184.04 v1(149.23,183.84) ; v1(154.11,140.35) 154.36,140.1 154.36,137.24 148.39,131.26 142.57,131.26 140.34,129.03 136.38,129.03 134.71,130.7 132.64,130.7 131.1,129.16 R122.2 130.74,128.88 130.74,128.45 129.69,127.4 128.93,127.4 126.93,125.4 126.93,122.4
  IN2 w0.14: v1(149.23,183.84) 149.89,183.18 149.89,182.52 149.5,182.12 149.5,180.17 149.55,180.12 149.55,176.05 150.09,175.51 150.09,172.94 149.55,172.4 149.55,166.89 145.07,162.4 145.07,144.44 148.98,140.53 153.93,140.53 v1(154.11,140.35)
  BOTTOM w0.114: U35.H20 129.58,118.7 128.49,118.7 128.24,118.45 127.69,118.45 v2(127.63,118.51)
VSASS_SENSE: length 105.7
  TOP w0.076: 127.31,122.47 127.3,122.46 127.3,121.17 127.39,121.08 127.39,120.22 127.33,120.16 127.33,119.72 127.66,119.38 v2(128.59,119.38)
  TOP w0.127: v1(155,140.35) 154.74,140.1 154.74,137.08 148.55,130.88 142.73,130.88 140.49,128.65 136.23,128.65 134.55,130.32 132.8,130.32 131.73,129.25 R109.1 131.46,128.16 130.99,128.16 129.85,127.02 129.09,127.02 127.31,125.24 127.31,122.47 ; v1(149.89,183.87) 149.41,184.35 149.41,186.2 148.51,187.1 145.52,187.1 PR52.2
  IN2 w0.14: v1(149.89,183.87) 150.29,183.47 150.29,182.35 149.89,181.96 149.89,180.33 149.94,180.28 149.94,176.22 150.49,175.67 150.49,172.78 149.94,172.23 149.94,166.72 145.46,162.24 145.46,144.61 149.09,140.98 149.19,140.98 149.21,140.96 154.39,140.96 v1(155,140.35)
  BOTTOM w0.114: U35.H21 128.67,119.38 v2(128.59,119.38)
VSTBY_FSPI: length 5.3
  BOTTOM w0.127: R11118.1 175.82,47.05 175.82,46.19 R11119.1 176.07,45.47 v1(176.33,45.21) 176.51,45.21 177.02,44.7 177.02,44.34 176.78,44.1 U45.106
VSYNC: length 25.2
  TOP w0.127: U37.2 v1(10.47,87.4) ; R11192.1 18.84,69.65 v1(18.42,70.07)
  IN2 w0.14: v1(10.47,87.4) 10.47,87.52 10.47,86.89 11.23,86.13 11.23,82.95 10.6,82.32 10.6,76.6 11.49,75.71 12.25,75.71 13.39,74.57 13.39,73.68 17,70.07 v1(18.42,70.07)
  BOTTOM w0.127: v1(10.47,87.4) 10.21,87.66 R11270.2
VSYNC_C: length 2
  TOP w0.127: U13.18 20.52,69.35 v1(20.46,69.4) 20.38,69.49 R11192.2
WIFI_SUSCLK: length 5.2
  BOTTOM w0.127: U43.4 200.71,183.16 R714.1 200.21,181.64 200.21,180.11 199.85,179.75 CN10.50
WLAN_CLKREQ#: length 19
  TOP w0.114: v1(177.5,180.41) 177.72,180.19 R245.1 177.73,179.72 v1(177.73,178.96) R253.2
  BOTTOM w0.114: CN10.53 181.53,179 180.5,180.03 179.41,180.03 178.47,180.97 177.81,180.97 177.5,180.66 v1(177.5,180.41) 177.5,179.68 177.97,179.22 Q23.4
WLAN_RST#: length 4.1
  BOTTOM w0.127: CN10.52 200.67,179.25 C821.2 R680.2 R671.2
WLAN_WAKE_R#: length 15.6
  TOP w0.127: v1(179.03,177.18) 179.75,177.91 R243.2 ; R243.2 180.41,177.91 v1(180.88,177.44) ; R243.2 179.9,177.9 v1(179.9,177.08) R242.1
  BOTTOM w0.127: Q23.1 179.27,176.93 179.52,177.18 179.8,177.18 v1(179.9,177.08) ; CN10.55 190.14,178.5 189.92,178.28 181.72,178.28 v1(180.88,177.44)
WLANPWR#: length 239.3
  TOP w0.127: R231.2 R230.1 v1(204.28,190.52) R712.2 R710.1
  IN2 w0.14: v1(204.28,190.52) 204.89,189.91 210.62,189.91 211.77,191.06 229.46,191.06 231.96,188.56 231.96,180.73 231.97,180.73 231.97,179.84 231.96,179.83 231.96,173.81 224.75,166.59 224.75,161.89 227.83,158.81 227.83,113.51 229.85,111.49 229.85,106.63 225.35,102.13 224.57,102.13 217.94,95.5 217.94,89.09 220.45,86.58 220.45,69.64 217.94,67.13 217.94,65.6 216.46,64.12 216.46,61.62 214.71,59.87 214.71,58.87 214.08,58.25 214.08,56.12 214.95,55.25 214.95,53 215.68,52.27 215.68,51.25 215.53,51.09 215.53,44.09 213.24,41.8 210.67,41.8 209.49,40.62 208.93,40.62 207.6,39.29 207.58,39.29 207.04,38.75 205.6,38.75 205.32,38.46 200.93,38.46 200.74,38.65 194.2,38.65 191.43,35.88 188.37,35.88 186.19,33.7 184.13,33.7 183.8,33.37 182.85,33.37 182.37,33.85 v1(182.3,33.85)
  BOTTOM w0.127: U45.35 184.78,28.34 184.4,28.72 183.17,28.72 182.3,29.59 v1(182.3,33.85)
WRST#: length 100.9
  IN1 w0.14: v1(210.57,66.82) 209.86,66.11 209.86,62.68 208.46,61.28 207.98,61.28 207.49,60.79 207.49,59.82 208.03,59.28 208.03,55.57 206.61,54.15 201.95,54.15 200.02,56.07 196.73,56.07 193.14,59.67 192.55,59.67 191.87,60.35 189.62,60.35 189.24,60.73 185.45,60.73 v1(181.29,64.89)
  BOTTOM w0.127: v1(181.29,64.89) 181.58,65.18 184.17,65.18 184.46,64.9 184.46,62.95 189.85,57.57 189.85,56.53 193.12,53.26 193.12,51.61 190.58,49.07 190.58,47.37 193.5,44.44 193.5,38.32 D12.2 192.73,37.55 192.73,36.48 R368.1 190.42,35.96 C491.1 190.18,36.26 190.02,36.42 189.16,36.42 188.78,36.04 188.22,36.04 188.06,36.2 U45.14 ; Q56.6 218.1,69.98 217.94,69.82 216.36,69.82 216.16,69.62 216.16,67.23 v1(215.94,67.01) 215.5,67.01 215.49,67 211.19,67 211.02,66.82 v1(210.57,66.82)
XCLK_BIASREF: length 7.6
  BOTTOM w0.076: 117.8,122.73 117.8,122.28 117.61,122.09 117.35,122.09 117.12,121.86 U35.E42
  BOTTOM w0.127: 117.8,122.73 117.8,123.65 118.93,124.79 118.93,126.72 119.01,126.79 v1(119.01,126.82) 118.81,127.01 R512.1
XDP_BPM#0: length 9.1
  BOTTOM w0.076: U35.C55 109.36,122.85 109.36,123.92 109.21,124.06 109.21,125.36 109.02,125.55 109.02,127.4 108.54,127.88
  BOTTOM w0.127: TP89.1 108.11,130.35 108.77,129.69 108.77,128.92 108.54,128.7 108.54,127.88
XDP_BPM#1: length 8.9
  BOTTOM w0.076: 109.02,129.81 109.02,128.8 108.77,128.54 108.77,127.91 109.2,127.48 109.2,125.62 109.38,125.44 109.38,124.13 109.53,123.98 109.53,123.11 109.76,122.88 109.76,122.6 109.47,122.31 U35.D55
  BOTTOM w0.127: TP90.1 109.02,130.17 109.02,129.81
XDP_BPM#2: length 5.4
  BOTTOM w0.076: TP64.1 109.4,128.04 109.4,125.75 109.54,125.61 109.54,124.2 109.69,124.05 109.69,123.45 110.03,123.11 U35.B54
XDP_BPM#3: length 6.7
  BOTTOM w0.076: 108.1,125.54 108.55,125.09 108.55,124.32 108.47,124.23 108.47,123.57 108.5,123.5 108.5,123 108.91,122.59 U35.C56
  BOTTOM w0.127: TP62.1 107.27,127.5 108.1,126.68 108.1,125.54
XDP_PRDY#: length 8.3
  BOTTOM w0.076: 108.78,126.42 108.78,125.56 109.05,125.29 109.05,123.99 109.19,123.85 109.19,122.97 109.17,122.94 109.17,122.56 109.22,122.51 109.22,122.31 109.06,122.15 109.06,121.92 U35.D56
  BOTTOM w0.114: 108.78,126.42 108.78,127.06
  BOTTOM w0.127: 108.78,127.06 108.78,127.13 108.31,127.6 108.31,129.18 TP91.1
XDP_PREQ#: length 7
  BOTTOM w0.076: U35.D61 106.13,122.06 106.13,122.39 106.06,122.46 106.06,123.19 106.02,123.24 106.02,123.52 106,123.56 105.99,123.57 105.99,124.14 106.05,124.2 106.05,124.35
  BOTTOM w0.127: TP92.1 103.94,127.02 105.46,125.51 105.63,125.51 106.05,125.09 106.05,124.35
XDP_TCK0: length 25.6
  IN1 w0.14: v1(105.85,131.21) 105.85,130.68 105.13,129.97 102.65,129.97 v1(101.78,130.83)
  BOTTOM w0.076: 106.33,124.15 106.16,123.97 106.16,123.62 106.18,123.55 106.18,123.31 U35.B61 ; 107.19,126.44 107.42,126.21 107.42,123.85 U35.A59
  BOTTOM w0.127: 107.19,126.44 106.23,127.4 106.23,128.29 105.85,128.67 v1(105.85,131.21) ; 106.33,124.15 106.33,125.14 104.7,126.77 104.7,127.53 104.07,128.16 102.61,128.16 102.05,128.72 v1(101.99,128.72) 101.89,128.72 101.28,129.33 R558.2 101.52,129.42 101.78,129.69 v1(101.78,130.83) 101.78,130.95 R513.1
XDP_TCK1: length 7.2
  BOTTOM w0.076: U35.B56 108.66,123.31 108.66,123.55 108.63,123.62 108.63,124.17 108.72,124.25 108.72,125.15 108.32,125.55 108.32,126.75
  BOTTOM w0.127: 108.32,126.75 108.32,126.83 107.8,127.35 107.8,128.61 R537.2
XDP_TDI: length 15.3
  BOTTOM w0.076: U35.D59 107.55,121.98 107.93,122.36 107.93,122.79 108.01,122.97 108.01,123.1 107.94,123.33 107.94,123.47 108,123.64 108,124 107.77,124.24 107.77,125.35 107.87,125.46 107.87,126.12
  BOTTOM w0.127: 107.87,126.12 107.87,126.52 106.74,127.65 106.74,128.54 106.36,128.92 106.36,130.58 106.61,130.83 106.61,131.85 105.97,132.48 105.49,132.48 v1(105.19,132.18) R515.2 104.32,131.3 R796.1
XDP_TDI_CPU: length 8.7
  BOTTOM w0.076: U35.D60 106.99,122.27 107.28,122.56 107.28,122.94 107.07,123.16 107.07,125.8 106.86,126
  BOTTOM w0.127: R796.2 105.72,128.03 105.72,127.15 106.86,126
XDP_TDO: length 15.8
  IN1 w0.14: v1(102.88,131.85) 104.2,131.85 104.83,132.48 106.48,132.48 107.12,131.85 v1(107.12,131.59)
  BOTTOM w0.076: 108.55,126.65 108.55,125.55 108.88,125.22 108.88,123.74 U35.A56
  BOTTOM w0.127: v1(107.12,131.59) 107.37,131.59 107.58,131.39 107.58,129.18 108.06,128.7 108.06,127.48 108.55,126.98 108.55,126.65 ; v1(102.88,131.85) 102.68,131.85 R559.2 R795.1
XDP_TDO_CPU: length 8.1
  BOTTOM w0.076: 106.41,125.39 106.53,125.27 106.53,123.82 U35.A61
  BOTTOM w0.127: 106.41,125.39 104.96,126.84 104.96,127.65 104.2,128.42 103.13,128.42 102.29,129.26 R795.2
XDP_TMS: length 14.9
  IN1 w0.14: v1(105.85,131.97) 105.01,131.97 103.87,130.83 v1(103.49,130.83)
  BOTTOM w0.076: 107.64,125.86 107.64,125.52 107.59,125.47 107.59,124.16 107.84,123.91 107.84,123.67 107.78,123.5 107.78,123.31 107.84,123.08 107.84,123 107.76,122.83 107.76,122.62 U35.C59
  BOTTOM w0.127: v1(105.85,131.97) 106.36,131.46 106.36,130.96 106.1,130.7 106.1,128.8 106.48,128.42 106.48,127.53 107.64,126.37 107.64,125.86 ; R514.2 103.46,130.86 v1(103.49,130.83) 103.31,130.65 R797.1
XDP_TMS_CPU: length 8.7
  BOTTOM w0.076: 106.7,125.79 106.88,125.61 106.88,122.85 U35.C60
  BOTTOM w0.127: 106.7,125.79 105.47,127.02 105.47,127.91 104.45,128.92 103.59,128.92 103.31,129.2 R797.2
XTAL24_IN: length 15.7
  IN2 w0.14: v2(119.43,121.34) 119.43,122.5 118.88,123.06 118.88,128.92 118.22,129.59 v1(118.22,129.64)
  BOTTOM w0.114: U35.E37 119.52,121.34 v2(119.43,121.34)
  BOTTOM w0.14: v1(118.22,129.64) 118.22,129.71 117.4,130.53 R536.1 117.4,131.23 C665.2 116.78,133.62 Y4.3
XTAL24_OUT: length 13.6
  IN2 w0.127: 120.21,121.4 v2(120.26,121.34)
  IN2 w0.14: v1(118.93,129.59) 118.93,129.28 119.16,129.05 119.16,127.26 119.1,127.2 119.1,123.19 120.21,122.08 120.21,121.4
  BOTTOM w0.114: v2(120.26,121.34) 120.43,121.34 U35.E35
  BOTTOM w0.14: v1(118.93,129.59) 118.93,129.71 118.18,130.47 R536.2 118.18,131.08 117.9,131.35 C658.2 117.9,132.99 Y4.1
XTAL27_IN: length 11.7
  BOTTOM w0.14: Y4200.1 193.71,112.39 193.71,113.71 194.19,114.19 C4207.2 193.71,114.69 193.71,115.47 193.17,116.01 192.49,116.01 190.79,117.71 190.79,119.06 190.51,119.33 190.51,119.96 U3002.H3
XTAL27_OUT: length 8.6
  BOTTOM w0.14: Y4200.3 192.92,113.4 C4206.2 193.35,114.67 193.35,115.49 193.07,115.77 192.39,115.77 190.53,117.62 190.53,118.88 190.13,119.28 U3002.H2
XTAL_OUTBUFF: length 12.2
  TOP w0.127: R4210.2 R4211.2 188.46,111.96 188.46,113.75 v1(188.52,113.81) 189.54,114.83 189.54,118.64 188.89,119.28 v1(188.89,120.77)
  BOTTOM w0.102: v1(188.89,120.77) 189.26,121.14 U3002.J4
XTAL_SSIN: length 7.2
  BOTTOM w0.14: U3002.H1 190.13,118.64 190.02,118.53 190.02,116.38 191.24,115.16 v1(191.24,114.8) 191.24,112.3 R4212.2
N62917: length 1.3
  TOP w0.381: v2(102.75,119.41) 102.27,119.41 R158.2
  BOTTOM w0.254: v2(102.75,119.41) 103.05,119.1 U35.H66
N62945: length 1.5
  TOP w0.381: R162.2 103.06,120.03 v1(103.66,119.42)
  BOTTOM w0.254: v1(103.66,119.42) 103.85,119.42 U35.H65
N62977: length 49.1
  TOP w0.127: v1(157.51,75.81) 157.97,75.36 157.97,74.88 R635.2
  IN1 w0.14: v1(157.51,75.81) 156.6,76.73 156.6,78.13 154.59,80.14 154.59,84.2 151.67,87.12 151.67,90.57 150.48,91.76 150.48,96.03 148.11,98.39 137.5,98.39 133.22,102.67 133.22,102.99 133.13,103.09 133.13,103.09 132.67,103.55 132.67,104.76 v2(132.21,105.22)
  BOTTOM w0.114: U35.AT16 131.86,104.85 132.21,105.2 v2(132.21,105.22)
N62981: length 48.6
  TOP w0.127: v1(157.51,75.15) 157.71,74.95 157.71,74.78 157.92,74.57 R646.2
  IN1 w0.132: 131.72,103.42 131.59,103.54 131.59,104.16 131.88,104.45 v2(132.21,104.45)
  IN1 w0.14: v1(157.51,75.15) 156.27,76.4 156.27,78.07 154.31,80.02 154.31,84.09 151.39,87.01 151.39,90.45 150.74,91.1 149.84,91.1 148.42,89.68 145.19,89.68 141.47,93.4 141.47,95.1 138.61,97.96 137.2,97.96 133.38,101.79 133.16,101.79 132.57,102.38 131.72,103.23 131.72,103.42
  BOTTOM w0.127: v2(132.21,104.45) 131.96,104.2 U35.AU16
N74227: length 7.8
  TOP w0.127: R174.2 142.92,113.3 v1(142.5,113.3) 141.94,113.3 141.85,113.39 141.45,113.39 141.2,113.64 140.31,113.64 140.25,113.58 137.5,113.58 137.13,113.22 v2(137.13,113.14)
  BOTTOM w0.127: U35.AB7 137.13,112.84 v2(137.13,113.14)
N108264: length 18.7
  BOTTOM w0.079: 137.09,100.68 136.78,100.99 136.78,102.18 136.61,102.35 136.38,102.35 135.92,102.82 U35.AW9
  BOTTOM w0.127: R623.2 151.26,98.17 v1(150.49,98.94) 149.43,99.99 144.48,99.99 144.33,99.84 139.88,99.84 139.45,100.28 137.49,100.28 137.09,100.68
N108478: length 25.2
  BOTTOM w0.079: 134.69,100.41 134.42,100.68 134.42,101.24 134.69,101.51 U35.BA11
  BOTTOM w0.127: C806.1 150.83,91.06 150.83,96.01 148.14,98.7 145.09,98.7 144.84,98.44 139.38,98.44 138.87,98.95 136.15,98.95 134.69,100.41
N109188: length 20.5
  BOTTOM w0.079: U35.AY9 135.92,102.16 136.18,101.89 136.18,101.33 136.23,101.29
  BOTTOM w0.127: R626.2 152.19,96.29 R627.2 152.07,97.3 v1(151.44,97.3) 151.31,97.3 148.88,99.74 144.61,99.74 144.38,99.51 139.83,99.51 139.38,99.97 136.86,99.97 136.23,100.6 136.23,101.29
N109300: length 11.6
  BOTTOM w0.076: U35.AY13 133.29,102.19 133.29,102.03 133.22,101.81 133.22,101.68 133.28,101.45 133.28,101.31 133.23,101.19 133.23,100.92 133.38,100.78
  BOTTOM w0.079: 133.41,99.91 133.38,99.94 133.38,100.78
  BOTTOM w0.127: 133.41,99.91 135.89,97.43 138.11,97.43 139.12,96.41 140.14,96.41 140.52,96.03 R659.2
N109332: length 8.7
  BOTTOM w0.079: U35.BA13 133.65,101.74 133.79,101.59 133.79,100.11 134,99.9
  BOTTOM w0.127: R640.2 139.12,97.17 138.36,97.94 135.96,97.94 134,99.9
N109356: length 12.6
  BOTTOM w0.079: U35.BB13 133.63,100.95 133.63,99.98 133.71,99.9
  BOTTOM w0.127: R653.2 141.15,94.03 141.03,94.15 141.03,96.01 140.37,96.67 139.25,96.67 138.23,97.68 135.93,97.68 133.71,99.9
N109380: length 12.6
  BOTTOM w0.079: U35.AY12 134.06,102.48 133.77,102.18 133.77,101.94 133.94,101.77 133.95,101.77 133.95,100.24 134.15,100.05
  BOTTOM w0.127: 134.15,100.05 136,98.19 138.49,98.19 138.99,97.68 140.42,97.68 141.66,96.44 R668.2
N112417: length 9.3
  BOTTOM w0.127: U35.AT1 140.6,104.85 141.08,104.85 141.38,104.54 142.68,104.54 144.81,102.41 145.31,102.41 145.85,101.87 R616.2
N112429: length 8.4
  BOTTOM w0.127: U35.B7 137.67,123.45 137.67,123.62 138.91,124.86 144.38,124.86 TP63.1
N112433: length 5.4
  TOP w0.127: v2(134.04,120.68) 134.04,120.68 133.69,121.03 133.69,121.56 136.15,124.02 R145.2
  BOTTOM w0.127: v2(134.04,120.68) 134.04,120.68 134.04,120.69 133.74,120.99 U35.E13
N119188: length 2.3
  TOP w0.127: v2(136.75,121.3) 137.29,121.85 v1(137.29,122.04) R153.1
  BOTTOM w0.152: U35.E8 136.44,120.99 v2(136.75,121.3)
N136283: length 5.6
  TOP w0.127: v1(168.26,93.77) 167.63,94.4 CN2.2
  BOTTOM w0.127: R282.1 166.31,91.82 v1(167.41,92.93) v1(168.26,93.77)
N136287: length 5.6
  TOP w0.127: v1(168.31,94.43) 168.63,94.75 CN2.4
  BOTTOM w0.127: R279.1 168.69,91.54 168.87,91.71 v1(168.87,92.01) 168.87,93.87 v1(168.31,94.43)
N136291: length 6.5
  TOP w0.127: v1(170.31,91.29) 169.68,91.29 169.38,91.59 169.38,94.49 169.63,94.74 CN2.6
  BOTTOM w0.127: v1(170.31,91.29) 170.01,90.99 R273.1
N136295: length 6.8
  TOP w0.127: v1(170.19,92.6) 169.65,93.14 169.65,93.85 169.84,94.04 170.61,94.04 171.13,94.56 CN2.9
  BOTTOM w0.127: R268.1 170.95,91.84 v1(170.19,92.6)
N136299: length 6.8
  TOP w0.127: CN2.11 172.13,94.98 170.69,93.54 v1(170.34,93.54)
  BOTTOM w0.127: R265.1 v1(171.96,91.92) 170.48,93.4 v1(170.34,93.54)
N136321: length 2.7
  TOP w0.127: CN2.13 173.13,97.24 173.16,97.27 R267.1 v1(173.91,98.05)
N136329: length 5.8
  TOP w0.127: CN2.5 169.13,93.27 v1(168.31,92.45)
  BOTTOM w0.127: R274.1 167.67,91.82 v1(168.31,92.45)
N321886: length 3.2
  BOTTOM w0.127: v1(207.52,21.79) 207.25,21.52 U25.5
  BOTTOM w0.508: U25.5 208.33,20.91 R390.2 R395.2
N366230:
  vias: v1(223.46,109.2)
N16779422: length 15.6
  IN2 w0.508: v1(132.59,18.51) v1(130.66,18.51)
  BOTTOM w0.508: v1(132.59,18.51) 133.56,18.51 133.95,18.12 L19.2 133.02,17.04 133.02,16.52 ; 133.02,16.52 133.02,16 Q42.1 ; 133.02,16.52 C781.1 ; R752.2 130.29,15.39 128.78,15.39 128.35,15.82 128.35,17.93 129.24,18.82 130.36,18.82 v1(130.66,18.51)
N16779565: length 20.7
  BOTTOM w0.127: Q19.3 225.71,127.15 R148.2 226.74,127.9 226.88,128.04 226.88,135.15 226.94,135.21 226.94,140.92 226.72,141.15 v1(226.72,142.01) 226.72,143.44 226.12,144.04 225.61,144.04 224.59,145.05
N16779579: length 5
  BOTTOM w0.127: Q42.2 131.98,15.54 R754.2 C786.1 130.44,16.98 130.44,17.62 129.98,18.08 v1(129.88,18.08)
N16781100: length 3.6
  TOP w0.508: v1(119.63,24.25) v1(120.9,24.25)
  BOTTOM w0.381: R402.2 R416.1 v1(120.9,24.25) ; R415.1 v1(119.63,24.25)
N16946782: length 3.8
  BOTTOM w0.127: v1(102.11,135.49) 101.78,135.82 Q5.2 99.93,136.52 99.8,136.65 R74.2
N16946786: length 2.4
  BOTTOM w0.127: R74.1 97.9,136.65 97.77,136.52 Q31.1 96.38,136.52 v1(96.17,136.74)
N16998366: length 8.5
  BOTTOM w0.127: R344.2 v1(203.51,41.46) 203.51,42.13 204.28,42.9 204.28,43.1 204.96,43.78 R343.1 206.49,43.78 207.55,42.72 208.11,42.72 208.49,42.34 Q27.2
N16998426: length 3.9
  BOTTOM w0.508: 210.19,45.36 v1(209.05,45.36) 208.54,45.36 208.27,45.09 R345.2 Q27.3
N17004316: length 4.2
  BOTTOM w0.127: D15.1 197.03,45.41 197.64,44.8 v1(199.1,44.8) Q29.3
N17028021: length 3.2
  TOP w0.127: v1(203.76,192.93) 203.5,192.67 C344.2 R230.2
  BOTTOM w0.127: Q22.2 204.27,192.17 203.76,192.68 v1(203.76,192.93)
N17046941: length 2.6
  TOP w0.127: PR6.1 149.97,171.6 v1(150.48,172.1)
  BOTTOM w0.127: v1(150.48,172.1) 150.55,172.18 PJ1.3
N17047009: length 2.4
  TOP w0.178: PR183.1 157.99,178.23 157.52,178.7 PU5.20
N17047028: length 2.5
  TOP w0.178: PU5.19 157.12,178.44 v1(157.21,178.35) 157.21,178.06 PR184.1
N17047083: length 3.3
  TOP w0.381: v1(154.97,172.28) 155.73,171.52 155.73,171.14 155.96,170.91 PR8.1
  BOTTOM w0.381: v1(154.97,172.28) 154.97,172.33 154.51,172.79 154.51,173.31 PJ1.5
N17047087: length 11.5
  TOP w0.381: v1(154.59,174.72) 154.72,174.72 155.23,175.23 PR186.1
  BOTTOM w0.152: PR169.1 168.69,174.21 168.43,174.47 168.43,176.61 167.74,177.31 166.74,177.31 PR176.2
  BOTTOM w0.305: v1(154.59,174.72) 154.64,174.77 154.64,174.72 155.68,173.68 155.68,171.11 PQ1.1
  vias: v1(175.82,175.91) v3(158.32,168.47) v3(158.35,167.71) v3(158.4,170.07) v3(158.4,169.31) v3(159.52,168.65) v3(159.54,167.89) v3(159.62,170.33) v3(159.57,169.54) v3(172.14,177.97) v3(173.16,177.97) v3(174.15,177.97) v3(175.11,177.97) v3(175.14,177.13) v3(176.03,177.97) v3(176.03,177.11)
N17047112: length 70.3
  TOP w0.203: v1(169.32,184.3) 169.32,184.5 v1(168.83,185) 168.2,185.62 167.77,185.62 164.98,188.41 158.17,188.41 157.61,187.85 PR165.1
  IN1 w0.203: v1(207.14,188.51) 207.09,188.46 202.15,188.46 201.36,187.68 201.36,186.93 190.68,176.25 184.99,176.25 183.27,177.97 179.13,177.97 176.96,180.14 176.96,182.98 175.41,184.53 169.55,184.53 v1(169.32,184.3)
  BOTTOM w0.381: PQ22.4 212.31,191.43 212.15,191.27 PC136.2 211.1,191.27 210.51,190.69 PC133.2 208.75,190.69 207.14,189.08 v1(207.14,188.51)
N17047335: length 2.6
  BOTTOM w0.508: PC4.1 166.77,184.36 v1(166.91,184.22) 167.17,183.96 PR2.2
N17047425: length 2.5
  TOP w0.127: PR7.1 152.79,171.44 152.56,171.67 v1(152.56,172.11)
  BOTTOM w0.127: PJ1.4 152.55,172.12 v1(152.56,172.11)
N17047601:
  vias: v1(157.21,166.69) v1(157.74,166.34)
N17067472: length 6.4
  TOP w0.508: PU4.8 50.15,115.89 50.18,115.93 PC104.2 49.08,116.61 v1(48.82,116.35) 48.62,116.15 PR154.2 48.62,114.4 48.7,114.32 PR155.1
N17067476: length 7.4
  TOP w0.254: PQ12.1 46.11,111.8 v1(46.11,111.07) 46.11,110.84 46.03,110.76 PR152.1 44.07,109.72 42.7,109.72 42.07,109.09 PD4.1
N17067510: length 3.2
  TOP w0.254: PQ12.3 45.36,114.29 v1(45.95,114.88) 46.44,115.36 PR154.1
N17067514: length 4.8
  TOP w0.254: PQ13.3 41.92,111.32 42.6,110.64 v1(42.83,110.64) 43.78,110.64 PR152.2 43.8,110.87 43.8,112.08 PQ12.2
N17067548: length 8.6
  TOP w0.508: PR155.2 47.17,110.78 PQ14.2 47.68,109.24 48.05,109.6 PC102.2 48.67,110.23 48.95,110.51 v1(49.13,110.51) 49.71,110.51 50.15,110.08 PU4.1
N17067560: length 8.1
  TOP w0.127: PQ9.3 40.65,117.11 v1(39.86,116.33) 39.86,115.87 39.27,115.29 v1(38.93,115.29)
  BOTTOM w0.127: PR262.1 36.34,115.29 v1(38.93,115.29)
N17067629: length 3.2
  TOP w0.381: PR137.2 39.33,43.32 v1(39.33,42.59) 39.33,42.45 38.99,42.11 PQ4.3
N17067635: length 2.9
  TOP w0.127: PR153.2 PQ10.3 38.18,33.55 v1(37.8,33.93)
N17192633: length 3
  BOTTOM w0.203: R337.2 U19.7
N17310717: length 15.6
  TOP w0.127: R430.2 D24.1 58.94,17.44 59.16,17.22 59.16,15.72 v1(60.94,13.94) 63.5,11.38 LED2.2
N17310725: length 15.6
  TOP w0.127: R433.2 D27.1 55.34,17.45 55.89,16.91 55.89,15.97 55,15.08 55,11.78 v1(56.72,10.05) 57,9.77 LED1.1
N17310735: length 16.5
  TOP w0.127: R431.2 D25.1 60.08,17.44 60.25,17.27 60.25,15.49 v1(60.46,15.29) 64.32,11.42 64.32,5.53 65,4.85 LED2.1
N17310861: length 14.9
  TOP w0.127: R432.2 D26.1 53.68,17.45 53.55,17.32 53.55,14.93 53.27,14.65 53.27,12.59 53.45,12.42 53.45,10.41 v1(55.17,8.68) 55.5,8.35 LED1.2
N17398787: length 2.9
  TOP w0.178: PU5.5 156.32,185.6 156.39,185.67 v1(156.39,185.85) PR167.2
N17410561: length 11.8
  TOP w0.508: PC223.1 53.44,91.32 v1(53.3,91.18) v1(52.56,90.44) 51.9,89.78 51.9,83.99 53.52,82.37 PR344.1
  vias: v3(55.17,95.78) v3(55.17,95.02) v3(55.94,95.78) v3(55.94,95.02) v3(56.7,95.78) v3(56.7,95.02) v3(57.46,95.78) v3(57.46,95.02) v3(66.35,97.81) v3(66.35,97.05) v3(67.11,97.81) v3(67.11,97.05) v3(69.02,99.97) v3(69.78,99.97)
N17410571: length 2.7
  TOP w0.305: v1(49.35,84.93) 49.16,84.93 PR280.2 48.71,83.59 R697.1
  BOTTOM w0.305: v1(49.35,84.93) 49.53,84.93 PR288.1
N17410893: length 2.3
  BOTTOM w0.254: PR290.2 v1(56.55,81.17) 56.32,81.17 55.62,81.87 PU14.13
N17424918: length 3.5
  TOP w0.178: PR177.2 v1(152.86,182.29) 153.3,181.85 153.83,181.85 153.98,181.71 PU5.11
N17424920: length 3.3
  TOP w0.178: PU5.12 v1(153.75,181.31) 152.88,181.31 PR178.2
N17424921: length 4.2
  TOP w0.178: PR170.2 154.41,185.74 154.4,185.72 154.4,184.76 154.36,184.72 v1(154.36,184.12) 154.87,184.12 155.02,184.28 155.4,184.28 155.52,184.15 PU5.7
N17424925: length 4.4
  TOP w0.178: PR172.2 151.97,185.19 153.12,184.04 v1(153.12,183.66) 153.12,183.37 153.98,182.51 PU5.9
N17424950: length 3.5
  TOP w0.178: PR13.2 153.64,179.04 v1(154.31,179.04) 154.35,179 155.16,179 155.52,179.36 PU5.15
  TOP w0.381: PR12.2 PR13.2
N17435661: length 2.9
  TOP w0.508: PQ5.3 v1(73.01,94.08) 73.23,94.08 73.39,94.23 PR138.2
N17542339: length 4.2
  TOP w0.127: R710.2 C756.2 206.61,188.28 207.02,187.88 v1(207.02,187.7)
  BOTTOM w0.127: Q38.2 206.3,186.99 v1(207.02,187.7)
N17642578: length 36.1
  IN2 w0.14: v1(149.92,88.41) 149.76,88.56 149.76,91.21 150.91,92.35 150.91,95.24 148.24,97.91 140.25,97.91 134.48,103.67 134.48,104.04 v2(134,104.52)
  BOTTOM w0.127: v2(134,104.52) 134.16,104.52 U35.AT11 ; TP4367.1 156.06,86.96 153.21,86.96 152.91,87.27 151.19,87.27 150.04,88.41 v1(149.92,88.41)
N17661815: length 5.2
  TOP w0.178: PR171.2 151.54,186.38 v1(152.89,185.03) 153.19,184.73 153.19,184.47 153.94,183.73 153.94,183.3 154.22,183.02 154.22,183.01 154.33,182.91 PU5.8
N17792383: length 41.1
  IN1 w0.127: 105.07,113.43 104.69,113.43 104.13,113.99 102.75,113.99 101.87,114.88 101,114.88
  IN1 w0.14: 101,114.88 100.08,115.79 91.09,115.79 89.52,114.22 85.96,114.22 80.57,108.84 80.57,107.33 79.85,106.6 v1(79.66,106.6) ; v2(106.52,112.35) 106.16,112.35 105.07,113.43
  BOTTOM w0.114: U35.AC63 106.08,112.08 106.34,112.35 v2(106.52,112.35)
  BOTTOM w0.127: v1(79.66,106.6) 79.48,106.6 79.25,106.37 79.25,106.14 79.1,105.99 76.66,105.99 76.12,105.45 R634.2 76,104.93 76,103.9 R172.1 76.12,103.74 v1(75.47,103.09)
N17792405: length 43.2
  IN1 w0.127: 99.96,115.51 100.86,114.61 101.78,114.61 102.65,113.74 104.06,113.74 104.6,113.2 104.94,113.2 106.23,111.91 106.34,111.91 v2(106.52,111.73)
  IN1 w0.14: 99.96,115.51 97.08,115.51 96.32,114.75 90.44,114.75 89.63,113.94 86.07,113.94 80.85,108.72 80.85,107.11 v1(79.69,105.94)
  BOTTOM w0.114: 106.23,111.53 106,111.3 105.52,111.3 U35.AE63
  BOTTOM w0.127: v2(106.52,111.73) 106.43,111.73 106.23,111.53 ; v1(79.69,105.94) 80.19,106.45 80.19,108.12 79.69,108.63 76.82,108.63 76.38,108.19 R176.1 76.08,107.7 v1(76.08,107.18) 76.08,106.49 R636.2
N17792407: length 44.3
  IN1 w0.14: v1(79.66,105.28) 79.15,105.79 79.15,106.88 79.35,107.07 79.93,107.07 80.2,107.35 80.2,108.86 83.13,111.79 83.13,112.8 83.44,113.11 84.45,113.11 85.84,114.5 89.39,114.5 90.96,116.07 101.1,116.07 102.31,114.86 103.62,114.86 104,114.48 104.8,113.68 105.18,113.68 106.07,112.8 106.73,112.8 106.94,112.59 106.94,111.31 v1(107.15,111.1)
  IN2 w0.127: 105.75,110.43 v2(105.75,107.16)
  IN2 w0.14: 105.75,110.43 106.15,110.84 106.88,110.84 v1(107.15,111.1)
  BOTTOM w0.102: U35.AL63 105.39,107.52 v2(105.75,107.16)
  BOTTOM w0.127: v1(79.66,105.28) 79.43,105.05 R633.2
N17792421: length 41.3
  IN1 w0.127: 102.47,115.11 103.73,115.11 104.9,113.94 105.29,113.94 106.1,113.12 106.76,113.12 107.21,112.68 107.21,111.67 107.74,111.13 107.74,110.89
  IN1 w0.14: v1(107.77,110.7) 107.77,110.87 107.74,110.89 ; v1(79.74,107.54) 79.74,108.79 82.84,111.89 82.84,112.9 83.32,113.39 84.33,113.39 85.72,114.78 89.19,114.78 90.76,116.35 101.23,116.35 102.47,115.11
  IN2 w0.14: v2(106.34,108.97) 107.23,108.97 107.6,109.34 107.6,110.53 v1(107.77,110.7)
  BOTTOM w0.127: R632.2 78.81,107.04 v1(78.99,107.22) 79.3,107.54 v1(79.74,107.54) ; v2(106.34,108.97) 106.25,108.88 U35.AJ62
N17817978: length 15.1
  TOP w0.127: R438.1 R440.1 52.67,17.45 52.51,17.29 v1(52.51,15.62) 52.51,14.85 53.02,14.35 53.02,12.49 53.19,12.31 53.19,10.08 54,9.27 LED1.3
N17818190: length 17.9
  TOP w0.127: R437.1 R439.1 57.25,17.44 56.98,17.16 56.98,15.36 57.13,15.21 58.1,15.21 v1(62.49,10.81) 62.87,10.43 62.87,6.29 62,5.43 LED2.3
N18005998: length 6.2
  BOTTOM w0.127: R326.2 225.36,54.26 v1(225.54,54.44) 225.69,54.58 229.43,54.58 CN14.18
N18020348: length 1.4
  TOP w0.127: TP17.1 126.7,107.67 v2(126.7,107.21)
  BOTTOM w0.127: v2(126.7,107.21) 126.95,107.45 U35.AM23
N18021386: length 2.5
  TOP w0.127: TP14.1 127.31,105.84 v2(128.56,107.08)
  BOTTOM w0.127: v2(128.56,107.08) 128.45,107.08 128.1,107.44 U35.AM22
N18022283: length 1.7
  TOP w0.127: v1(121.91,118.27) 121.7,118.49 TP12.1
  BOTTOM w0.114: U35.K32 122.11,118.27 v1(121.91,118.27)
N18022286: length 1.6
  TOP w0.127: v2(122.82,108.96) 122.82,108.15 TP20.1
  BOTTOM w0.079: v2(122.82,108.96) 122.61,108.75 U35.AK32
N18137715: length 21.8
  TOP w0.127: v1(145.12,100.48) 145.6,100.48 146.11,100.98 147.71,100.98 148.06,100.63 TP29.1
  IN1 w0.14: v1(145.12,100.48) 145.12,100.22 144.46,99.56 138.08,99.56 135.41,102.23 135.41,103.93 134.95,104.39 v2(134.95,104.63)
  BOTTOM w0.127: U35.AU11 134.92,104.63 v2(134.95,104.63)
N18834425: length 5.4
  TOP w0.127: R717.2 v1(218.03,72.93) ; R717.2 C764.1 ; R717.2 218.88,73.68 218.75,73.81 v1(218.75,73.83)
  BOTTOM w0.127: Q56.2 218.75,73.81 ; 218.75,73.81 v1(218.75,73.83) ; 218.75,73.81 218.78,73.78 219.26,73.78 219.4,73.64 Q56.3
N18834459: length 3
  TOP w0.127: R756.1 R757.1 ; R757.1 R717.1 ; R757.1 v1(217.87,71.15)
N18849499: length 4.5
  TOP w0.127: R4.1 125.13,176.53 124.73,176.93 v1(124.54,176.93) 124.54,177.29 124.41,177.42 R6.2
  BOTTOM w0.127: v1(124.54,176.93) 125.66,176.93 126.33,176.26 CN5.11
N18849555: length 4.5
  TOP w0.127: R5.2 124.67,177.54 124.77,177.44 v1(125.02,177.44) 125.02,177.06 125.38,176.7 R3.1
  BOTTOM w0.127: v1(125.02,177.44) 125.91,177.44 126.71,176.64 CN5.10
N18953365: length 11.8
  TOP w0.127: v1(142.86,102.25) 142.93,102.18 144.79,102.18 145.09,101.87 R759.1
  BOTTOM w0.079: 141.16,100.73 140.24,100.73 140.01,100.96 140.01,101.29 139.83,101.47 139.83,101.85 139.53,102.15 U35.AY3
  BOTTOM w0.127: 141.16,100.73 141.28,100.6 142.42,100.6 142.68,100.86 142.68,101.95 142.86,102.13 v1(142.86,102.25)
N18953425: length 7.4
  BOTTOM w0.079: U35.AY71 99.7,102.2 98.99,101.49 97.59,101.49
  BOTTOM w0.127: R760.1 v1(94.32,100.35) 95.01,101.05 95.51,101.05 95.95,101.49 97.59,101.49
N18954271: length 12.5
  BOTTOM w0.076: 103.41,125.22 103.95,124.68 103.95,124.23 104.34,123.84 104.34,122.91 U35.C64
  BOTTOM w0.127: 103.41,125.22 103.21,125.42 99.07,125.42 96.75,127.73 v1(96.37,127.73) 95.51,127.73 95.43,127.65 R761.1
N18954886: length 46.8
  IN1 w0.102: 110.72,109.67 110.72,108.35
  IN1 w0.127: 100.71,114.38 101.65,114.38 102.54,113.48 103.99,113.48 104.5,112.97 104.81,112.97 105.92,111.87 105.92,111.64 106.67,110.89
  IN1 w0.14: v1(108.46,105.79) 108.92,106.24 108.92,107.33 109.38,107.79 110.19,107.79 110.72,108.33 110.72,108.35 ; 106.67,110.89 107.38,110.18 110.22,110.18 110.72,109.67 ; 100.71,114.38 99.85,115.23 97.2,115.23 96.44,114.47 90.56,114.47 89.75,113.66 86.19,113.66 81.13,108.61 81.13,106.99 80.19,106.05 80.19,105.12 v1(79.68,104.6)
  BOTTOM w0.127: R762.1 v1(79.51,103.78) 79.68,103.95 v1(79.68,104.6) ; v1(108.46,105.79) 108.69,105.56 108.84,105.56 U35.AR56
N18954889: length 2.3
  TOP w0.127: TP88.1 109.81,107.54 109.81,106.94 v2(109.35,106.48)
  BOTTOM w0.127: v2(109.35,106.48) 109.03,106.15 U35.AP56
N19018012: length 24.8
  TOP w0.254: v1(152.28,114.42) 152.76,114.42 153.31,114.97 C794.2
  TOP w0.381: v1(152.28,114.42) 152.05,114.42 151.45,115.02 R775.2
  IN1 w0.305: 138.94,114.78 136.12,114.78 136.04,114.7 135.59,114.7 135.06,114.17 v2(135.06,114.12)
  IN1 w0.381: v1(152.28,114.42) 152.91,113.79 152.91,112.39 152.25,111.73 145.01,111.73 144.23,112.52 144.23,112.95 143.03,114.14 141.56,114.14 140.9,114.8 138.97,114.8 138.94,114.78
N19520551: length 6.2
  BOTTOM w0.127: CN20.27 152.42,17.37 151.82,17.98 v1(151.82,18.31) D34.1 151.3,19.36 151.13,19.19 R776.1
N19736816: length 9
  TOP w0.127: v1(133.22,107.97) 133,108.19 132.99,108.19 132.76,108.41 131.49,108.41 131.22,108.15 130.6,108.15 130.58,108.17 130.18,108.17 129.9,107.89 129.9,104.34 TP84.1
  BOTTOM w0.127: v1(133.22,107.97) 133.22,107.97 132.7,107.45 U35.AM15
N20339214: length 5.5
  TOP w0.127: v1(138.33,110.89) 138.46,111.02 140.52,111.02 140.77,110.76 141.65,110.76 R778.1
  BOTTOM w0.127: v1(138.33,110.89) 138.46,110.76 138.46,110.15 138.86,109.75 U35.AG4
N20915811: length 6.1
  TOP w0.127: TP95.1 129.42,109.06 131.32,109.06 131.76,108.63 132.85,108.63 133.08,108.4 133.48,108.4 133.86,108.03 v1(133.86,107.97)
  BOTTOM w0.127: U35.AK13 133.53,108.29 v1(133.86,107.97)
N20965717:
  vias: v1(211.93,172.69)
N21057139: length 5.7
  TOP w0.381: PU2.2 45.71,47.8 v1(46.23,47.28) 46.87,46.64 PR37.2 47.07,45.97 47.36,45.69 PR54.1 48.41,45.69 48.61,45.49 PC61.2
N21057151:
  vias: v1(36.96,49.93)
N21057157:
  vias: v1(46.37,49.45)
N21057159: length 3.1
  TOP w0.381: PR119.1 37.42,47.64 37.47,47.7 PR121.2 37.98,48.2 38.38,47.8 PU2.7
N21057165: length 6.4
  TOP w0.381: PU2.4 45.23,50.34 45.48,50.6 PR68.1 46.37,51.42 v1(46.36,51.44) 46.4,51.49 46.45,51.49 47.43,52.47 47.43,52.42 47.39,52.38 47.46,52.38 PC70.2 47.6,53.25 48,53.66 PC81.2
N21057401: length 5.6
  BOTTOM w0.381: PC75.2 163.33,62.96 162.85,62.49 PR69.2 162.22,62.71 161.21,62.71 PR75.1 160.99,62.73 v1(160.51,63.22) 159.82,63.9 159.82,64.65
N21057413:
  vias: v1(159.77,72.87)
N21057419: length 9.1
  BOTTOM w0.508: PU6.3 158.55,63.9 159.79,62.67 PC76.1 PC78.2 159.79,60.63 160.76,59.66 v1(160.76,57.55) PR1250.2
N21057421: length 3.9
  BOTTOM w0.305: PR133.1 160.14,72.14 PR156.2
  BOTTOM w0.381: PR133.1 159.87,72.03 v1(159.44,71.6) 159.44,71.32 159.82,70.94 159.82,70.11
N21057429: length 9.1
  BOTTOM w0.508: PR81.1 159.18,59.18 158.82,58.83 157.99,58.83 157.79,59.02 157.79,59.64 157.55,59.88 v1(157.55,60.92) 157.55,61.22 157.06,61.71 PC77.2 156.39,61.97 PC79.2 156.19,62.95 156.19,64.21 156.64,64.65 PU6.4
N21060883: length 3.4
  BOTTOM w0.508: v1(159.8,39.26) 159.42,39.64 PQ17.3 158.56,39.63 PR164.2
N21061023: length 163.6
  TOP w0.508: 56.95,71.52 56.57,71.52 v1(55.94,72.16) ; v1(55.94,72.16) 55.94,72.36 56.41,72.83 PR159.2 PR157.1 ; v1(55.94,72.16) 55.68,71.9 v1(54.67,71.9) 54.01,71.9 52.99,70.89 51.85,70.89 51.34,71.39 49.24,71.39 48.7,71.93 PQ16.2
  IN1 w0.508: v1(75.98,69.64) 74.43,71.19 62.57,71.19 61.1,72.66 56.44,72.66 v1(55.94,72.16) ; v1(119.72,32.51) 124.64,32.51 127.87,29.29 142.79,29.29 145.12,31.62 149.76,31.62 157.11,38.96 v1(157.49,38.96)
  BOTTOM w0.508: v1(75.98,69.64) 76,69.64 79.91,65.73 79.91,62.12 77.5,59.71 77.5,49.37 77.02,48.89 77.02,46.4 77.03,46.38 77.03,45.78 76.66,45.41 76.66,39.6 76.93,39.34 78.72,39.34 79.69,39.34 80.17,38.86 89.61,38.86 93.75,38.86 95.96,36.65 96.59,36.65 120.86,36.65 121.39,36.11 121.39,34.16 119.72,32.48 v1(119.72,32.51) ; v1(157.49,38.96) 157.54,39.01 PQ17.2
N21061031: length 4.6
  TOP w0.381: PR158.1 52.54,70.12 52.55,70.11 52.68,70.11 ; 52.68,70.11 53.98,70.11 PR160.2 54.61,69.49 v1(54.84,69.49) PQ15.2 ; 52.68,70.11 PC109.2
N21390980: length 2.1
  BOTTOM w0.127: TP108.1 172.5,94.51 172.5,95.88 CN23.10
N21390982: length 2.7
  BOTTOM w0.127: TP109.1 160.84,93.84 161,94 CN23.56
N21390990: length 3.6
  BOTTOM w0.127: CN23.58 160.5,94.25 159.48,93.24 TP150.1
N21466717: length 1.8
  TOP w0.127: C1329.2 117.95,64.92 v1(118.13,64.74)
  TOP w0.254: R10930.1 117.41,65.92 C1329.2
N21854677: length 46.8
  BOTTOM w0.254: PC110.2 193.95,56.69 193.22,56.69 192.21,57.7 192.21,58.57 188.56,62.21 188.56,63.43 185.07,66.92 175.29,66.92 174.53,67.69 174.53,73.76 175.28,74.51 175.28,80.22 176.37,81.31 179.06,81.31 179.63,81.88 179.63,82.54 PR163.2 PR84.2
  BOTTOM w0.381: PC110.2 PR277.1 v1(193.27,57.73)
N21854679: length 46.8
  BOTTOM w0.254: PR85.2 PR162.2 179.17,82.44 179.17,81.96 178.91,81.69 176.16,81.69 174.9,80.44 174.9,74.68 174.15,73.93 174.15,67.53 175.13,66.54 184.91,66.54 188.18,63.27 188.18,62.01 191.83,58.36 191.83,57.55 193.14,56.23 193.62,56.23 PR279.1 v1(194.03,55)
N21854704: length 3
  BOTTOM w0.381: v1(210.45,60.5) 210.45,60.01 PQ18.2 212.23,59.38 PC187.1
