# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RXN2: length 120
  TOP w0.114: v1(55.43,107.21) 55.68,107.46 55.68,117.44 54.65,118.47 41.24,118.47 38.64,115.86 38.06,115.86 C394.1
  IN2 w0.114: v2(135.87,118.18) 134.57,118.18 134.43,118.31 130.8,118.31 130.28,117.79 129.06,117.79 127.33,116.06 116.96,116.06 116.5,116.52 104.77,116.52 104.62,116.67 101.57,116.67 101.01,117.23 98.72,117.23 98.66,117.29 98.07,117.88 97.49,118.46 90.58,118.46 89.76,117.63 85.92,117.63 83.86,115.58 82.96,115.58 76.05,108.67 76.05,107.18 75.65,106.78 68.48,106.78 68.14,107.12 59.84,107.12 58.82,106.1 56.23,106.1 55.76,106.57 55.76,107 55.56,107.21 v1(55.43,107.21)
  BOTTOM w0.102: U35.J10 135.66,118.39 v2(135.87,118.18)
USB3_RXN3: length 123
  TOP w0.114: v1(57.38,107.16) 57.67,107.45 57.67,117.99 54.45,121.22 40.14,121.22 38.82,119.9 35.99,119.9 C4777.1
  IN2 w0.102: 135.35,120.11 135.35,120.13 135.58,120.35 135.58,120.38 v2(135.87,120.67)
  IN2 w0.114: 135.35,120.11 135.35,119.79 135.12,119.56 134.81,119.56 134.18,118.92 130.42,118.92 129.99,118.49 128.69,118.49 127.29,117.09 125.05,117.09 124.5,117.63 123.72,117.63 123.11,117.02 118.15,117.02 117.28,117.9 114.59,117.9 114.1,117.42 106.74,117.42 106.58,117.57 101.91,117.57 100.68,118.8 99.18,118.8 98.52,119.46 90.33,119.46 89.35,118.49 85.57,118.49 83.54,116.45 82.63,116.45 74.33,108.15 57.99,108.15 57.67,107.82 57.67,107.45 v1(57.38,107.16)
  BOTTOM w0.114: v2(135.87,120.67) 135.73,120.67 U35.E10
USB3_RXP0: length 289.6
  TOP w0.114: R387.2 18.89,9.83 18.89,9.75 C517.2 18.95,8.89 18.95,8.02 19.23,7.74 20.58,7.74 23.98,11.15 33.66,11.15 36.61,14.09 36.61,14.51 v1(36.32,14.8)
  IN2 w0.114: v2(136.78,119.36) 136.78,119.42 137.42,120.06 138.21,120.06 138.42,120.28 138.98,120.28 139.4,119.86 145.14,119.86 145.41,119.59 151.46,119.59 152.17,120.3 156.13,120.3 158.53,117.9 158.76,117.9 166.6,110.05 166.6,109.32 170.45,105.47 170.45,96.63 171.11,95.97 171.11,90.43 169.75,89.07 169.75,85.8 169.84,85.71 169.84,83.37 169.22,82.75 169.22,79.37 168.71,78.86 168.71,74.09 168.9,73.91 168.9,69.1 171.72,66.28 171.72,65.61 173.21,64.12 174.64,62.69 174.85,62.48 174.85,61.48 175.25,61.07 175.25,56.58 175.88,55.96 175.88,54.66 175.38,54.16 175.38,50.12 174.58,49.32 174.58,45.53 173.9,44.85 173.9,44.16 171.94,42.2 171.94,40.84 171.08,39.97 171.08,38.4 170.5,37.83 169.96,37.83 167.61,35.48 167.16,35.48 166.38,34.69 163.94,34.69 163.83,34.8 159.66,34.8 159.15,34.3 157.39,34.3 151.3,28.2 114.92,28.2 114.08,29.04 113.28,29.04 111.85,30.46 109.44,30.46 107.02,32.89 87.66,32.89 80.16,25.38 77.14,25.38 75.7,23.94 71.94,23.94 67.44,19.45 67.44,18.31 65.27,16.14 61.99,16.14 61.57,16.56 52.46,16.56 50.95,15.04 48.57,15.04 48.23,15.39 47.07,15.39 46.31,14.62 43.06,14.62 42.46,14.03 36.92,14.03 36.65,14.31 36.65,14.47 v1(36.32,14.8)
  BOTTOM w0.114: v2(136.78,119.36) 136.66,119.36 U35.G8
USB3_RXP0_R: length 9.2
  TOP w0.114: R387.1 18.91,11.27 18.91,11.64 19.14,11.87 19.14,12.52 18.94,12.73 16.69,12.73 U24.5 16.47,12.73 15.46,12.73 15.08,13.12 14.12,13.12 13.53,12.53 13.02,12.53 12.92,12.63 CN16.6
USB3_RXP1: length 284.1
  TOP w0.114: v1(26.06,28.34) 25.77,28.63 25.77,29.07 24.74,30.1 23.43,30.1 C469.2 22.93,30.37 R353.2
  IN2 w0.114: v1(26.06,28.34) 25.84,28.57 25.84,28.75 25.95,28.86 26.26,28.86 28.01,27.11 28.01,25.99 28.38,25.62 28.38,24.02 37.14,15.26 46.05,15.26 46.81,16.02 48.29,16.02 48.61,16.34 50.21,16.34 51.89,18.02 64.56,18.02 66.47,19.92 66.47,21.8 66.88,22.22 68.18,22.22 68.69,22.73 69.49,22.73 71.34,24.58 75.43,24.58 76.87,26.02 79.71,26.02 87.48,33.79 109.55,33.79 112.18,31.16 113.66,29.67 114.34,29.67 115.18,28.84 151.03,28.84 157.8,35.6 163.81,35.6 164.34,36.14 167.37,36.14 169.83,38.6 169.83,40.3 170.69,41.17 170.69,42.01 172.73,44.04 172.73,44.77 173.37,45.42 173.37,49.01 174.75,50.38 174.75,54.42 175.19,54.86 175.19,55.75 174.62,56.32 174.62,60.76 174.14,61.24 174.14,62.05 168.26,67.93 168.26,73.65 168.08,73.83 168.08,79.13 168.59,79.63 168.59,81.17 167.83,81.93 167.83,83.2 168.8,84.17 168.8,85.86 169.12,86.17 169.12,89.39 169.62,89.89 169.62,97.53 169.17,97.98 169.17,105.47 165.7,108.94 165.7,110.04 158.86,116.89 157.94,116.89 155.95,118.88 145.18,118.88 144.84,119.22 140.01,119.22 139.63,118.84 138.69,118.84 138.4,119.13 137.99,119.13 v1(137.74,119.38)
  BOTTOM w0.114: U35.H6 137.58,119.38 v1(137.74,119.38)
USB3_RXP1_R: length 10.6
  TOP w0.114: CN13.6 12.92,28.97 13.03,28.86 13.3,28.86 13.87,29.43 14.59,29.43 16.06,30.91 17.04,30.91 U21.5 17.24,30.91 19.95,30.91 20.78,30.07 20.95,30.07 R353.1
USB3_RXP2: length 120
  TOP w0.114: v1(56.23,107.21) 55.9,107.53 55.9,117.53 54.74,118.69 41.15,118.69 38.58,116.12 38.02,116.12 C4781.1
  IN2 w0.114: v1(56.23,107.21) 56.06,107.05 56.06,107.04 55.97,106.96 55.97,106.66 56.32,106.32 58.73,106.32 59.75,107.33 68.23,107.33 68.57,106.99 75.56,106.99 75.83,107.27 75.83,108.75 82.87,115.79 83.78,115.79 85.83,117.85 89.67,117.85 90.49,118.68 97.58,118.68 98.81,117.44 101.1,117.44 101.66,116.89 104.7,116.89 104.86,116.73 116.59,116.73 117.05,116.28 127.27,116.28 128.98,117.98 130.2,117.98 130.72,118.51 134.56,118.51 134.67,118.4 135.5,118.4 135.85,118.74 v2(135.85,118.79)
  BOTTOM w0.102: U35.H10 135.6,119.04 v2(135.85,118.79)
USB3_RXP3: length 123
  TOP w0.114: v1(58.18,107.16) 57.98,107.16 57.89,107.26 57.89,118.08 54.54,121.43 40.05,121.43 38.73,120.11 35.84,120.11 35.63,120.33 C4776.1
  IN2 w0.114: v2(135.85,120.06) 135.56,119.77 135.56,119.71 135.2,119.36 135.04,119.36 135.03,119.36 134.91,119.36 134.27,118.71 130.51,118.71 130.08,118.27 128.78,118.27 127.38,116.87 124.96,116.87 124.41,117.42 123.81,117.42 123.2,116.81 118.07,116.81 117.19,117.69 114.68,117.69 114.19,117.2 106.65,117.2 106.49,117.36 101.82,117.36 100.59,118.59 99.09,118.59 98.43,119.25 90.42,119.25 89.44,118.27 85.66,118.27 83.63,116.24 82.72,116.24 74.42,107.93 58.08,107.93 57.89,107.74 57.89,107.26 57.98,107.16 v1(58.18,107.16)
  BOTTOM w0.114: U35.F10 135.69,120.06 v2(135.85,120.06)
USB3_TXN0: length 242.4
  TOP w0.114: C499.1 19.76,20.26 19.97,20.26 20.27,19.97 20.27,19.1 21.34,18.03 43.87,18.03 44.21,17.69 47.14,17.69 48,18.55 48,22.66 45.87,24.8 45.87,25.84 43.56,28.15 42.61,28.15 v1(42.37,28.39)
  IN2 w0.114: v1(42.37,28.39) 42.2,28.21 41.44,28.21 41.37,28.28 41.37,29.57 31.62,39.33 29.97,39.33 27.31,41.98 27.31,43.96 29.41,46.06 29.41,57.21 31.96,59.76 37.12,59.76 38.56,61.21 40.47,61.21 45.23,65.97 46.36,65.97 50.82,70.43 50.82,85.38 47.45,88.74 47.45,97.94 49.78,100.26 49.78,103.41 54.93,108.57 74.06,108.57 82.37,116.87 83.36,116.87 85.4,118.9 89.07,118.9 91.93,121.76 94.82,121.76 96.6,119.98 100.54,119.98 101.9,118.63 104.18,118.63 104.68,118.13 106.99,118.13 107.3,118.43 115.97,118.43 116.26,118.73 120.68,118.73 120.97,118.43 120.97,118.33 121.64,117.66 122.56,117.66 123.63,118.73 125.39,118.73 125.79,119.12 127.74,119.12 128.11,118.75 129.77,118.75 130.71,119.7 130.71,121.56 131.08,121.92 131.78,121.92 131.89,121.82 131.89,121.56 v2(131.87,121.54)
  BOTTOM w0.079: v2(131.87,121.54) 131.87,121.41 132.1,121.18 132.18,121.18 132.46,121.46 132.84,121.46 132.88,121.42 133.24,121.42 133.38,121.56 133.38,121.98 133.48,122.08 133.8,122.08 133.99,122.27 133.99,122.46 133.94,122.51 133.78,122.51 U35.C13
USB3_TXN0_C: length 3.4
  TOP w0.114: R384.2 18.99,19.19 18.81,19.19 18.57,19.43 18,19.43 17.85,19.59 17.85,20.13 18.03,20.32 18.15,20.32 C499.2
USB3_TXN0_R: length 10.4
  TOP w0.114: CN16.8 12.92,17.83 13.02,17.93 13.57,17.93 13.95,17.55 14.64,17.55 15.49,16.69 15.49,16.34 16.03,15.79 16.03,15.79 16.11,15.71 18.41,15.71 U24.10 18.55,15.71 18.77,15.71 19.07,16.01 19.07,16.44 18.97,16.54 18.97,16.65 C511.1 19.35,18.04 R384.1
USB3_TXN1: length 230.1
  TOP w0.114: v1(26.19,39.52) 25.95,39.76 25.65,39.76 25.55,39.66 25.55,38.54 25.98,38.11 25.98,36.66 25.34,36.02 25.34,34.3 25.02,33.97 24.36,33.97 23.96,33.57 C461.1
  IN2 w0.114: v1(144.45,136.98) 144.25,137.18 144.25,138.22 143.55,138.92 138.65,138.92 136.82,137.09 126.21,137.09 124.49,135.38 118.95,135.38 118.5,135.83 113.75,135.83 113.12,135.21 105.68,135.21 102.74,138.16 97.88,138.16 95.6,135.87 92.17,135.87 89.3,133 84.98,133 73.03,121.05 68.14,121.05 67.71,120.62 64.27,120.62 62.69,122.19 54.8,122.19 39.16,106.56 39.16,101.23 38.27,100.34 38.27,83.7 37.33,82.76 36.62,82.76 36.07,82.21 36.07,79.63 36.53,79.17 36.53,76.2 34.42,74.09 34.42,73.07 33.76,72.41 31.96,72.41 28.33,68.78 28.33,66.52 28.64,66.2 28.64,64.74 27.02,63.11 27.02,60.46 25.43,58.87 25.43,53.6 23.95,52.12 23.95,41.59 23.95,41.23 25.42,39.75 25.96,39.75 v1(26.19,39.52)
  BOTTOM w0.114: U35.B13 134.67,124.05 134.75,124.05 136.46,125.75 137.45,125.75 138.51,126.82 141.43,126.82 144.32,129.7 144.32,136.08 144.16,136.23 144.16,136.69 v1(144.45,136.98)
USB3_TXN1_C: length 1
  TOP w0.114: C461.2 R341.2
USB3_TXN1_R: length 10.3
  TOP w0.114: CN13.8 12.92,34.58 12.99,34.65 13.33,34.65 13.98,34.01 14.69,34.01 14.98,34.3 17.05,34.3 U21.1 17.23,34.3 17.92,34.3 18.58,33.63 18.64,33.57 18.7,33.51 19.4,33.51 19.81,33.92 19.91,33.92 20.24,33.58 C460.1 20.33,33.57 R341.1
USB3_TXN2: length 140.2
  TOP w0.114: v1(53.87,119.36) 53.87,119.69 53.23,120.33 41.12,120.33 38.75,117.96 36.09,117.96 C4780.1
  IN2 w0.114: v1(53.87,119.36) 53.89,119.37 54.18,119.37 55.1,118.46 72.7,118.46 85.63,131.39 90.02,131.39 92.08,133.45 95.56,133.45 96.11,134 97.97,134 98.1,133.88 104.2,133.88 105.09,132.99 110.04,132.99 111.41,131.62 111.72,131.62 112.38,130.95 114.02,130.95 114.65,131.58 121.82,131.58 124.06,133.81 125.67,133.81 127.44,135.58 137.88,135.58 139.63,137.33 141.1,137.33 141.34,137.09 141.34,137.02 141.2,136.88 v1(141.14,136.88)
  BOTTOM w0.076: U35.B15 132.23,123.17 132.23,123.36 132.06,123.53 132.06,124.41 132.82,125.17 134.6,125.17 136.12,126.69 136.43,126.69 136.53,126.79 136.52,126.82 136.54,126.83
  BOTTOM w0.114: 136.54,126.83 138.06,128.35 140.66,128.35 142.53,130.22 142.53,132.51 141.38,133.65 141.38,136.64 v1(141.14,136.88)
USB3_TXN3: length 144.8
  TOP w0.114: C4779.1 36.06,122 55.57,122 56.34,121.23 56.34,120.91 56.26,120.83 v1(56.02,120.83)
  IN2 w0.114: v1(142.43,137.46) 142.58,137.46 142.68,137.56 142.68,137.93 142.54,138.07 139.17,138.07 137.32,136.21 126.98,136.21 125.25,134.49 123.78,134.49 121.5,132.21 114.29,132.21 113.67,131.59 112.77,131.59 112.07,132.29 111.7,132.29 110.33,133.66 105.5,133.66 104.4,134.77 101.28,134.77 99.75,136.29 97.34,136.29 95.94,134.89 92.51,134.89 89.64,132.02 85.32,132.02 73.36,120.06 70.02,120.06 69.2,119.24 67.98,119.24 67.59,119.63 57.96,119.63 56.92,120.68 56.52,121.08 56.27,121.08 v1(56.02,120.83)
  BOTTOM w0.076: 136.98,126.39 136.93,126.34 136.26,126.34 134.7,124.78 133.03,124.78 132.6,124.36 132.6,123.59 132.58,123.53 132.56,123.48 132.56,123.33 132.61,123.18 132.61,122.99 132.54,122.79 132.54,122.67 132.33,122.47 U35.C15
  BOTTOM w0.114: 136.98,126.39 138.29,127.71 140.98,127.71 143.29,130.02 143.29,132.94 142.69,133.53 142.69,137.34 142.58,137.46 v1(142.43,137.46)
USB3_TXP0: length 242.4
  TOP w0.114: v1(42.37,27.71) 42.6,27.93 43.47,27.93 45.65,25.75 45.65,24.71 47.78,22.57 47.78,18.64 47.05,17.9 44.3,17.9 43.96,18.24 21.43,18.24 20.48,19.19 20.48,20.06 20.06,20.48 19.73,20.48 C498.1
  IN2 w0.114: v2(132.16,120.65) 132.27,120.76 132.27,121.71 131.86,122.12 130.99,122.12 130.93,122.06 130.93,122.05 130.7,121.82 130.7,121.82 130.51,121.64 130.51,119.78 129.7,118.97 128.2,118.97 127.83,119.34 125.7,119.34 125.3,118.94 123.54,118.94 122.45,117.85 121.72,117.85 121.16,118.41 121.16,118.51 120.81,118.86 120.77,118.91 120.76,118.91 120.75,118.92 116.2,118.92 116.18,118.94 116.17,118.94 115.88,118.65 107.21,118.65 106.9,118.35 104.77,118.35 104.27,118.84 101.99,118.84 100.63,120.2 96.69,120.2 94.91,121.98 91.84,121.98 88.98,119.12 85.31,119.12 83.27,117.09 82.28,117.09 73.97,108.78 54.84,108.78 49.56,103.5 49.56,100.35 47.24,98.03 47.24,88.65 50.6,85.29 50.6,70.52 46.27,66.19 45.14,66.19 40.38,61.42 38.47,61.42 37.03,59.98 31.87,59.98 29.19,57.3 29.19,46.15 27.1,44.05 27.1,41.89 29.88,39.11 31.53,39.11 41.15,29.48 41.15,28.19 41.35,28 42.08,28 v1(42.37,27.71)
  BOTTOM w0.079: v2(132.16,120.65) 132.16,120.92 132.53,121.29 132.77,121.29 132.81,121.25 133.31,121.25 133.69,121.63 U35.D13
USB3_TXP0_C: length 3.4
  TOP w0.114: C498.2 18.29,20.53 17.94,20.53 17.63,20.22 17.63,19.5 17.91,19.21 18.48,19.21 18.54,19.16 18.54,19.02 R381.2
USB3_TXP0_R: length 10.4
  TOP w0.114: CN16.9 12.92,18.24 13.02,18.14 13.65,18.14 14.04,17.76 14.73,17.76 15.71,16.78 15.71,16.43 16.19,15.95 16.48,15.95 U24.1 16.7,15.93 18.68,15.93 18.86,16.1 18.86,16.35 18.75,16.45 18.75,16.64 C505.1 18.35,18.04 R381.1
USB3_TXP1: length 230.1
  TOP w0.114: C459.1 23.96,34.59 24.36,34.19 24.93,34.19 25.13,34.39 25.13,36.11 25.76,36.75 25.76,38.02 25.33,38.45 25.33,39.75 25.56,39.97 26.32,39.97 26.42,40.08 26.42,40.36 26.32,40.46 v1(26.17,40.46)
  IN2 w0.114: v1(143.66,136.98) 144.04,137.36 144.04,138.13 143.46,138.7 138.74,138.7 136.91,136.88 126.3,136.88 124.58,135.16 118.86,135.16 118.41,135.62 113.84,135.62 113.21,135 105.59,135 102.65,137.94 97.97,137.94 95.69,135.66 92.26,135.66 89.39,132.79 85.07,132.79 73.12,120.83 68.23,120.83 67.8,120.41 64.18,120.41 62.6,121.98 54.89,121.98 39.38,106.47 39.38,101.14 38.49,100.25 38.49,83.61 37.42,82.54 36.71,82.54 36.29,82.12 36.29,79.72 36.75,79.26 36.75,76.11 34.64,74 34.64,72.98 33.85,72.19 32.05,72.19 28.54,68.69 28.54,66.61 28.86,66.29 28.86,64.65 27.23,63.02 27.23,60.37 25.65,58.78 25.65,53.51 24.16,52.03 24.16,41.35 25.44,40.07 25.54,39.97 26.37,39.97 26.45,40.04 26.45,40.36 26.35,40.46 v1(26.17,40.46)
  BOTTOM w0.114: v1(143.66,136.98) 143.95,136.69 143.95,136.14 144.1,135.99 144.1,129.79 141.34,127.03 138.42,127.03 137.34,125.95 136.37,125.95 134.68,124.26 134.49,124.26 133.94,123.71 U35.A13
USB3_TXP1_C: length 1
  TOP w0.114: C459.2 R340.2
USB3_TXP1_R: length 10.3
  TOP w0.114: CN13.9 12.92,34.97 13.02,34.87 13.42,34.87 14.06,34.22 14.6,34.22 14.89,34.51 18,34.51 18.71,33.8 U21.10 19.09,33.75 19.34,33.75 19.72,34.13 19.85,34.13 C458.1 20.34,34.59 R340.1
USB3_TXP2: length 140.3
  TOP w0.114: C369.1 35.96,118.17 38.66,118.17 41.03,120.54 53.32,120.54 54.11,119.76 54.27,119.76 v1(54.43,119.92)
  IN2 w0.114: v1(54.43,119.92) 54.26,119.75 54.26,119.6 55.19,118.68 72.61,118.68 85.54,131.6 89.93,131.6 91.99,133.67 95.47,133.67 96.02,134.22 98.06,134.22 98.19,134.09 104.29,134.09 105.18,133.2 110.13,133.2 111.5,131.83 111.81,131.83 112.47,131.17 113.93,131.17 114.56,131.8 121.73,131.8 123.97,134.03 125.58,134.03 127.35,135.8 137.79,135.8 139.54,137.55 141.19,137.55 141.56,137.18 141.56,137.05 141.74,136.88 v1(141.84,136.88)
  BOTTOM w0.076: 136.69,126.68 136.68,126.67 136.64,126.67 136.5,126.52 136.19,126.52 134.67,125 132.89,125 132.23,124.34 132.23,124.07 132.34,123.96 132.34,123.71 U35.A15
  BOTTOM w0.114: 136.69,126.68 138.15,128.14 140.75,128.14 142.74,130.13 142.74,132.6 141.6,133.74 141.6,136.64 v1(141.84,136.88)
USB3_TXP3: length 144.8
  TOP w0.114: v1(56.74,121.47) 56.4,121.47 55.66,122.21 35.99,122.21 C4778.1
  IN2 w0.114: v1(56.74,121.47) 56.74,121.16 57.01,120.89 58.05,119.85 67.68,119.85 68.07,119.46 69.11,119.46 69.93,120.28 73.27,120.28 85.24,132.24 89.55,132.24 92.42,135.11 95.85,135.11 97.25,136.51 99.84,136.51 101.37,134.98 104.49,134.98 105.59,133.88 110.42,133.88 111.79,132.51 112.16,132.51 112.86,131.8 113.58,131.8 114.2,132.43 121.41,132.43 123.69,134.7 125.16,134.7 126.89,136.43 137.23,136.43 139.08,138.28 142.63,138.28 142.89,138.02 142.89,137.69 v1(143.12,137.46)
  BOTTOM w0.076: 137.13,126.24 137.13,126.23 137.1,126.23 137.06,126.2 137.05,126.2 137.04,126.18 136.33,126.18 134.77,124.62 133.09,124.62 132.77,124.29 132.77,123.56 132.72,123.45 132.72,123.36 132.77,123.21 132.77,122.96 132.7,122.76 132.7,122.45 132.63,122.38 132.63,122.28 132.33,121.99 U35.D15
  BOTTOM w0.114: v1(143.12,137.46) 142.91,137.24 142.91,133.62 143.5,133.03 143.5,129.93 141.07,127.49 138.38,127.49 137.13,126.24
USB3_TYPC_RX2N_C: length 12.3
  IN2 w0.114: v1(11.66,118.61) 11.66,118.69 11.82,118.84 11.94,118.84 12.11,118.68 12.11,118.4 11.69,117.98 5.44,117.98 5.25,118.17 CN2021.B10
  BOTTOM w0.114: R11196.2 15.28,118.9 14.81,118.9 14.62,119.08 13.09,119.08 U4509.2 12.89,119.08 12.24,119.08 12.02,118.87 11.9,118.87 11.66,118.63 v1(11.66,118.61)
USB3_TYPC_RX2N_C_RE: length 6.7
  TOP w0.114: U9.1 32.41,117.4 32.5,117.49 32.77,117.49 33.03,117.24 33.03,116.56 33.71,115.87 35.26,115.87 v1(35.79,115.34) 36.31,115.85 36.49,115.85 C394.2
USB3_TYPC_RX2N_RE: length 13.7
  TOP w0.114: v1(27.49,117.27) 27.72,117.49 28.4,117.49 28.5,117.4 U9.27
  BOTTOM w0.114: v1(27.49,117.27) 27.27,117.49 26.42,117.49 25.57,118.35 24.1,118.35 23.41,119.04 16.94,119.04 16.8,118.9 16.28,118.9 R11196.1
USB3_TYPC_RX2P_C: length 12.4
  IN2 w0.114: v1(11.82,119.3) 11.82,119.27 12.33,118.76 12.33,118.31 11.78,117.76 5.51,117.76 CN2021.B11
  BOTTOM w0.114: v1(11.82,119.3) 13.86,119.3 U4509.8 14.03,119.3 14.66,119.3 14.81,119.45 15.28,119.45 R11199.2
USB3_TYPC_RX2P_C_RE: length 6.7
  TOP w0.114: U9.2 32.41,117.8 32.5,117.71 32.86,117.71 33.24,117.33 33.24,116.64 33.8,116.09 35.27,116.09 v1(35.79,116.61) 36.34,116.06 36.46,116.06 C4781.2
USB3_TYPC_RX2P_RE: length 13.7
  TOP w0.114: U9.26 28.47,117.8 28.38,117.71 27.7,117.71 27.49,117.92 v1(27.49,117.93)
  BOTTOM w0.114: v1(27.49,117.93) 27.27,117.71 26.51,117.71 25.66,118.56 24.19,118.56 23.49,119.25 16.96,119.25 16.77,119.45 16.28,119.45 R11199.1
USB3_TYPC_RX3N_C: length 11.8
  BOTTOM w0.114: CN2021.A10 7.96,121.65 8.1,121.8 12.01,121.8 12.61,121.2 13.83,121.2 U4509.6 14.01,121.08 15.9,122.97 16.92,122.97 17.09,122.81 17.59,122.81 17.7,122.7 R817.2
USB3_TYPC_RX3N_C_RE: length 3.2
  TOP w0.114: C4777.2 34.44,119.93 33.53,119.93 33.46,119.86 32.62,119.86 32.56,119.8 U9.7
USB3_TYPC_RX3N_RE: length 12.4
  TOP w0.114: U9.21 28.51,119.8 28.43,119.88 27.64,119.88 v1(27.39,119.63)
  BOTTOM w0.114: v1(27.39,119.63) 27.13,119.88 26.12,119.88 24.74,121.25 v1(24.01,121.25) 24.01,121.99 23.96,122.04 20.88,122.04 19.95,122.97 19.52,122.97 19.35,122.81 18.84,122.81 18.74,122.7 R817.1
USB3_TYPC_RX3P_C: length 11.8
  BOTTOM w0.114: CN2021.A11 7.96,122.15 8.1,122.01 12.1,122.01 12.7,121.41 12.92,121.41 U4509.5 13.06,121.41 14.03,121.41 15.81,123.19 16.92,123.19 17.09,123.36 17.59,123.36 17.7,123.46 R816.2
USB3_TYPC_RX3P_C_RE: length 3.2
  TOP w0.114: C4776.2 34.45,120.15 33.45,120.15 33.37,120.07 32.62,120.07 32.49,120.2 U9.8
USB3_TYPC_RX3P_RE: length 12.4
  TOP w0.114: U9.20 28.52,120.2 28.42,120.1 27.63,120.1 v1(27.39,120.34)
  BOTTOM w0.114: R816.1 18.74,123.46 18.84,123.36 19.35,123.36 19.52,123.19 20.04,123.19 20.97,122.26 24.05,122.26 24.15,122.15 v1(24.91,122.15) 24.91,121.4 26.21,120.1 27.15,120.1 v1(27.39,120.34)
USB3_TYPC_TX2N_C: length 10.5
  BOTTOM w0.114: R820.2 15.9,117.6 15.71,117.41 15.28,117.41 15.02,117.15 14.85,117.15 14.59,117.42 14.59,118.21 14.36,118.43 13.99,118.43 U4509.9 13.9,118.43 12.22,118.43 11.5,117.71 8.83,117.71 8.67,117.87 8.09,117.87 8.01,117.95 8.01,118.08 7.93,118.15 CN2021.A3
USB3_TYPC_TX2N_C_RE: length 4.1
  TOP w0.114: C4780.2 34.56,117.78 34.18,117.78 34.07,117.67 v1(34.07,117.37) 33.58,117.85 33.58,118 32.9,118.69 32.49,118.69 32.4,118.6 U9.4
USB3_TYPC_TX2N_R: length 2.9
  BOTTOM w0.114: C4771.1 19.12,117.36 19.03,117.27 17.62,117.27 17.47,117.41 16.96,117.41 16.78,117.6 R820.1
USB3_TYPC_TX2N_RE: length 11.3
  TOP w0.114: v1(22.69,118.28) 22.9,118.07 22.9,117.76 23.15,117.52 23.77,117.52 24.92,118.68 28.4,118.68 28.48,118.6 U9.24
  BOTTOM w0.114: C4771.2 20.27,117.28 22.61,117.28 22.9,117.57 22.9,118.07 v1(22.69,118.28)
USB3_TYPC_TX2P_C: length 10.2
  BOTTOM w0.114: CN2021.A2 8.58,117.65 8.74,117.49 11.59,117.49 12.31,118.22 12.86,118.22 U4509.1 13.11,118.2 14.28,118.2 14.37,118.1 14.37,117.33 14.76,116.94 15.17,116.94 15.24,116.86 15.79,116.86 R821.2
USB3_TYPC_TX2P_C_RE: length 4.1
  TOP w0.114: C369.2 34.85,118.4 34.45,118.01 34.34,118.01 34.07,118.28 v1(34.07,118.64) 33.69,118.26 33.64,118.26 32.99,118.9 32.49,118.9 32.4,119 U9.5
USB3_TYPC_TX2P_R: length 2.7
  BOTTOM w0.114: R821.1 16.81,116.71 16.96,116.86 17.47,116.86 17.66,117.05 18.83,117.05 C4770.1
USB3_TYPC_TX2P_RE: length 11.2
  TOP w0.114: v1(23.35,118.26) 23.12,118.03 23.12,117.85 23.24,117.74 23.68,117.74 24.83,118.89 28.38,118.89 28.49,119 U9.23
  BOTTOM w0.114: C4770.2 20.21,117.06 22.7,117.06 23.12,117.48 23.12,118.03 v1(23.35,118.26)
USB3_TYPC_TX3N_C: length 12.3
  IN2 w0.114: v1(11.92,121.3) 12.07,121.15 12.16,121.15 12.34,121.33 12.34,121.55 12.07,121.81 5.39,121.81 5.25,121.67 CN2021.B3
  BOTTOM w0.114: v1(11.92,121.3) 12.07,121.15 12.35,121.15 12.92,120.58 U4509.4 14.15,120.58 14.74,121.17 15.15,121.17 15.29,121.3 R11207.2
USB3_TYPC_TX3N_C_RE: length 3.9
  TOP w0.114: C4779.2 34.47,121.94 34.04,121.94 33.99,121.89 v1(33.99,121.23) 33.23,121.23 33.08,121.08 32.57,121.08 32.49,121 U9.10
USB3_TYPC_TX3N_R: length 3.3
  BOTTOM w0.114: C4762.1 18.72,121.16 17.86,121.16 17.71,121.01 17.08,121.01 16.91,121.17 16.4,121.17 16.27,121.3 R11207.1
USB3_TYPC_TX3N_RE: length 11.3
  TOP w0.114: U9.18 28.45,121 28.38,121.08 24.06,121.08 23.68,120.69 23.68,120.16 v1(23.91,119.93)
  BOTTOM w0.114: v1(23.91,119.93) 23.67,120.17 23.67,120.7 23.24,121.13 20.33,121.13 C4762.2
USB3_TYPC_TX3P_C: length 12.3
  IN2 w0.114: v1(12.2,120.7) 12.55,121.05 12.55,121.64 12.16,122.03 5.53,122.03 CN2021.B2
  BOTTOM w0.114: R11202.2 15.29,120.49 15.15,120.62 14.5,120.62 14.24,120.37 14.13,120.37 U4509.7 13.81,120.31 12.58,120.31 v1(12.2,120.7)
USB3_TYPC_TX3P_C_RE: length 3.9
  TOP w0.114: C4778.2 34.43,122.16 33.12,122.16 v1(33.09,122.13) 33.09,121.4 32.99,121.29 32.57,121.29 32.46,121.4 U9.11
USB3_TYPC_TX3P_R: length 3.3
  BOTTOM w0.114: R11202.1 16.27,120.49 16.4,120.62 16.91,120.62 17.08,120.79 17.8,120.79 17.95,120.94 18.72,120.94 C4763.1
USB3_TYPC_TX3P_RE: length 11.2
  TOP w0.114: U9.17 28.49,121.4 28.38,121.29 23.97,121.29 23.46,120.78 23.46,120.2 v1(23.22,119.96)
  BOTTOM w0.114: C4763.2 20.27,120.91 23.15,120.91 23.45,120.61 23.45,120.19 v1(23.22,119.96)
USB_BC_ON: length 187.1
  TOP w0.127: v1(17.2,28.93) 17.52,28.61 U22.4
  IN1 w0.14: v1(40.6,19.55) 41.1,19.55 42.98,21.43 45.78,21.43 48.64,18.57 64.79,18.57 65.68,17.68 67.15,17.68 71.64,22.17 80.4,22.17 88.17,29.94 105.11,29.94 106.69,28.37 109.74,28.37 110.43,27.68 114.19,27.68 114.57,28.06 122.53,28.06 125.17,25.42 146.72,25.42 154.85,33.55 163.88,33.55 164.42,34.09 167.26,34.09 167.58,34.41 169.27,34.41 169.71,34.85 169.72,34.85 171.84,36.97 171.84,40.15 173.41,41.72 173.42,41.72 v1(173.42,41.71)
  BOTTOM w0.127: v1(17.2,28.93) 16.74,28.93 16.41,28.59 16.41,28.14 16.62,27.93 16.62,25.37 17.15,24.84 18.4,24.84 22.31,20.92 22.31,18.87 23.7,17.47 38.51,17.47 v1(39.73,18.69) v1(40.6,19.55) ; U45.97 173.18,42.02 173.23,41.96 173.42,41.77 v1(173.42,41.71)
USB_CHARGE_ON: length 186.4
  TOP w0.127: v1(16.95,28.32) 16.47,28.79 R364.1 16.11,28.56 v1(16.11,27.99) 16.11,27.48 16.35,27.24 U22.5
  IN1 w0.14: v1(39.96,19.76) 40.29,20.08 40.29,20.24 42.04,21.99 46.03,21.99 48.89,19.13 65.02,19.13 65.91,18.24 66.92,18.24 71.41,22.73 80.04,22.73 87.81,30.5 105.34,30.5 106.92,28.93 109.97,28.93 110.55,28.35 114.03,28.35 114.89,29.2 122.18,29.2 125.41,25.98 146.46,25.98 154.59,34.11 158.76,34.11 159.3,34.65 167.03,34.65 167.35,34.97 167.87,34.97 169.85,36.95 170.31,36.95 171.35,37.99 171.35,41.82 v1(171.27,41.9)
  BOTTOM w0.127: U45.96 170.84,41.4 170.73,41.51 170.73,41.79 170.85,41.9 v1(171.27,41.9) ; v1(39.96,19.76) 38,17.8 23.76,17.8 22.56,18.99 22.56,21.08 18.55,25.09 17.28,25.09 16.92,25.45 16.92,28.29 v1(16.95,28.32)
USB_CLT1: length 203.2
  TOP w0.127: U22.6 15.91,26.74 v1(15.91,26.74)
  IN2 w0.14: v1(15.91,26.74) 15.91,25.8 16.64,25.06 21.42,25.06 22.71,26.36 24.87,26.36 26.35,24.88 26.35,23.08 33.98,15.45 33.98,13.75 37.25,10.48 66.32,10.48 71.86,16.02 71.86,17.61 73.81,19.56 77.5,19.56 78.96,21.01 82.23,21.01 89.73,28.52 102.54,28.52 112.83,18.23 124.21,18.23 127.15,21.18 135.08,21.18 135.59,21.69 139.25,21.69 141.33,19.6 158.03,19.6 163.46,25.04 169.4,25.04 174.8,30.44 175.72,30.44 176.57,31.29 181.61,31.29 182.48,30.42 v1(183.11,30.42)
  BOTTOM w0.127: U45.31 186.27,29.4 185.73,29.94 183.59,29.94 v1(183.11,30.42)
USB_OC0#: length 233.4
  TOP w0.127: v1(21.44,25.8) 21.22,25.57 20.45,25.57 20.29,25.74 U22.13
  IN1 w0.14: v1(145.83,126.89) 145.83,128.57 140.39,134 122.85,134 119.73,130.88 112.07,130.88 111.11,131.85 109.84,131.85 106.97,128.98 95.74,128.98 95.26,128.49 92.18,128.49 88.73,125.04 84,125.04 64.44,105.47 51,105.47 48.29,102.76 48.29,99.23 46.79,97.73 46.79,84.73 45.84,83.78 45.84,80.36 48.52,77.68 48.52,70.2 48.11,69.79 47.42,69.79 43.84,66.21 42.45,66.21 36.35,60.11 36.35,48.64 36.58,48.41 36.58,43.36 35.16,41.93 35.16,37.76 31.98,34.59 31.98,29.94 28.9,26.86 28.9,21.77 v1(28.66,21.53)
  IN2 w0.14: v1(28.66,21.53) 26.63,23.57 26.63,25 24.99,26.64 22.28,26.64 v1(21.44,25.8)
  BOTTOM w0.076: 137.55,124.51 137.4,124.36 137.04,124.36 136.4,123.71 U35.A9
  BOTTOM w0.127: R541.1 147.12,127.02 146.84,127.3 146.23,127.3 v1(145.83,126.89) 145.27,126.33 143.59,126.33 142.93,125.67 138.72,125.67 137.55,124.51
USB_OC1#: length 217.8
  TOP w0.127: v1(25.13,37.18) 25.1,37.15 24.21,37.15 v1(24.03,36.98) 23.85,36.79 U20.3
  IN1 w0.14: v1(33.25,35.12) 33.64,35.12 35.77,37.26 35.77,42.15 36.86,43.24 36.86,48.52 36.63,48.75 36.63,60 42.57,65.93 43.95,65.93 47.51,69.49 48.2,69.49 48.8,70.08 48.8,77.79 46.12,80.47 46.12,82.47 47.22,83.57 47.22,97.68 48.65,99.11 48.65,102.64 51.12,105.11 64.51,105.11 84.16,124.76 88.88,124.76 92.34,128.21 95.41,128.21 95.87,128.67 107.09,128.67 109.99,131.57 110.99,131.57 111.96,130.6 119.84,130.6 122.87,133.62 140.26,133.62 144.43,129.46 144.43,125.72 v1(144.84,125.32)
  IN2 w0.14: v1(25.13,37.18) 26.27,37.18 27.29,36.16 32.21,36.16 v1(33.25,35.12)
  BOTTOM w0.076: 137.78,124.05 137.75,124.03 137.18,124.03 137.01,123.86 137.01,122.87 137.02,122.86 137.02,122.62 137.01,122.61 137.01,122.6 136.83,122.41 U35.C9
  BOTTOM w0.127: R540.1 147.16,125.32 v1(144.84,125.32) 143.52,125.32 143.34,125.14 138.87,125.14 137.78,124.05
USB_OC2#: length 190.8
  TOP w0.127: v1(169.75,116.7) v1(168.89,116.7) 168.65,116.7 167.73,117.62 166.69,118.66 165.03,118.66 163.05,120.64 163.05,124.2 160.64,126.61 156.29,126.61 155.94,126.97 150.7,126.97 v1(149.69,125.95)
  IN1 w0.14: v1(221.67,50.92) 221.34,50.92 220.78,50.36 220.78,49.32 222.89,47.21 222.89,41.63 221.93,40.66 218.65,40.66 217.2,39.21 217.2,35.76 216.62,35.17 214.76,35.17 214.46,35.48 214.05,35.48 213.49,34.92 v1(213.49,34.87) ; v1(206.3,61.44) 206.3,58.72 204.03,56.44 196.76,56.44 193.25,59.94 192.67,59.94 191.98,60.63 189.73,60.63 189.02,61.34 185.97,61.34 180.51,66.8 179.87,66.8 176.08,70.58 176.08,74.34 175.82,74.59 175.82,81.36 180.3,85.84 180.3,90.29 179.13,91.45 179.13,99.94 177.43,101.65 177.43,104.16 178.16,104.9 178.16,106.4 174.94,109.62 174.94,115.13 173.37,116.7 v1(169.75,116.7)
  BOTTOM w0.076: 137.81,125.1 136.59,125.1 135.87,124.38 135.87,122.06 U35.D9
  BOTTOM w0.127: v1(206.3,61.44) 207.04,61.44 207.24,61.23 212.21,61.23 214.12,59.33 214.12,54.93 217.85,51.2 221.39,51.2 v1(221.67,50.92) ; v1(149.69,125.95) 149.69,127.55 148.82,128.42 147.55,128.42 147.37,128.23 R543.1 145.57,127.91 144.61,126.95 143.8,126.95 142.82,125.97 138.68,125.97 137.81,125.1 ; v1(213.49,34.87) 213.49,34.4 U4511.3
USB_OC3#: length 146
  TOP w0.127: R11281.1 34.66,102.12 v1(34.78,102)
  IN1 w0.14: v1(47.25,101.11) 47.25,102.12 50.88,105.75 64.27,105.75 83.84,125.32 88.55,125.32 92,128.77 95.14,128.77 95.62,129.26 106.85,129.26 109.72,132.13 111.22,132.13 112.19,131.16 119.61,131.16 122.74,134.28 140.51,134.28 146.11,128.69 146.11,128.62 146.56,128.16 v1(146.56,126.84)
  BOTTOM w0.076: 137.65,124.28 137.56,124.19 137.11,124.19 136.85,123.93 136.85,123.25 136.66,123.06 U35.B9
  BOTTOM w0.127: 137.65,124.28 138.77,125.39 143.11,125.39 143.74,126.03 145.57,126.03 145.6,126 R542.1 147.37,126.24 146.77,126.84 v1(146.56,126.84) ; v1(47.25,101.11) 35.67,101.11 v1(35.36,101.42) v1(34.78,102)
USBCOMP: length 4.8
  TOP w0.114: R178.1 141.54,113 141.11,113.43 140.39,113.43 140.1,113.14 v2(137.76,113.14)
  BOTTOM w0.114: U35.AB6 138.09,112.6 137.76,112.92 v2(137.76,113.14)
USBON#: length 252.9
  TOP w0.127: v1(214.31,34.84) v1(214.31,36.62) 214.76,37.08 214.76,38.5 211.49,41.78 208.8,41.78 207.17,43.4 206.43,43.4 205.63,44.21 194.38,44.21 193.68,44.91 193.68,47.2 192.58,48.31 191.73,48.31 v1(191.67,48.36) ; v1(22.13,37.87) 22.85,38.59 U20.4 ; v1(173.84,41.22) 174.22,41.6 175.11,41.6 175.56,41.16 176.04,41.16 176.42,40.77 177.82,40.77 179.19,42.15 181.54,42.15 181.81,41.88 185.19,41.88 185.77,41.31 187.12,41.31 187.18,41.37 188.14,41.37 189.85,43.07 189.85,45.31 v1(190.3,45.77)
  IN1 w0.14: v1(173.84,41.22) 172.12,39.49 172.12,36.85 169.84,34.57 169.82,34.57 169.39,34.13 167.7,34.13 167.34,33.78 164.57,33.78 164.54,33.81 163.99,33.27 154.97,33.27 146.84,25.14 125,25.14 122.36,27.78 114.69,27.78 114.31,27.4 110.31,27.4 109.63,28.09 107.93,28.09 v1(107.6,27.76) ; v1(191.67,48.36) 190.3,46.98 v1(190.3,45.77)
  IN2 w0.14: v1(107.6,27.76) 106.51,27.76 104.35,29.92 89.15,29.92 81.65,22.41 78.38,22.41 76.94,20.97 73.21,20.97 70.44,18.2 70.44,16.61 66.93,13.1 61.52,13.1 59.47,11.05 54.75,11.05 54.14,11.65 54.1,11.65 53.72,12.03 51.62,12.03 50.63,11.05 38,11.05 35.06,13.99 35.06,16.06 27.22,23.9 27.22,26.78 26.45,27.55 23.96,27.55 22.94,28.57 22.94,35.22 22.18,35.99 22.18,37.82 v1(22.13,37.87)
  BOTTOM w0.127: v1(214.31,34.84) 214.92,34.84 215.43,34.34 U4511.4 ; U45.99 173.98,41.36 v1(173.84,41.22)
USBP0+: length 261.9
  TOP w0.114: U22.3 18.02,28.51 18.1,28.6 18.1,28.83 17.93,29 v1(17.91,29)
  IN2 w0.114: v1(26.07,32.2) 26.31,31.96 26.31,31.71 26.56,31.45 27.98,31.45 32.37,27.07 32.37,25.09 36.57,20.89 50.35,20.89 50.36,20.9 57.26,20.9 59.45,23.1 63.59,23.1 65.92,25.42 68.37,25.42 70.23,27.27 73.12,27.27 75.04,29.19 78.21,29.19 85.75,36.74 112.13,36.74 115.84,33.03 117.9,33.03 119.12,31.81 140.1,31.81 142.16,33.87 148.27,33.87 157.09,42.69 157.09,43.28 157.09,44 162.2,49.1 162.2,52.2 161.5,52.9 161.5,57.75 161.96,58.21 161.96,59.8 162.55,60.39 162.55,60.83 162.55,60.84 162.55,62.24 161.75,63.04 161.75,65.78 162.22,66.25 162.22,70.41 162.3,70.49 162.3,72.37 162.72,72.8 162.72,73.44 162.3,73.87 162.3,85.73 163.04,86.46 163.04,88.89 163.62,89.48 163.62,92.4 163.04,92.99 163.04,94.75 163.62,95.33 163.62,102.79 162.83,103.58 162.38,103.58 159.75,106.22 159.75,108.22 156.7,111.27 152.89,111.27 150.92,113.24 145.49,113.24 145.27,113.46 138.29,113.46 137.96,113.79 135.77,113.79 v2(135.15,113.16)
  BOTTOM w0.114: v1(17.91,29) 18.1,29.19 18.1,29.64 19.04,30.58 25.46,30.58 26.28,31.4 26.28,31.99 v1(26.07,32.2) ; U35.AB10 135.15,112.87 v2(135.15,113.16)
USBP0+_C: length 16.1
  TOP w0.114: v1(21.74,13.03) 21.45,13.32 20.97,13.32 20.65,13 R386.2 ; v1(17.94,23.8) 18.16,24.03 18.16,24.29 18.02,24.44 U22.10
  BOTTOM w0.114: v1(21.74,13.03) 21.45,13.32 20.36,13.32 19.65,14.03 19.65,16.87 18.17,18.36 18.17,23.58 v1(17.94,23.8)
USBP0+_R: length 7.1
  TOP w0.114: CN16.3 14.42,14.95 14.54,15.07 14.74,15.07 15.27,14.54 15.27,13.91 15.83,13.36 17.15,13.36 17.19,13.31 18.41,13.31 U24.7 18.55,13.31 19.16,13.31 R386.1
USBP0-: length 261.9
  TOP w0.114: v1(18.64,29) 18.45,29 18.32,28.87 18.32,28.64 18.52,28.44 U22.2
  IN2 w0.114: v1(27.03,32.2) 26.9,32.33 26.65,32.33 26.52,32.2 26.52,31.8 26.65,31.67 28.07,31.67 32.58,27.16 32.58,25.18 36.66,21.1 50.26,21.1 50.27,21.11 57.17,21.11 59.37,23.31 63.5,23.31 65.83,25.64 68.29,25.64 70.14,27.49 73.03,27.49 74.95,29.41 78.12,29.41 85.66,36.95 112.22,36.95 115.93,33.24 117.99,33.24 119.21,32.02 140.01,32.02 142.07,34.08 148.18,34.08 156.88,42.78 156.88,43.19 156.88,44.09 161.98,49.19 161.98,52.12 161.28,52.81 161.28,57.84 161.74,58.3 161.74,59.88 162.33,60.48 162.33,60.92 162.34,60.93 162.34,62.15 161.54,62.95 161.54,65.87 162.01,66.34 162.01,70.5 162.09,70.58 162.09,72.46 162.51,72.89 162.51,73.36 162.09,73.78 162.09,85.82 162.82,86.55 162.82,88.98 163.4,89.56 163.4,92.31 162.82,92.9 162.82,94.84 163.4,95.42 163.4,102.7 162.74,103.37 162.29,103.37 159.53,106.13 159.53,108.13 156.61,111.06 152.8,111.06 150.83,113.02 145.4,113.02 145.18,113.24 138.23,113.24 137.88,113.59 135.85,113.59 135.75,113.5 135.75,113.27 v2(135.86,113.16)
  BOTTOM w0.114: U35.AB9 135.95,112.53 135.66,112.83 135.66,112.96 v2(135.86,113.16) ; v1(27.03,32.2) 26.6,32.2 26.5,32.1 26.5,31.31 25.55,30.36 19.13,30.36 18.32,29.55 18.32,29.21 18.35,29.18 18.35,29.09 18.45,29 v1(18.64,29)
USBP0-_C: length 16
  TOP w0.114: v1(18.65,23.79) 18.61,23.79 18.38,24.03 18.38,24.29 18.52,24.44 U22.11 ; R385.2 20.65,13.86 20.97,13.54 21.69,13.54 21.74,13.6 v1(21.74,13.83)
  BOTTOM w0.114: v1(18.65,23.79) 18.59,23.79 18.38,23.59 18.38,18.45 19.87,16.96 19.87,14.12 20.45,13.54 21.57,13.54 21.74,13.71 v1(21.74,13.83)
USBP0-_R: length 7.2
  TOP w0.114: R385.1 19.15,13.53 17.28,13.53 17.24,13.57 16.65,13.57 U24.4 16.51,13.57 15.92,13.57 15.48,14 15.48,14.63 14.83,15.29 14.53,15.29 14.42,15.4 CN16.2
USBP1+: length 245.9
  TOP w0.114: v1(26.35,35.86) 26.64,35.57 27.07,35.57 27.36,35.28 27.36,33.8 26.79,33.23 25.53,33.23 24.15,31.85 22.37,31.85 R348.2
  IN2 w0.114: v2(137.51,111.99) 137.68,111.83 137.68,111.57 137.92,111.34 140.91,111.34 141.1,111.14 150.6,111.14 150.82,110.93 150.82,109.68 152.99,107.51 152.99,104.36 153.85,103.5 158.71,103.5 161.4,100.81 161.4,87.14 160.66,86.41 160.66,71.17 159.86,70.36 159.86,61.15 160.31,60.7 160.31,59.02 159.86,58.57 159.86,49.08 150.32,39.54 147.03,39.54 144.49,37 143.52,37 140.57,34.06 116.26,34.06 112.66,37.66 85.37,37.66 78.85,31.15 77.46,31.15 76.59,30.27 74.8,30.27 72.73,28.2 69.84,28.2 67.99,26.35 65.53,26.35 63.23,24.05 55.19,24.05 53.03,26.21 50.31,26.21 49.77,26.74 41.87,26.74 38.49,30.12 38.49,31.06 37.62,31.92 35.42,31.92 31.81,35.54 26.66,35.54 v1(26.35,35.86)
  BOTTOM w0.114: U35.AD7 137.43,111.91 v2(137.51,111.99)
USBP1+_R: length 8.1
  TOP w0.114: CN13.3 14.42,31.62 14.5,31.71 14.88,31.71 15.11,31.48 18.97,31.48 U21.7 19.11,31.48 19.88,31.48 20.26,31.85 20.92,31.85 R348.1
USBP1-: length 245.8
  TOP w0.114: v1(26.35,35.06) 26.64,35.35 26.98,35.35 27.15,35.19 27.15,33.89 26.7,33.45 25.44,33.45 24.06,32.07 22.37,32.07 R342.2
  IN2 w0.114: v1(26.35,35.06) 26.61,35.33 31.72,35.33 35.33,31.71 37.53,31.71 38.27,30.97 38.27,30.03 41.78,26.52 49.68,26.52 50.22,25.99 52.94,25.99 55.1,23.83 63.32,23.83 65.62,26.13 68.08,26.13 69.93,27.98 72.82,27.98 74.89,30.06 76.68,30.06 77.55,30.93 78.94,30.93 85.46,37.45 112.57,37.45 116.17,33.84 140.66,33.84 143.61,36.79 144.58,36.79 147.12,39.33 150.41,39.33 160.08,48.99 160.08,58.48 160.53,58.93 160.53,60.79 160.08,61.24 160.08,70.27 160.88,71.08 160.88,86.32 161.61,87.05 161.61,100.9 158.8,103.72 153.94,103.72 153.21,104.45 153.21,107.6 151.03,109.77 151.03,111.02 150.69,111.36 141.19,111.36 141,111.55 137.97,111.55 137.87,111.65 137.87,111.81 138.06,111.99 v2(138.14,111.99)
  BOTTOM w0.114: v2(138.14,111.99) 138.01,111.99 137.9,111.88 137.9,111.6 138.04,111.47 U35.AD6
USBP1-_R: length 8.1
  TOP w0.114: R342.1 20.92,32.07 20.17,32.07 19.79,31.69 17.25,31.69 U21.4 17.03,31.69 15.2,31.69 14.97,31.92 14.5,31.92 14.42,32.01 CN13.2
USBP2+: length 202.5
  IN2 w0.114: v2(138.66,108.81) 138.66,108.9 138.79,109.02 139.41,109.02 140.81,107.63 141.06,107.37 141.06,106.53 141.92,105.68 143.47,105.68 144,106.22 146.01,106.22 149.1,103.12 150.22,103.12 150.98,102.36 150.98,101.27 151.7,100.55 156.42,100.55 158.07,98.9 158.07,93.34 158.5,92.91 158.5,89.57 157.99,89.05 157.99,68.51 158.35,68.15 158.35,60.52 158.89,59.98 158.89,59.61 158.35,59.07 158.35,49.73 149.71,41.09 146.4,41.09 144.56,39.25 142.37,39.25 140.53,37.41 140.53,36.99 v1(140.32,36.77)
  BOTTOM w0.114: v2(138.66,108.81) 138.66,108.68 138.74,108.6 139.73,108.6 139.83,108.51 139.83,108.27 139.73,108.17 139.61,108.17 U35.AJ3 ; CN2020.7 211.85,19.65 211.99,19.51 213.26,19.51 214.42,18.35 214.42,11.6 214.42,11.19 214.42,11.01 211.87,8.46 204.14,8.46 200.11,12.49 195.93,16.66 182.91,16.66 182.63,16.38 172.88,16.38 172.27,15.77 167.53,15.77 167.47,15.83 164.56,15.83 164.45,15.95 163.71,15.95 157.28,22.37 151.67,22.37 145.33,28.71 145.33,30.97 144.57,31.73 144.57,33.33 142.21,35.69 140.91,35.69 140.56,36.05 140.56,36.53 v1(140.32,36.77)
USBP2-: length 202.4
  IN2 w0.114: v1(140.98,36.75) 140.75,36.98 140.75,37.32 142.46,39.03 144.65,39.03 146.49,40.88 149.8,40.88 158.57,49.64 158.57,58.98 159.1,59.52 159.1,60.07 158.57,60.61 158.57,68.24 158.2,68.6 158.2,88.97 158.72,89.48 158.72,93 158.29,93.43 158.29,98.99 156.51,100.77 151.79,100.77 151.35,101.21 151.2,101.36 151.2,102.45 150.31,103.33 149.19,103.33 146.09,106.43 143.91,106.43 143.38,105.9 142.01,105.9 141.28,106.62 141.28,107.46 140.96,107.78 139.5,109.24 138.44,109.24 138.06,108.86 v2(137.72,108.86)
  BOTTOM w0.114: v2(137.72,108.86) 138.11,108.86 138.49,109.24 138.88,109.24 U35.AH3 ; CN2020.8 211.85,19.15 211.99,19.29 213.17,19.29 214.2,18.26 214.2,11.51 214.2,11.1 211.78,8.68 204.23,8.68 200.26,12.64 196.02,16.88 182.83,16.88 182.54,16.59 172.79,16.59 172.18,15.98 167.62,15.98 167.56,16.05 164.65,16.05 164.54,16.16 163.8,16.16 157.37,22.59 151.76,22.59 145.55,28.8 145.55,31.06 144.79,31.82 144.79,33.42 142.3,35.91 141,35.91 140.77,36.14 140.77,36.55 v1(140.98,36.75)
USBP3+: length 205.6
  IN2 w0.114: v1(135.6,112.02) 136.23,112.64 136.32,112.64 136.35,112.67 136.53,112.67 136.54,112.67 138.74,112.67 139.12,112.29 140.09,112.29 140.43,112.63 142.26,112.63 142.81,112.08 151.01,112.08 153.88,109.21 157.11,109.21 157.93,108.39 157.93,107.82 158.68,107.07 158.68,106.27 162.08,102.87 162.54,102.87 162.91,102.5 162.91,95.63 162.32,95.04 162.32,92.69 162.91,92.11 162.91,89.77 162.32,89.19 162.32,86.76 161.59,86.02 161.59,70.78 160.79,69.98 160.79,62.33 161.84,61.28 161.84,60.68 161.24,60.08 161.24,58.63 160.79,58.18 160.79,48.7 156.38,44.29 156.38,42.98 147.97,34.58 145.66,34.58 145.46,34.78 145.46,35.06 v1(145.19,35.33)
  BOTTOM w0.114: v1(135.6,112.02) 135.6,111.59 U35.AD10 ; v1(145.19,35.33) 145.46,35.06 145.46,32.44 146.09,31.81 146.09,29.01 151.85,23.26 162.13,23.26 162.77,23.9 168.18,23.9 171.04,21.04 171.67,21.04 171.89,20.82 171.89,19.45 174.22,17.11 181.44,17.11 181.91,17.58 196.31,17.58 204.7,9.19 211.59,9.19 213.71,11.31 213.71,16.66 212.72,17.65 CN2020.11
USBP3-: length 205.6
  IN2 w0.114: v1(146.16,35.28) 146.16,35.66 146.06,35.76 145.78,35.76 145.68,35.66 145.68,34.87 145.75,34.79 147.88,34.79 156.17,43.07 156.17,44.38 160.57,48.79 160.57,58.27 161.02,58.72 161.02,60.17 161.62,60.77 161.62,61.19 160.57,62.24 160.57,70.07 161.37,70.87 161.37,86.11 162.11,86.85 162.11,89.28 162.69,89.86 162.69,92.02 162.11,92.6 162.11,95.13 162.69,95.72 162.69,102.41 162.45,102.65 161.99,102.65 158.46,106.18 158.46,106.98 157.71,107.73 157.71,108.3 157.02,109 153.79,109 150.92,111.87 142.72,111.87 142.17,112.41 140.52,112.41 140.18,112.07 139.03,112.07 138.65,112.45 136.44,112.45 136.26,112.27 v2(136.26,112.02)
  BOTTOM w0.114: v2(136.26,112.02) 136.24,112.02 135.99,111.76 135.99,111.61 U35.AD9 ; CN2020.12 211.81,17.15 211.89,17.23 211.89,17.37 211.96,17.43 212.63,17.43 213.49,16.57 213.49,11.4 211.5,9.41 204.79,9.41 196.4,17.8 181.82,17.8 181.35,17.33 174.31,17.33 172.1,19.54 172.1,20.91 171.76,21.25 171.13,21.25 168.27,24.11 162.68,24.11 162.04,23.48 151.94,23.48 146.31,29.1 146.31,31.9 145.68,32.53 145.68,35.68 145.78,35.78 146.06,35.78 146.16,35.68 v1(146.16,35.28)
USBP4+: length 150.9
  IN2 w0.114: v1(149.66,137.64) 149.45,137.85 149.45,138.32 149.79,138.67 156.08,138.67 156.67,139.26 156.67,140.1 155.54,141.23 155.54,147.02 154.76,147.81 154.76,155.82 157.42,158.49 157.42,163.23 159.75,165.55 159.75,166.49 161.05,167.8 161.05,170.95 162.49,172.38 180.35,172.38 181.96,174 189.38,174 193.52,178.14 196.61,178.14 197,178.52 197,178.77 197.24,179.01 v1(197.24,179.02)
  BOTTOM w0.114: v1(149.66,137.64) 149.4,137.37 149.4,134.68 153.92,130.16 153.92,124.49 157.85,120.56 157.85,118.68 159.28,117.25 159.28,110.78 157.55,109.05 151.73,109.05 151.45,108.77 145.89,108.77 145.71,108.59 143.45,108.59 143.15,108.29 141.28,108.29 140.98,107.98 140.45,107.98 U35.AJ2 ; CN10.3 191.89,191.5 192.03,191.36 193.28,191.36 194.13,190.51 194.13,183.62 196.97,180.78 196.97,179.29 v1(197.24,179.02)
USBP4-: length 150.9
  IN2 w0.114: v1(196.12,179.01) 196.68,179.01 196.78,178.91 196.78,178.61 196.53,178.35 193.43,178.35 189.29,174.21 181.87,174.21 180.26,172.6 162.4,172.6 160.84,171.04 160.84,167.89 159.53,166.58 159.53,165.64 157.21,163.32 157.21,158.58 154.54,155.91 154.54,147.72 155.33,146.93 155.33,141.14 156.46,140.01 156.46,139.35 155.99,138.88 149.7,138.88 149.23,138.41 149.23,137.79 149.08,137.64 v1(148.86,137.64)
  BOTTOM w0.114: v1(148.86,137.64) 149.05,137.64 149.18,137.51 149.18,134.59 153.7,130.07 153.7,124.4 157.64,120.47 157.64,118.59 159.06,117.16 159.06,110.87 157.46,109.27 151.64,109.27 151.36,108.99 145.8,108.99 145.62,108.81 143.36,108.81 143.06,108.5 141.05,108.5 U35.AJ1 ; v1(196.12,179.01) 196.3,178.84 196.65,178.84 196.75,178.94 196.75,180.69 193.91,183.53 193.91,190.42 193.19,191.14 192.04,191.14 191.9,191 CN10.5
USBP5+: length 151.8
  TOP w0.114: R4.2 126.19,175.39 126.31,175.27 126.31,175.09 122.8,171.58 122.8,171.28 122.48,170.96 v1(122.48,170.86)
  IN2 w0.114: v1(147.26,137) 146.97,137.29 146.97,138.07 144.32,140.72 137.81,140.72 135.97,138.88 126.7,138.88 125.95,139.63 125.95,142.07 123.26,144.76 117.49,144.76 112.67,139.94 108.08,139.94 106.64,141.38 106.64,148.4 108.19,149.96 111.5,149.96 113.9,152.36 113.9,158.69 114.94,159.73 114.94,162.99 118.12,166.16 121.67,166.16 124.1,168.59 124.1,171.13 123.75,171.47 123.07,171.47 122.48,170.89 v1(122.48,170.86) ; v1(149.56,110.66) 149.35,110.45 149.35,110.19 148.94,109.79 144.24,109.79 143.34,110.69 139.15,110.69 138.69,110.23 137.75,110.23 v2(137.1,110.88)
  BOTTOM w0.114: U35.AF7 137.43,110.54 v2(137.1,110.88) ; v1(147.26,137) 147.05,136.78 147.05,134.97 152.42,129.6 152.42,123.81 155.87,120.35 155.87,117.81 157.7,115.98 157.7,112.55 156.2,111.06 150.52,111.06 150.5,111.07 150.13,111.07 149.71,110.66 v1(149.56,110.66)
USBP5-: length 151.8
  TOP w0.114: R3.2 126.44,175.44 126.52,175.36 126.52,175 123.02,171.5 123.02,170.96 123.11,170.87 v1(123.13,170.87)
  IN2 w0.114: v1(123.13,170.87) 123.13,170.97 123.37,171.22 123.63,171.22 123.88,170.96 123.88,168.68 121.58,166.38 118.03,166.38 114.73,163.08 114.73,159.82 113.68,158.78 113.68,152.45 111.41,150.17 108.1,150.17 106.42,148.49 106.42,141.29 107.99,139.72 112.76,139.72 117.58,144.55 123.17,144.55 125.74,141.98 125.74,139.54 126.61,138.67 136.06,138.67 137.9,140.51 144.23,140.51 146.75,137.98 146.75,137.16 v1(146.59,137) ; v1(148.76,110.66) 149.03,110.66 149.13,110.56 149.13,110.28 148.85,110 144.3,110 143.4,110.9 139.03,110.9 138.56,110.43 137.83,110.43 137.71,110.55 v1(137.71,110.89)
  BOTTOM w0.114: v1(148.76,110.66) 148.88,110.66 149.32,111.1 149.85,111.1 150.04,111.29 150.59,111.29 150.61,111.27 156.11,111.27 157.49,112.64 157.49,115.9 155.66,117.72 155.66,120.26 152.2,123.72 152.2,129.51 146.83,134.88 146.83,136.76 v1(146.59,137) ; v1(137.71,110.89) 137.75,110.85 137.75,110.02 137.85,109.93 137.99,109.93 138.09,110.02 U35.AF6
USBP6+: length 147.7
  IN2 w0.114: v1(128.55,171.47) 128.7,171.61 128.7,171.82 128.57,171.95 128.19,171.95 127.65,171.41 127.65,169.65 126.09,168.09 125.41,168.09 121.81,164.5 118.61,164.5 117.66,163.55 116.52,163.55 115.65,162.68 115.65,158.49 114.65,157.49 114.65,152.1 111.79,149.24 108.49,149.24 107.35,148.1 107.35,141.99 108.64,140.7 112.13,140.7 117.09,145.65 123.46,145.65 126.83,142.29 126.83,139.95 127.18,139.59 135.57,139.59 137.41,141.43 145,141.43 148.28,138.16 148.28,137.55 148.43,137.4 148.43,137.23 v1(148.7,136.96)
  BOTTOM w0.114: v1(128.55,171.47) 128.85,171.76 128.85,172.93 128.28,173.5 127.82,173.5 R2.1 ; v1(148.7,136.96) 148.48,136.75 148.48,134.58 153.13,129.93 153.13,124.19 156.74,120.58 156.74,117.99 158.46,116.26 158.46,112.27 155.98,109.79 151.45,109.79 151.16,109.49 145.78,109.49 145.35,109.06 143.14,109.06 142.8,108.73 140.77,108.73 140.65,108.6 140.17,108.6 U35.AH2
USBP6+_R: length 2.2
  BOTTOM w0.114: R2.2 127.04,174.51 126.78,174.77 125.72,174.77 CN5.14
USBP6-: length 147.7
  IN2 w0.114: v1(148,136.96) 148.22,137.18 148.22,137.31 148.06,137.46 148.06,138.07 144.91,141.22 137.5,141.22 135.66,139.38 127.09,139.38 126.61,139.86 126.61,142.2 123.37,145.43 117.18,145.43 112.22,140.48 108.55,140.48 107.13,141.9 107.13,148.19 108.4,149.46 111.7,149.46 114.43,152.19 114.43,157.58 115.44,158.58 115.44,162.77 116.43,163.76 117.57,163.76 118.52,164.71 121.72,164.71 125.32,168.31 126,168.31 127.44,169.74 127.44,171.5 128.1,172.16 128.66,172.16 128.92,171.91 128.92,171.75 129.19,171.47 v1(129.35,171.47)
  BOTTOM w0.114: U35.AH1 140.5,108.93 140.5,108.95 142.72,108.95 143.05,109.28 145.26,109.28 145.69,109.71 151.07,109.71 151.36,110 155.89,110 158.25,112.36 158.25,116.17 156.52,117.9 156.52,120.49 152.91,124.1 152.91,129.84 148.27,134.49 148.27,136.7 v1(148,136.96) ; v1(129.35,171.47) 129.27,171.47 129.06,171.68 129.06,173.02 128.45,173.63 128.45,174.14 R1.1
USBP6-_R: length 2.3
  BOTTOM w0.114: R1.2 126.93,174.92 126.87,174.99 126.21,174.99 125.65,175.55
USBP7+: length 232.7
  TOP w0.114: v1(79.69,91.89) 79.69,91.73 79.58,91.62 79.29,91.62 79.01,91.9 79.01,92.43 79.36,92.78 79.8,92.78 82.28,95.26 82.28,106.95 79.41,109.82 73.44,109.82 71.52,111.74 67.08,111.74 63.32,115.5 63.32,116.62 56.17,123.76 36.21,123.76 33.98,125.99 26.94,125.99 22.88,121.93 22.88,121.32 20.7,119.14 20.23,119.14 20.05,119.32 19.76,119.32 R819.1
  IN2 w0.114: v2(135.86,110.88) 135.77,110.79 135.77,110.56 135.87,110.46 136.59,110.46 137.24,109.81 138.53,109.81 138.85,109.49 140.71,109.49 142.92,107.28 143.25,106.95 145.49,106.95 145.51,106.93 146.3,106.93 149.4,103.83 150.11,103.83 150.52,103.83 151.49,102.85 151.69,102.65 151.69,102.13 152.56,101.26 156.71,101.26 158.78,99.2 158.78,93.63 159.21,93.2 159.21,89.27 158.7,88.76 158.7,76.09 v1(158.65,76.04)
  BOTTOM w0.114: U35.AF9 135.88,110.4 135.79,110.48 135.79,110.81 v2(135.86,110.88) ; v1(79.69,91.89) 80.05,91.53 80.79,91.53 81.5,92.25 88.55,92.25 94.79,86.01 126.74,86.01 137.28,75.47 149.6,75.47 150.2,74.87 151,74.87 151.66,75.53 153.28,75.53 154.01,76.26 156.99,76.26 157.19,76.46 157.78,76.46 158.17,76.07 158.17,75.91 158.21,75.87 158.25,75.83 158.44,75.83 v1(158.65,76.04)
USBP7-: length 232.6
  TOP w0.114: v1(79.66,91.18) 79.44,91.4 79.2,91.4 78.79,91.81 78.79,92.52 79.27,93 79.71,93 82.06,95.35 82.06,106.86 79.32,109.61 73.35,109.61 71.43,111.53 66.99,111.53 63.1,115.41 63.1,116.53 56.08,123.55 36.12,123.55 33.89,125.78 27.03,125.78 23.1,121.84 23.1,121.23 20.79,118.92 20.18,118.92 20.03,118.77 19.7,118.77 R818.1
  IN2 w0.114: v1(158.68,75.38) 159.09,75.79 159.09,76.25 158.91,76.42 158.91,88.67 159.43,89.18 159.43,93.29 159,93.72 159,99.29 156.8,101.48 152.65,101.48 151.91,102.22 151.91,102.74 151.79,102.86 150.61,104.05 150.02,104.05 149.49,104.05 146.39,107.14 145.6,107.14 145.58,107.17 145.47,107.17 145.45,107.14 143.33,107.14 140.79,109.68 138.93,109.68 138.61,110 137.32,110 136.48,110.84 v2(136.48,110.88)
  BOTTOM w0.114: v1(79.66,91.18) 79.79,91.31 80.88,91.31 81.59,92.03 88.46,92.03 94.7,85.8 126.65,85.8 137.19,75.25 149.51,75.25 150.11,74.66 151.09,74.66 151.75,75.32 153.37,75.32 154.1,76.04 157.08,76.04 157.28,76.25 157.69,76.25 157.96,75.98 157.96,75.82 158.16,75.62 158.52,75.62 158.68,75.46 v1(158.68,75.38) ; v2(136.48,110.88) 136.48,110.7 U35.AF8
USBP8+: length 137.6
  IN2 w0.114: v1(118.42,35.45) 118.67,35.2 118.67,34.88 118.98,34.58 140.23,34.58 143.25,37.6 144.37,37.6 146.88,40.11 150.13,40.11 159.29,49.27 159.35,49.33 159.35,58.76 159.82,59.22 159.82,60.49 159.35,60.96 159.35,74.33 159.7,74.68 159.7,88.06 160.33,88.69 160.33,99.06 160.21,99.18 160.19,99.18 159.39,99.98 159.39,101.42 157.83,102.98 157.65,102.98 157.65,102.98 153.08,102.98 150.26,105.8 150.26,106.1 147.63,108.73 147.61,108.73 143.21,108.73 142.8,109.13 v1(142.8,109.75)
  BOTTOM w0.114: R11301.2 115.36,25.87 115.36,27.72 114.85,28.23 114.85,31.76 116.76,33.66 118.41,33.66 118.64,33.9 118.64,35.23 v1(118.42,35.45)
  BOTTOM w0.127: U35.AG2 140.24,109.6 140.47,109.37 140.52,109.37 140.65,109.24 142.3,109.24 v1(142.8,109.75)
USBP8+_PI3: length 1.4
  BOTTOM w0.114: U1006.1 115.27,24.14 R11301.1
USBP8+_R: length 11
  BOTTOM w0.114: CN95.2 111.75,15.45 111.67,15.36 111.54,15.36 111.49,15.31 111.49,15.06 111.69,14.85 112.58,14.85 114.05,16.33 115.02,16.33 115.33,16.64 115.33,17.81 EC54.2 115.07,18.54 115.3,18.54 115.39,18.63 115.39,20.45 115.25,20.59 114.92,20.59 R11303.1
USBP8+_R_COM: length 9.5
  TOP w0.114: v1(114.84,19.07) 115.37,19.6 115.37,26.26 v1(114.84,26.79)
  BOTTOM w0.114: R11302.2 v1(114.84,19.07) ; R11299.1 v1(114.84,26.79)
USBP8+_R_PI3: length 1.4
  BOTTOM w0.114: U1006.7 115.27,21.72 R11303.2
USBP8-: length 137.6
  IN2 w0.114: v1(119.46,35.43) 119.46,35.66 119.34,35.78 119.01,35.78 118.89,35.67 118.89,34.97 119.07,34.79 140.14,34.79 143.16,37.82 144.28,37.82 146.79,40.33 150.04,40.33 159.14,49.42 159.14,58.85 159.6,59.31 159.6,60.4 159.14,60.87 159.14,74.42 159.49,74.77 159.49,88.15 160.11,88.78 160.11,98.95 160.11,98.96 160.1,98.96 159.17,99.89 159.17,101.33 157.74,102.76 152.99,102.76 150.04,105.71 150.04,105.99 147.52,108.52 143.12,108.52 142.58,109.06 142.58,109.34 142.35,109.56 142.35,109.56 v1(142.17,109.75)
  BOTTOM w0.114: R11291.2 115.72,25.35 115.58,25.5 115.58,27.81 115.07,28.32 115.07,31.67 116.85,33.45 118.5,33.45 118.86,33.81 118.86,35.48 119.03,35.66 119.23,35.66 v1(119.46,35.43)
  BOTTOM w0.127: v1(142.17,109.75) 142.17,109.57 142.09,109.49 140.92,109.49 U35.AG1
USBP8-_PI3: length 1.4
  BOTTOM w0.114: R11291.1 115.67,24.14 U1006.2
USBP8-_R: length 11
  BOTTOM w0.114: CN95.3 111.25,14.99 111.6,14.64 112.67,14.64 114.14,16.11 115.11,16.11 115.55,16.56 115.55,17.8 EC53.2 115.6,18.74 115.6,20 R11305.1
USBP8-_R_COM: length 9.5
  TOP w0.114: v1(116.11,26.79) 115.58,26.26 115.58,19.6 v1(116.11,19.07)
  BOTTOM w0.114: R11300.1 v1(116.11,26.79) ; R11304.2 v1(116.11,19.07)
USBP8-_R_PI3: length 1.4
  BOTTOM w0.114: R11305.2 115.67,21.72 U1006.6
USBPWR0: length 0.8
  TOP w0.203: U24.2 16.03,15.24 v1(15.88,15.09)
  vias: v1(20.69,15.63) v1(22,24.94) v3(24.14,25.7) v3(24.92,25.55) v3(24.97,24.73)
