# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LID#15: length 10.1
  TOP w0.508: MR1.2 86.54,3.96 v1(85.48,3.96) 85.11,3.96 R435.1 78.69,9.38 R11129.2
LINE1-L: length 15.1
  TOP w0.381: v1(206.08,19.83) 206.13,19.88 v1(206.13,20.7) 206.13,21.2 206.81,21.89 206.81,26.16 207.49,26.83 207.5,26.83 207.85,27.18 207.85,29.31 v1(208.9,30.35)
  BOTTOM w0.203: U23.22 208.24,31 v1(208.9,30.35)
  BOTTOM w0.381: v1(206.08,19.83) 206.1,19.81 206.25,19.81 207.33,18.73 C552.1
LINE1-R: length 17.1
  TOP w0.381: v1(209.4,30.75) 209.53,30.63 209.53,30.02 208.9,29.38 208.9,22.7 208.3,22.1 208.3,19.97 v1(207.27,18.94) 206.64,18.31 v1(206.41,18.31)
  BOTTOM w0.203: v1(209.4,30.75) 208.75,31.4 U23.21
  BOTTOM w0.381: v1(206.41,18.31) 206.41,18.38 205.88,18.91 C549.1
LINE1-VREFO-L: length 12.9
  IN1 w0.381: v1(204.2,28.09) 204.5,28.09 204.91,27.68 204.91,22.75 206.38,21.28 206.38,20.47 v1(207.14,19.7)
  BOTTOM w0.203: U23.31 v1(204.2,28.09)
  BOTTOM w0.381: R421.2 208.39,19.58 v1(208.26,19.7) v1(207.14,19.7)
LINE1-VREFO-R: length 10.7
  TOP w0.381: v1(203.97,20.01) 203.74,20.24 v1(203.74,21.43) v1(203.74,26.64)
  BOTTOM w0.203: U23.30 204.6,28.33 204.66,28.28 204.66,27.9 204.6,27.84 204.6,27.22
  BOTTOM w0.381: R418.2 204.34,19.61 203.97,19.98 v1(203.97,20.01) ; v1(203.74,26.64) 204.02,26.64 204.6,27.22
LM393_PIN2: length 25.6
  TOP w0.127: PR146.2 48.8,106.8 v1(48.47,106.47) 48.06,106.06 42.83,106.06 39.55,109.34 39.55,113.91 v1(39.86,114.22)
  TOP w0.254: PU4.2 51.42,107.46 PR146.2
  BOTTOM w0.127: v1(39.86,114.22) 39.3,114.78 36.07,114.78 PR262.2
LPC_LAD0: length 303.3
  IN2 w0.14: v1(202.22,177.03) 202.83,177.03 203.53,176.34 203.53,173.62 203.69,173.46 203.69,171.91 203.43,171.65 203.43,169.49 204.25,168.68 204.25,166.04 205.21,165.08 205.21,163.64 205.73,163.12 205.73,162.08 208.3,159.51 214.33,159.51 215.35,158.49 219.72,158.49 222.89,155.32 222.89,110.07 218.49,105.67 216.99,105.67 212.55,101.23 212.55,84.3 213.65,83.2 213.65,66.67 213.64,66.66 213.64,62.79 211.89,61.04 211.89,60.04 211.26,59.42 211.26,54.95 212,54.21 212,48.05 209.19,45.23 207.87,45.23 207.17,45.94 203.45,45.94 202.67,46.72 200.82,46.72 200.01,47.54 197.47,47.54 196.68,48.33 195.74,48.33 190.99,53.08 189.49,53.08 186.82,50.41 186.82,47.57 186.34,47.09 186.34,43.48 185.75,42.89 185.75,41.68 186.14,41.29 186.14,39.47 185.22,38.55 v1(184.44,38.55) 184.22,38.55 183.76,39.01 182.63,39.01 181.82,38.2 179.51,38.2 176.83,40.87 176.83,42.66 177.09,42.92 177.09,45.07 177.77,45.75 177.77,50.87 178.55,51.65 178.55,53.9 179.56,54.91 179.56,55.29 179.39,55.46 179.39,56.88 178,58.27 178,61.71 174.73,64.98 174.73,65.5 170.82,69.41 170.82,74.37 170.44,74.75 170.19,74.75 v1(170.11,74.82) 170.11,74.98 170.05,75.03 170.05,77.1 170.88,77.93 170.88,80.31 170.91,80.34 170.91,81.78 171.61,82.48 171.61,86.56 v1(171.56,86.61)
  BOTTOM w0.127: v1(184.44,38.55) 185.19,37.8 U45.10 ; v1(171.56,86.61) 171.37,86.8 171.14,86.8 170.6,87.35 165.16,87.35 164.01,88.49 160.14,88.49 155.95,84.3 153,84.3 152.32,84.98 149.65,84.98 146.29,88.34 143.9,88.34 140.65,91.59 140.65,94.63 140.52,94.76 R659.1 ; R688.1 v1(202.22,177.03) ; v1(170.11,74.82) 170.11,74.9 169.65,75.36 167.85,75.36 167.62,75.13 U44.24
LPC_LAD0_C: length 2.4
  BOTTOM w0.127: CN10.64 199.48,176.25 200.26,177.03 R688.2
LPC_LAD1: length 303.4
  IN2 w0.14: v1(202.19,176.09) 202.61,175.67 202.61,174.84 202.98,174.47 202.98,173.04 203.08,172.94 203.08,172.18 202.9,172 202.9,168.93 203.48,168.36 203.48,164.55 205.19,162.83 205.19,161.85 209.24,157.8 219.51,157.8 222.36,154.96 222.36,110.29 218.27,106.2 216.77,106.2 211.99,101.43 211.99,83.99 213.09,82.9 213.09,66.9 212.36,66.17 212.36,64.14 212.93,63.58 212.93,62.83 210.51,60.42 210.51,58.77 210.73,58.56 210.73,55.5 210.43,55.2 210.43,49.13 207.77,46.47 203.67,46.47 201.86,48.28 199.35,48.28 198.74,48.89 196.02,48.89 191.27,53.64 189.29,53.64 186.26,50.61 186.26,47.77 185.81,47.31 185.81,43.74 185.22,43.15 185.22,41.45 185.6,41.07 185.6,40.08 185.15,39.62 184.59,39.62 v1(184.51,39.54) 182.41,39.54 181.6,38.73 179.73,38.73 178.08,40.38 178.08,42.52 177.65,42.95 177.65,44.87 178.3,45.53 178.3,45.97 178.3,49.5 180.03,51.23 180.03,52.92 180.82,53.7 180.82,56.33 180.81,56.33 180.81,56.94 180.82,56.95 180.82,58.3 178.62,60.5 178.62,61.85 175.29,65.18 175.29,65.7 171.35,69.64 171.35,75.09 170.77,75.68 v1(170.77,76.04) 170.77,76.49 171.01,76.73 171.01,76.88 171.13,77.01 171.13,77.33 171.42,77.61 171.42,80.09 171.44,80.12 171.44,81.56 172.34,82.46 172.34,87.2 v1(171.84,87.7)
  BOTTOM w0.127: R690.1 v1(202.19,176.09) ; v1(170.77,76.04) 170.72,76.04 170.66,75.98 166.69,75.98 166.12,75.4 U44.21 ; v1(171.84,87.7) 171.13,87.7 170.97,87.85 165.37,87.85 164.22,89 159.93,89 155.74,84.81 153.21,84.81 152.53,85.49 149.86,85.49 146.5,88.84 144.28,88.84 141.59,91.54 141.59,94.08 141.23,94.43 141.23,96.28 140.34,97.17 R640.1 ; v1(184.51,39.54) 184.51,39.11 185.42,38.2 U45.9
LPC_LAD1_C: length 2.2
  BOTTOM w0.127: R690.2 200.23,176.09 199.89,175.75 CN10.66
LPC_LAD2: length 303.1
  IN2 w0.14: v1(203,176.04) 203,174.86 203.25,174.61 203.25,173.33 203.41,173.17 203.41,172.08 203.17,171.84 203.17,169.21 203.82,168.56 203.82,164.6 205.46,162.96 205.46,161.96 208.19,159.23 214.23,159.23 215.25,158.21 219.54,158.21 222.62,155.12 222.62,110.18 218.38,105.94 216.88,105.94 212.27,101.33 212.27,84.14 213.37,83.05 213.37,66.8 213.37,66.8 213.37,62.9 211.62,61.15 211.62,60.15 211,59.53 211,54.83 211.73,54.1 211.73,48.15 209.08,45.5 207.98,45.5 207.28,46.2 203.56,46.2 201.94,47.82 197.62,47.82 196.83,48.61 195.92,48.61 191.17,53.36 189.39,53.36 186.54,50.51 186.54,47.67 186.07,47.2 186.07,43.63 185.48,43.04 185.48,41.57 185.87,41.18 185.87,39.89 v1(185.12,39.14) 185.02,39.03 184.23,39.03 183.99,39.28 182.52,39.28 181.71,38.46 179.62,38.46 177.76,40.32 177.76,42.46 177.37,42.85 177.37,44.98 178.03,45.64 178.03,49.68 179.76,51.4 179.76,53.03 180.36,53.63 180.36,54.92 179.65,55.63 179.65,56.99 178.35,58.3 178.35,61.74 175.02,65.07 175.02,65.59 171.09,69.52 171.09,74.98 170.33,75.74 170.33,76.71 v1(170.54,76.92) 170.87,77.24 170.87,77.44 171.15,77.72 171.15,80.2 171.18,80.23 171.18,81.67 172.07,82.57 172.07,87.03 171.87,87.24 171.64,87.24 171.64,87.24 v1(171.33,87.24)
  BOTTOM w0.127: R693.1 202.11,175.15 v1(203,176.04) ; R653.1 141.15,91.54 144.11,88.59 146.4,88.59 149.75,85.24 152.42,85.24 153.1,84.55 155.84,84.55 160.03,88.74 164.12,88.74 165.26,87.6 170.87,87.6 171.22,87.24 v1(171.33,87.24) ; U45.8 185.63,38.6 185.12,39.11 v1(185.12,39.14) ; U44.18 164.62,76.04 v1(164.91,76.33) 165.02,76.44 169.89,76.44 170.38,76.92 v1(170.54,76.92)
LPC_LAD2_C: length 2.1
  BOTTOM w0.127: CN10.68 200.01,175.25 200.11,175.15 R693.2
LPC_LAD3: length 305.4
  IN2 w0.14: v1(202.51,174.23) 202.63,174.1 202.63,168.68 203.05,168.26 203.05,163.62 209.14,157.53 219.28,157.53 221.95,154.86 221.98,154.86 221.98,154.83 222.08,154.73 222.08,110.39 218.16,106.47 216.29,106.47 215.7,105.89 214.95,105.89 213.49,104.43 213.49,103.47 211.72,101.7 211.72,83.74 212.81,82.65 212.81,67 212.1,66.29 212.1,63.62 211.78,63.31 211.78,62.29 210.25,60.75 210.25,59.17 209.64,58.55 209.64,48.72 207.67,46.75 205.55,46.75 204.68,47.62 202.9,47.62 201.86,48.66 199.4,48.66 198.9,49.16 196.31,49.16 191.55,53.92 189.2,53.92 185.98,50.71 185.98,47.87 185.54,47.42 185.54,43.85 184.95,43.26 184.95,41.34 185.12,41.17 v1(185.12,40.38) 184.77,40.02 182.47,40.02 181.44,39 179.84,39 178.72,40.11 178.72,40.29 178.35,40.67 178.35,42.63 177.92,43.06 177.92,44.76 178.57,45.41 178.57,46.08 178.57,49.32 180.3,51.05 180.3,51.63 181.9,53.24 181.9,54.57 181.08,55.39 181.08,56.44 181.08,56.44 181.08,56.83 181.08,56.84 181.08,58.41 178.89,60.61 178.89,61.96 175.56,65.29 175.56,65.81 171.64,69.72 171.64,75.18 171.27,75.55 171.27,76.77 171.6,77.1 v1(171.6,77.13) 171.68,77.22 171.68,81.43 172.61,82.35 172.61,87.64 172.07,88.18 v1(171.38,88.18)
  BOTTOM w0.127: R668.1 141.66,94.51 141.87,94.3 141.87,91.76 144.43,89.2 146.65,89.2 150.11,85.74 152.63,85.74 153.32,85.06 155.63,85.06 159.82,89.25 164.39,89.25 165.53,88.11 170.9,88.11 170.97,88.18 v1(171.38,88.18) ; R696.1 202.01,174.19 202.05,174.23 v1(202.51,174.23) ; v1(171.6,77.13) 171.34,77.39 169.84,77.39 v1(169.73,77.27) 169.69,77.27 169.12,77.85 164.12,77.85 163.58,77.31 163.58,75.31 162.58,74.31 162.58,73.66 162.79,73.46 U44.15 ; U45.7 186.15,39 185.12,40.02 v1(185.12,40.38)
LPC_LAD3_C: length 2.3
  BOTTOM w0.127: R696.2 200.12,174.75 CN10.70
LPC_LFRAME#: length 308.9
  IN2 w0.14: v1(202.09,171.8) 202.09,168.66 202.66,168.1 202.66,163.45 208.99,157.12 219.13,157.12 221.56,154.69 221.56,110.51 218.03,106.99 214.34,106.99 213.8,106.45 213.8,105.47 212.97,104.65 212.97,103.51 211.31,101.85 211.31,83.56 212.4,82.47 212.4,67.2 211.58,66.38 211.58,63.84 211.39,63.65 211.39,62.45 209.85,60.92 209.85,59.33 209.24,58.72 209.24,49.06 208.21,48.03 205.01,48.03 204.9,48.14 203.12,48.14 202.11,49.14 199.65,49.14 199.12,49.68 196.53,49.68 191.88,54.33 189.05,54.33 185.02,50.3 185.02,43.89 184.43,43.3 184.43,41.13 184.49,41.07 v1(184.49,40.57) 182.28,40.57 181.22,39.52 180.06,39.52 178.74,40.83 178.74,41.93 178.74,43.24 179.51,44.01 179.51,45.94 179.71,46.15 180.5,46.15 180.75,46.4 180.75,46.78 181.11,47.14 181.11,48.05 181.72,48.66 181.72,50.06 182.28,50.62 182.28,52.2 182.45,52.38 182.45,55.77 182.73,56.05 182.73,57.32 179.28,60.77 179.28,62.13 176.63,64.78 175.95,65.45 175.95,65.97 172.16,69.76 172.16,76.12 v1(171.79,76.5) 172.29,77 172.29,79.96 171.96,80.28 171.96,81.33 173.18,82.54 173.18,87.81 172.29,88.69 v1(172.22,88.69)
  BOTTOM w0.079: U35.BA12 134.11,102.02 134.11,100.38 134.44,100.04
  BOTTOM w0.127: v1(202.09,171.8) 202.06,171.83 R699.2 ; v1(171.79,76.5) 171.77,76.49 170.48,76.49 170.2,76.21 166.39,76.21 165.62,75.44 U44.20 ; v1(172.22,88.69) 170.94,88.69 170.74,88.49 165.87,88.49 164.6,89.76 159.61,89.76 155.42,85.57 154.87,85.57 154.86,85.58 153.52,85.58 152.84,86.25 150.35,86.25 146.89,89.71 144.64,89.71 v1(142.3,92.05) 142.3,96.31 140.67,97.94 139.12,97.94 138.61,98.44 136.04,98.44 134.44,100.04 ; v1(184.49,40.57) 184.78,40.86 185.38,40.86 185.64,40.6 185.64,39.96 186.2,39.4 U45.6
LPC_LFRAME#_C: length 12.2
  BOTTOM w0.127: CN10.73 191.89,174 192.56,173.32 193.3,173.32 193.55,173.07 193.55,171.88 194.82,170.61 197.47,170.61 v1(197.62,170.76) 198.68,171.83 R699.1
LPCPD: length 2.2
  BOTTOM w0.127: v1(169.63,73.2) 169.82,73 R744.2 169.82,72.46 U44.28
LPM_ZVM_N: length 47.4
  TOP w0.127: PR280.1 47.93,85.16 v1(48.05,85.29) 48.05,86.24 49.97,88.16 v1(49.97,88.89)
  IN2 w0.14: v1(74.96,102.48) 74.91,102.53 72.4,102.53 71.25,103.68 66.4,103.68 66.38,103.65 55.02,103.65 48.77,97.4 48.77,90.09 v1(49.97,88.89)
  BOTTOM w0.127: R762.2 78.03,103.29 77.27,102.53 75.01,102.53 v1(74.96,102.48)
M_A_A0: length 65.9
  IN1 w0.079: 112.46,87.32 112.25,87.53 112.25,97.61 111.19,98.67 110.9,98.67 110.63,98.4 v1(110.63,97.68)
  IN1 w0.216: 112.46,87.32 113.5,86.28 113.5,78.56 115.97,76.1 115.97,63.6 116.53,63.04 116.53,52.03 116.95,51.62 v1(116.95,46.84)
  BOTTOM w0.079: U35.AY50 112.58,102.23 112.38,102.03 112.38,102.02 112.3,101.81 112.3,101.66 112.37,101.43 112.37,101.32 112.36,101.28 112.35,101.28 112.3,101.16 112.3,100.87 112.49,100.68 112.49,99.56 111.51,98.58 111.51,97.99 111.2,97.68 v1(110.63,97.68)
  BOTTOM w0.191: JDIM1.144 118.47,45.38 117.02,46.84 v1(116.95,46.84)
M_A_A1: length 64.4
  IN1 w0.079: v1(110.63,97.03) 110.63,97.16 110.75,97.29 110.99,97.29 111.11,97.16 111.11,96.49 111.19,96.42 111.3,96.42 111.38,96.49 111.38,97.28 111.46,97.36 111.57,97.36 111.65,97.28 111.65,96.01 111.75,95.91 111.75,86.77 111.9,86.62
  IN1 w0.216: 111.9,86.62 112.51,86.01 112.51,78.05 114.72,75.85 114.72,70.1 114.14,69.53 114.14,66.4 114.02,66.28 113.6,66.28 113.47,66.15 113.47,64.68 114.94,63.21 114.94,62.81 114.76,62.63 114.76,60.05 114.88,59.92 115.18,59.92 115.31,59.79 115.31,59.53 115.18,59.41 114.88,59.41 114.76,59.28 114.76,59.13 114.88,59 114.88,56.49 115.01,56.36 115.48,56.36 115.61,56.24 115.61,55.9 115.48,55.78 114.47,55.78 114.32,55.62 114.32,55.38 114.45,55.26 115.29,55.26 115.41,55.13 115.41,54.86 114.88,54.33 114.88,53.44 114.73,53.29 114.39,53.29 114.24,53.14 114.24,52.92 114.39,52.77 114.73,52.77 114.88,52.62 114.88,52 116.01,50.88 v1(116.01,50.06)
  BOTTOM w0.079: v1(110.63,97.03) 110.79,97.03 111.69,97.93 111.69,98.52 112.65,99.48 112.65,100.89 112.58,100.96 U35.BB50
  BOTTOM w0.191: v1(116.01,50.06) 115.72,50.34 JDIM1.133
M_A_A2: length 66.1
  IN1 w0.079: 112.18,86.97 111.97,87.18 111.97,97.29 v1(111.11,98.16)
  IN1 w0.216: 112.18,86.97 113.01,86.15 113.01,78.35 115.47,75.88 115.47,69.91 114.72,69.15 114.72,64.1 116.15,62.67 116.15,55.02 115.39,54.27 115.39,52.63 116.54,51.48 116.54,47.07 115.95,46.48 115.56,46.48 115.44,46.35 115.44,45.96 115.56,45.83 115.91,45.83 116.04,45.71 116.04,44.4 115.91,44.28 115.49,44.28 115.37,44.4 v1(115.37,44.59)
  BOTTOM w0.079: U35.AY51 112.18,102.48 112.18,101.97 112.13,101.81 112.13,101.69 112.19,101.46 112.19,101.34 112.16,101.26 112.14,101.2 112.14,100.8 112.32,100.62 112.32,99.63 111.11,98.42 v1(111.11,98.16)
  BOTTOM w0.191: v1(115.37,44.59) 115.47,44.48 JDIM1.132
M_A_A3: length 64.7
  IN1 w0.079: v1(110.63,96.39) 111.51,95.5 111.51,86.32 111.6,86.23
  IN1 w0.216: v1(116.01,48.74) 116.01,47.11 115.88,46.98 115.51,46.98 115.39,47.11 115.39,50.88 113.78,52.48 113.78,54.28 113.92,54.42 113.92,55.98 114.45,56.51 114.45,58.73 114.26,58.92 114.26,63.25 112.99,64.52 112.99,66.92 113.61,67.55 113.61,69.7 114.22,70.31 114.22,75.64 112.02,77.85 112.02,85.81 111.6,86.23
  BOTTOM w0.079: v1(110.63,96.39) 111.44,97.2 111.44,97.39 111.86,97.82 111.86,98.46 112.82,99.41 112.82,100.53 112.92,100.63 112.92,101.24 112.58,101.59 U35.BA50
  BOTTOM w0.191: v1(116.01,48.74) 115.93,48.74 115.22,49.44 JDIM1.131
M_A_A4: length 65.2
  IN1 w0.079: 109.08,90.81 109.08,91.11 110,92.03 110,95.78 v1(109.41,96.38)
  IN1 w0.216: v1(113.97,44.8) 113.87,44.7 113.06,44.7 112.93,44.83 112.93,45.11 113.06,45.23 113.32,45.23 113.45,45.36 113.45,45.77 113.26,45.96 113.26,47.33 112.77,47.83 112.77,50.1 110.39,52.47 110.39,55.21 110.55,55.36 110.98,55.36 111.1,55.49 111.1,55.75 110.98,55.88 110.55,55.88 110.39,56.03 110.39,58.24 110.55,58.4 110.99,58.4 111.12,58.52 111.12,58.79 110.99,58.92 110.55,58.92 110.39,59.07 110.39,61.71 110.24,61.86 110.24,67.48 110.53,67.76 110.53,72.99 110.02,73.5 110.02,75.66 109.08,76.6 109.08,90.81
  BOTTOM w0.079: v1(109.41,96.38) 109.89,96.86 109.89,98.03 111.15,99.3 111.15,100.78 111.25,100.88 U35.BB52
  BOTTOM w0.191: v1(113.97,44.8) 113.97,44.73 114.47,44.23 JDIM1.128
M_A_A5: length 66.2
  IN1 w0.079: 110.57,91.18 110.57,91.39 111.05,91.88 111.05,94.29 110.92,94.43 v1(110.63,94.43)
  IN1 w0.216: v1(113.97,46.12) 113.87,46.12 113.74,46.25 113.74,46.71 113.87,46.84 114.28,46.84 114.41,46.96 114.41,50.45 112.57,52.28 112.57,54.23 112.98,54.63 112.98,58.42 112.81,58.59 112.81,59.16 112.93,59.29 112.94,59.29 113.24,59.58 113.24,60.32 112.81,60.75 112.81,63.4 112.02,64.19 112.02,70.16 112.77,70.91 112.77,74.75 112.39,75.14 111.64,75.14 111.51,75.26 111.51,76.27 110.57,77.21 110.57,91.18
  BOTTOM w0.079: U35.BA51 111.69,101.84 111.69,101.62 111.69,101.61 111.68,101.6 111.68,101.6 111.64,101.5 111.64,101.32 111.68,101.22 111.68,100.79 111.48,100.59 111.48,99.16 110.22,97.9 110.22,94.83 v1(110.63,94.43)
  BOTTOM w0.191: v1(113.97,46.12) 113.95,46.12 113.82,46.25 113.82,46.6 113.7,46.73 113.47,46.73 113.34,46.6 113.34,44.75 113.97,44.11 JDIM1.126
M_A_A6: length 65
  IN1 w0.079: 109.58,90.93 109.58,91.24 110.22,91.88 110.22,96.71 109.9,97.03 v1(109.41,97.03)
  IN1 w0.216: v1(113.72,48.79) 113.46,48.79 113.19,49.07 113.19,50.25 110.86,52.58 110.86,54.72 110.99,54.85 111.44,54.85 111.57,54.98 111.57,61.07 111.2,61.44 111.2,61.58 111.33,61.71 111.79,61.71 111.92,61.84 111.92,62.09 111.79,62.21 110.8,62.21 110.68,62.34 110.68,62.59 110.8,62.72 111.77,62.72 111.9,62.85 111.9,63.11 111.77,63.24 110.76,63.24 110.61,63.39 110.61,63.61 110.76,63.76 111.06,63.76 111.21,63.91 111.21,64.13 111.06,64.28 110.76,64.28 110.61,64.43 110.61,67.3 111.02,67.71 111.02,73.2 110.51,73.71 110.51,75.86 109.58,76.8 109.58,90.93
  BOTTOM w0.079: v1(109.41,97.03) 109.72,97.34 109.72,98.1 110.98,99.36 110.98,101.47 U35.BA52
  BOTTOM w0.191: JDIM1.127 114.22,49.1 113.92,48.79 v1(113.72,48.79)
M_A_A7: length 66.9
  IN1 w0.079: 108.58,90.73 108.58,90.97 109.81,92.19 109.81,95.32 v1(109.41,95.73)
  IN1 w0.216: v1(112.45,46.76) 112.61,46.76 112.76,46.9 112.76,47.22 112.35,47.63 112.35,49.86 111.65,50.56 111.48,50.56 111.32,50.4 111.14,50.4 110.92,50.62 110.92,50.8 111.05,50.93 111.05,51.14 110.89,51.29 110.68,51.29 110.53,51.15 110.35,51.15 110.16,51.33 110.16,51.51 110.31,51.66 110.31,51.88 110.16,52.03 109.94,52.03 109.85,51.95 109.64,51.95 109.34,52.25 109.34,54.48 109.86,55 109.86,67.55 110.03,67.72 110.03,71.73 109.88,71.88 109.68,71.88 109.52,72.04 109.52,72.25 109.68,72.41 109.88,72.41 110.03,72.56 110.03,72.77 109.88,72.93 109.68,72.93 109.52,73.08 109.52,75.45 108.58,76.39 108.58,90.73
  BOTTOM w0.079: v1(109.41,95.73) 108.98,96.15 108.98,97.6 110.82,99.44 110.82,101.78 111.04,101.99 111.04,102.53 111.35,102.85 U35.AW52
  BOTTOM w0.191: v1(112.45,46.76) 112.97,46.23 JDIM1.122
M_A_A8: length 65.6
  IN1 w0.079: 110.07,91.06 110.07,91.42 110.63,91.97 v1(110.63,93.78)
  IN1 w0.216: 110.07,91.06 110.07,77.01 111.01,76.07 111.01,74.8 111.18,74.63 112.13,74.63 112.26,74.5 112.26,74.24 112.13,74.11 111.36,74.11 111.21,73.96 111.21,73.74 111.36,73.59 112.14,73.59 112.27,73.46 112.27,73.2 112.14,73.07 111.69,73.07 111.54,72.92 111.54,72.7 111.69,72.55 112.14,72.55 112.26,72.42 112.26,72.16 112.14,72.03 111.72,72.03 111.52,71.83 111.52,71.66 111.67,71.51 112.15,71.51 112.28,71.38 112.28,71.11 112.15,70.99 111.67,70.99 111.52,70.83 111.52,68.23 111.61,68.13 111.61,64.03 112.39,63.25 112.39,61.06 112.24,60.91 112.09,60.91 111.96,60.78 111.96,60.51 112.09,60.39 112.6,60.39 112.73,60.26 112.73,59.99 112.6,59.87 112.14,59.87 112.01,59.74 112.01,59.47 112.14,59.35 112.24,59.35 112.39,59.19 112.39,58.88 111.94,58.42 111.94,56.32 112.09,56.17 112.45,56.17 112.6,56.02 112.6,55.8 112.45,55.65 112.09,55.65 111.94,55.5 111.94,55.28 112.09,55.13 112.38,55.13 112.53,54.98 112.53,54.76 112.38,54.61 112.09,54.61 111.94,54.46 111.94,52.22 113.72,50.43 v1(113.72,50.11)
  BOTTOM w0.079: v1(110.63,93.78) 110.05,94.35 110.05,97.96 111.32,99.23 111.32,100.66 111.52,100.87 111.52,101.18 111.48,101.28 111.48,101.29 111.48,101.54 111.53,101.65 111.53,101.81 111.49,101.92 111.49,101.92 111.45,102.02 111.45,102.28 U35.AY52
  BOTTOM w0.191: JDIM1.125 v1(113.72,50.11)
M_A_A9: length 64.5
  IN1 w0.216: v1(109.41,92.47) 109.41,92.34 108.09,91.03 108.09,76.19 109.01,75.27 109.01,71.46 109.14,71.34 109.37,71.34 109.52,71.18 109.52,70.97 109.37,70.82 109.15,70.82 109,70.66 109,70.45 109.15,70.3 109.37,70.3 109.52,70.14 109.52,69.93 109.37,69.77 109.15,69.77 109,69.62 109,69.41 109.15,69.25 109.37,69.25 109.52,69.1 109.52,68.89 109.37,68.73 109.15,68.73 108.77,68.35 108.77,67.81 108.59,67.63 108.59,67.45 108.69,67.35 109.06,67.35 109.18,67.23 109.18,66.91 109.06,66.78 108.77,66.78 108.64,66.65 108.64,64.33 108.77,64.2 109.2,64.2 109.36,64.05 109.36,63.83 109.2,63.68 108.99,63.68 108.84,63.53 108.84,63.31 108.99,63.16 109.2,63.16 109.36,63 109.36,62.79 109.2,62.64 108.99,62.64 108.84,62.48 108.84,62.27 108.99,62.12 109.2,62.12 109.36,61.96 109.36,61.75 109.2,61.6 108.99,61.6 108.84,61.44 108.84,59.1 108.99,58.95 109.29,58.95 109.44,58.8 109.44,58.58 109.29,58.43 108.99,58.43 108.84,58.28 108.84,56.3 108.99,56.14 109.26,56.14 109.41,55.99 109.41,55.77 109.26,55.62 108.99,55.62 108.84,55.47 108.84,52.11 111.25,49.69 v1(111.86,49.69)
  BOTTOM w0.079: 109.28,92.6 108.39,93.49 108.39,97.71 110.32,99.64 110.32,100.83 110.22,100.93 U35.BB54
  BOTTOM w0.191: v1(109.41,92.47) 109.28,92.6
  BOTTOM w0.203: JDIM1.121 112.72,50.13 112.29,49.69 v1(111.86,49.69)
M_A_A10: length 67.5
  IN1 w0.079: v2(112.06,104.53) 112.06,102.99 113.79,101.26 113.79,100.13 115.1,98.82 115.1,93.83 115.25,93.68 115.25,93.29
  IN1 w0.216: v1(121.41,44.62) 121.5,44.62 121.96,45.08 121.96,46.89 120.34,48.51 120.34,49.75 120,50.09 120,58.55 120.32,58.86 120.32,63.36 121.24,64.29 121.24,65.76 120.67,66.33 120.67,77.32 117.76,80.24 117.76,86.02 115.25,88.53 115.25,93.29
  BOTTOM w0.191: JDIM1.146 120.97,44.18 v1(121.41,44.62)
  BOTTOM w0.203: U35.AT50 v2(112.06,104.53)
M_A_A11: length 65.5
  IN1 w0.079: 107.1,90.65 107.1,90.94 108.7,92.54 108.7,93.34 v1(109.41,94.04)
  IN1 w0.216: v1(112.47,45.31) 112.43,45.31 111.59,46.14 111.59,46.36 111.84,46.61 111.84,46.79 111.63,46.99 111.45,46.99 111.24,46.78 111.06,46.78 110.87,46.97 110.87,47.15 111.09,47.37 111.09,47.58 110.94,47.74 110.72,47.74 110.53,47.54 110.35,47.54 110.16,47.73 110.16,47.91 110.35,48.11 110.35,48.32 110.1,48.57 110.1,49.6 108.14,51.56 108.14,62.59 107.1,63.64 107.1,68.13 107.29,68.32 107.29,70.18 107.87,70.76 107.87,72.09 108.02,72.24 108.02,74.86 107.1,75.78 107.1,90.65
  BOTTOM w0.079: v1(109.41,94.04) 108.59,94.86 108.59,97.68 110.49,99.57 110.49,101.47 U35.BA54
  BOTTOM w0.191: JDIM1.120 v1(112.47,45.31)
M_A_A12: length 66.5
  IN1 w0.079: 107.59,90.71 107.59,91.04 108.96,92.41 108.96,92.95 v1(109.41,93.39)
  IN1 w0.216: 107.59,90.71 107.59,75.98 108.51,75.06 108.51,72.04 108.36,71.88 108.36,70.55 107.79,69.98 107.79,69.48 107.94,69.33 108.36,69.33 108.49,69.2 108.49,68.94 108.36,68.81 107.94,68.81 107.79,68.66 107.79,68.44 107.94,68.29 108.13,68.29 108.29,68.14 108.29,67.92 108.13,67.77 107.94,67.77 107.79,67.62 107.79,66.97 108.15,66.61 108.15,64.51 108,64.36 107.76,64.36 107.61,64.21 107.61,63.99 107.76,63.84 108,63.84 108.15,63.69 108.15,63.29 108.5,62.94 108.5,51.85 110.64,49.71 110.64,48.6 110.88,48.37 v1(111.86,48.37)
  BOTTOM w0.079: U35.AW54 110.12,102.82 110.43,102.51 110.43,101.96 110.66,101.74 110.66,99.5 108.8,97.65 108.8,95.11 109.4,94.51 109.56,94.51 109.91,94.15 109.91,93.9 v1(109.41,93.39)
  BOTTOM w0.191: v1(111.86,48.37) 111.73,48.37 111.25,48.85 111.25,49.74 111.69,50.18 111.97,50.18 112.22,50.44 JDIM1.119
M_A_A13: length 69.4
  IN1 w0.079: 117.32,93.44 117.32,93.66 117.81,94.15 117.81,99.04 117.38,99.47 117.38,100.95 114.85,103.48 v2(114.85,103.88)
  IN1 w0.216: v1(123.68,46.21) 123.68,47.6 123.25,48.03 123.25,51.07 124.63,52.46 124.63,52.77 124.48,52.93 124.28,52.93 124.13,53.08 124.13,53.29 124.28,53.45 124.48,53.45 124.63,53.6 124.63,61.37 124.21,61.79 124.21,62.63 124.46,62.87 124.68,62.87 124.96,62.59 125.18,62.59 125.33,62.74 125.33,62.95 125.04,63.24 125.04,63.46 125.14,63.56 125.14,68.59 124.87,68.86 124.87,71.71 124.2,72.37 124.2,78.23 120.87,81.57 120.87,85.86 117.32,89.42 117.32,93.44
  BOTTOM w0.191: v1(123.68,46.21) 123.93,46.21 124.16,45.99 124.16,44.57 123.97,44.39 JDIM1.158
  BOTTOM w0.203: v2(114.85,103.88) U35.AU46
M_A_ACT#: length 65.4
  IN1 w0.14: 106.99,96.7 v1(107.57,97.28)
  IN1 w0.216: v1(110.22,45.97) 109.67,46.53 107.96,46.53 106.64,47.85 106.64,50.27 104.87,52.03 104.87,66.42 103.73,67.56 103.73,87.52 104.69,88.48 104.69,92.26 106.99,94.56 106.99,96.7
  BOTTOM w0.079: v1(107.57,97.28) 107.75,97.46 107.75,97.76 109.19,99.21 109.19,100.67 109.35,100.83 109.35,101.16 109.28,101.36 109.28,101.78 U35.BA55
  BOTTOM w0.191: JDIM1.114 110.97,44.45 110.8,44.62 110.8,45.52 110.35,45.97 v1(110.22,45.97)
M_A_ALERT#: length 73.7
  TOP w0.191: R11043.1 110.72,98.7 109.99,97.96 109.99,96.21 110.47,95.73 v1(110.63,95.73)
  IN1 w0.079: 110.94,88.99 110.94,91.38 111.25,91.69 111.25,95.11 v1(110.63,95.73)
  IN1 w0.216: v1(111.51,44.6) 111.8,44.31 114.2,44.31 114.59,44.69 114.59,45.69 114.85,45.96 114.85,50.69 113.09,52.45 113.09,54.14 113.45,54.5 113.45,58.23 113.8,58.57 113.8,63.08 112.54,64.34 112.54,67.6 112.79,67.86 112.79,69.91 113.5,70.61 113.5,75.31 111.29,77.51 111.29,85.62 110.94,85.97 110.94,88.99
  BOTTOM w0.079: 113.09,99.8 113.09,101.52 112.85,101.75 112.85,102.7 U35.AW50
  BOTTOM w0.191: JDIM1.116 111.47,44.56 v1(111.51,44.6)
  BOTTOM w0.203: 113.09,99.8 113.09,99.28 112.11,98.3 112.11,97.21 v1(110.63,95.73)
M_A_BA#0: length 66.1
  IN1 w0.079: 114.77,98.37 114.77,98.88 113.5,100.15 113.5,101.12 111.38,103.24 111.38,103.62 v2(111.12,103.88)
  IN1 w0.216: 114.77,98.37 114.77,88.33 116.97,86.12 116.97,79.87 119.92,76.92 119.92,59.1 119.57,58.74 119.57,49.93 119.9,49.6 119.9,48.2 120,48.1 120,47.36 v1(121.41,45.94)
  BOTTOM w0.191: v1(121.41,45.94) 121.52,45.94 121.97,45.49 JDIM1.150
  BOTTOM w0.203: U35.AU52 v2(111.12,103.88)
M_A_BA#1: length 67.7
  IN1 w0.14: 116.2,98.76 115.79,99.17 115.79,101.1 113.45,103.44 113.45,104.06 v2(113.92,104.53)
  IN1 w0.216: v1(121.52,49.55) 121.52,55.23 122.2,55.91 122.2,61.35 122,61.55 122,62.54 122.97,63.5 122.97,68.12 123.13,68.28 123.13,71.01 122.95,71.19 122.69,71.19 122.51,71.01 122.51,69.14 122.33,68.96 122.07,68.96 121.89,69.14 121.89,77.84 121.46,78.26 119.08,80.64 119.08,85.99 116.2,88.87 116.2,98.76
  BOTTOM w0.203: JDIM1.145 120.72,49.97 121.15,49.55 v1(121.52,49.55) ; v2(113.92,104.53) U35.AT48
M_A_BG#0: length 65.7
  IN1 w0.14: 106.37,90.72 108.4,92.74 108.4,95.8 v1(107.57,96.63)
  IN1 w0.216: 106.37,90.72 106.37,75.48 107.3,74.56 107.3,72.54 107.14,72.39 107.14,71.06 106.57,70.48 106.57,70.46 106.56,70.45 106.56,63.21 107.17,62.59 107.17,55.89 107.29,55.77 107.41,55.77 107.54,55.64 107.54,55.46 107.41,55.33 107.29,55.33 107.16,55.19 107.16,55.01 107.29,54.88 107.39,54.88 107.52,54.75 107.52,54.56 107.39,54.44 107.29,54.44 107.16,54.31 107.16,54.12 107.29,53.99 107.37,53.99 107.5,53.86 107.5,53.68 107.37,53.55 107.29,53.55 107.16,53.42 107.16,52.01 109.71,49.46 109.71,48.29 v1(109.22,47.8)
  BOTTOM w0.079: v1(107.57,96.63) 107.83,96.63 107.98,96.78 107.98,97.76 110,99.78 110,100.61 109.78,100.83 109.78,101.2 109.8,101.25 109.85,101.36 109.85,101.43 109.77,101.69 109.77,101.81 109.85,102.03 109.85,102.22 109.46,102.61 U35.AY55
  BOTTOM w0.191: v1(109.22,47.8) 109.25,47.83 109.61,47.83 110.47,48.69 110.47,49.6 111.25,50.38 111.25,51.37 JDIM1.115
M_A_BG#1: length 65.8
  IN1 w0.14: v1(107.57,95.98) 108.1,95.45 108.1,92.95 105.89,90.74
  IN1 w0.216: v1(109.22,49.12) 109.22,49.44 106.84,51.83 106.84,54.59 106.71,54.72 106.37,54.72 106.24,54.85 106.24,55.04 106.37,55.17 106.71,55.17 106.84,55.3 106.84,55.48 106.71,55.61 106.37,55.61 106.24,55.74 106.24,55.92 106.37,56.06 106.71,56.06 106.84,56.19 106.84,58.44 106.2,59.08 106.2,59.56 106.33,59.69 106.59,59.69 106.72,59.82 106.72,60 106.59,60.13 106.33,60.13 106.2,60.26 106.2,68.29 106.06,68.43 106.06,70.65 106.07,70.66 106.07,70.69 106.65,71.26 106.65,72.59 106.74,72.68 106.74,74.18 106.55,74.37 106.28,74.37 106.09,74.18 106.09,73.57 105.87,73.35 105.66,73.35 105.44,73.57 105.44,87.29 105.89,87.74 105.89,90.74
  BOTTOM w0.079: v1(107.57,95.98) 108.17,96.59 108.17,97.72 110.17,99.72 110.17,100.68 109.95,100.9 109.95,101.17 110.02,101.32 110.02,101.43 109.95,101.67 109.95,101.81 110.02,102.03 110.02,102.28 U35.AY54
  BOTTOM w0.191: v1(109.22,49.12) 109.49,49.12 110.72,50.36 JDIM1.113
M_A_CAS#: length 67.8
  IN1 w0.079: v2(113.92,103.88) 113.92,103.69 116.21,101.4 116.21,100.02 117.35,98.88 117.35,94.16 117.11,93.92 116.88,93.92 116.62,93.65 116.62,93.42
  IN1 w0.216: 116.62,93.42 116.62,89 119.88,85.74 119.88,81.14 122.95,78.06 122.95,72.22 123.88,71.29 123.88,68.49 124.12,68.24 124.12,63.9 123.37,63.15 123.37,61.36 122.7,60.69 122.7,52.07 122.23,51.6 122.23,48.18 123.12,47.29 123.12,45.32 123.53,44.9 v1(123.68,44.9)
  BOTTOM w0.191: v1(123.68,44.9) 123.47,44.7 JDIM1.156
  BOTTOM w0.203: v2(113.92,103.88) U35.AU48
M_A_CB0: length 3.2
  TOP w0.127: R10896.2 104.84,45.28 v1(104.97,45.15)
  BOTTOM w0.127: JDIM1.92 105.47,44.65 v1(104.97,45.15)
M_A_CB1: length 6.6
  TOP w0.127: v1(104.32,48.8) 103.66,49.46 103.66,50.08 103.31,50.44 102.79,50.44 R10871.2
  BOTTOM w0.127: JDIM1.91 105.22,50.43 104.99,50.2 104.99,49.47 v1(104.32,48.8)
M_A_CB2: length 7.6
  TOP w0.127: v1(108.11,48.36) 106.89,47.14 v1(106.61,47.14) R10875.2
  BOTTOM w0.127: JDIM1.101 107.72,50.49 107.24,50.01 107.24,48.79 107.68,48.36 v1(108.11,48.36)
M_A_CB3: length 6.2
  TOP w0.127: v1(108.11,49.69) v1(107.22,50.57) 105.83,51.96 R10881.2
  BOTTOM w0.127: v1(108.11,49.69) 108.11,49.66 108.72,50.28 JDIM1.105
M_A_CB4: length 4
  TOP w0.127: R10879.2 104.84,43.83 104.45,44.22 104.45,44.76 104.06,45.15 v1(103.97,45.15)
  BOTTOM w0.127: v1(103.97,45.15) 104.47,44.65 JDIM1.88
M_A_CB5: length 3
  TOP w0.127: v1(104.32,50.12) 104.13,50.12 R10884.2
  BOTTOM w0.127: JDIM1.87 104.22,50.21 v1(104.32,50.12)
M_A_CB6: length 7.2
  TOP w0.127: R10888.2 108.9,41.68 107.75,42.82 v1(107.75,43.81) 107.75,44.36 v1(106.97,45.14)
  BOTTOM w0.127: v1(106.97,45.14) 107.47,44.64 JDIM1.100
M_A_CB7: length 5.5
  TOP w0.127: v1(108.97,45.14) 108.51,44.68 108.51,43.33 v1(108.92,42.92) 109.15,42.69 R10892.2
  BOTTOM w0.127: JDIM1.104 108.47,44.64 v1(108.97,45.14)
M_A_CKE0: length 66.3
  IN1 w0.216: v1(108.11,47.67) 107.58,48.2 107.58,50.55 105.69,52.44 105.69,67.16 104.72,68.13 104.72,71.75 104.95,71.98 105.77,71.98 105.92,72.13 105.92,72.47 105.77,72.63 104.9,72.63 104.72,72.8 104.72,87.28 105.54,88.1 105.54,90.9 107.8,93.16 107.8,93.54 v1(107.32,94.03)
  BOTTOM w0.079: U35.BA56 109.11,101.52 109.11,101.33 109.18,101.14 109.18,100.9 109.03,100.75 109.03,99.32 107.16,97.46 107.16,94.18 v1(107.32,94.03)
  BOTTOM w0.191: JDIM1.109 109.72,50.38 108.74,49.4 108.74,46.97 108.53,46.76 108.29,46.76 108.11,46.94 v1(108.11,47.67)
M_A_CKE1: length 65.9
  IN1 w0.216: v1(107.32,93.35) 104.99,91.03 104.99,88.22 104.22,87.45 104.22,67.84 105.3,66.76 105.3,52.2 107.07,50.44 107.07,47.96 107.89,47.14 109.73,47.14 111,45.87 111,44.24 110.8,44.04 110.43,44.04 110.23,44.24 v1(110.23,44.66)
  BOTTOM w0.079: U35.BB56 108.84,101.03 108.84,99.36 106.91,97.43 106.91,93.76 v1(107.32,93.35)
  BOTTOM w0.191: v1(110.23,44.66) 109.97,44.4 JDIM1.110
M_A_CLK0: length 67.3
  IN1 w0.089: v2(110.26,104.51) 109.84,104.08 109.84,101.84 110.64,101.04 112.28,101.04 112.7,100.62 112.7,99.8 112.7,99.65 112.73,99.62 112.73,99.6 112.74,99.59
  IN1 w0.114: v1(118.05,47.75) 118.23,47.75 118.35,47.87 118.35,60.1 117.57,60.88 117.57,64.06 117.49,64.14 117.49,76.74 115.12,79.11 115.12,86.33 113.33,88.12 113.33,91.54 113.67,91.89 113.67,98.66 112.74,99.59
  BOTTOM w0.127: v1(118.05,47.75) 118.31,47.75 118.58,48.01 118.58,48.15 116.85,49.89 116.85,50.24 116.72,50.36 JDIM1.137 ; U35.AT53 v2(110.26,104.51)
M_A_CLK0#: length 67.3
  IN1 w0.089: v1(110.26,103.88) 110,103.63 110,101.91 110.71,101.2 112.35,101.2 112.87,100.69 112.87,99.74 112.88,99.73
  IN1 w0.114: v1(119.32,47.75) 119.24,47.67 118.7,47.67 118.57,47.8 118.57,60.18 117.79,60.97 117.79,64.15 117.71,64.23 117.71,76.83 115.33,79.2 115.33,86.42 113.54,88.21 113.54,91.48 113.87,91.8 113.87,98.74 112.88,99.73
  BOTTOM w0.127: U35.AU53 110.72,103.98 110.63,103.88 v1(110.26,103.88) ; JDIM1.139 117.22,50.41 117.07,50.26 117.07,49.98 118.81,48.25 118.81,47.98 119.04,47.75 v1(119.32,47.75)
M_A_CLK1: length 67.2
  IN1 w0.089: 108.88,104.07 109.34,104.53 v1(109.37,104.53) ; 108.88,101.87 111.23,99.52 111.95,99.52 112.22,99.25
  IN1 w0.114: v1(116.61,44.78) 117.1,45.27 117.1,46.02 117.39,46.32 117.39,51.72 116.87,52.24 116.87,63.61 116.64,63.84 116.64,76.39 114.2,78.84 114.2,86.12 112.71,87.61 112.71,91.79 113.14,92.22 113.14,98.33 112.22,99.25 ; 108.88,101.87 108.88,104.07
  BOTTOM w0.114: JDIM1.138 116.97,44.27 117.05,44.34 117.05,44.68 116.95,44.78 v1(116.61,44.78)
  BOTTOM w0.127: U35.AT55 109.48,104.53 v1(109.37,104.53)
M_A_CLK1#: length 67.1
  IN1 w0.089: 112.35,99.39 112.05,99.69 111.34,99.69 109.07,101.95 109.07,103.6 109.34,103.87 v1(109.37,103.87)
  IN1 w0.114: v1(117.88,44.78) 117.38,44.78 117.31,44.85 117.31,45.93 117.61,46.23 117.61,51.81 117.09,52.33 117.09,63.7 116.86,63.93 116.86,76.48 114.41,78.93 114.41,86.21 112.9,87.72 112.9,91.71 113.09,91.9 113.33,92.14 113.33,98.41 112.35,99.39
  BOTTOM w0.114: JDIM1.140 117.47,44.15 117.27,44.36 117.27,44.67 117.38,44.78 v1(117.88,44.78)
  BOTTOM w0.127: U35.AU55 109.81,103.93 109.75,103.87 v1(109.37,103.87)
M_A_CS#0: length 70.5
  IN1 w0.079: v2(115.78,104.53) 115.34,104.09 115.34,103.33 117.59,101.08 117.59,99.51 118,99.1 118,94.06 117.67,93.72 117.67,93.44
  IN1 w0.216: 117.67,93.44 117.67,89.66 121.79,85.54 121.79,81.72 125.18,78.33 125.18,73.67 125.3,73.54 125.48,73.54 125.64,73.39 125.64,73.17 125.15,72.69 125.15,72.45 125.6,72 125.6,63.41 126.05,62.96 126.05,56.78 125.15,55.88 125.15,52.07 123.82,50.73 123.82,49.45 123.98,49.3 124.44,49.3 124.59,49.14 124.59,48.8 124.44,48.65 123.86,48.65 123.7,48.5 123.7,48.12 123.93,47.9 v1(124.39,47.9)
  BOTTOM w0.191: JDIM1.149 121.72,50.26 122.13,49.86 122.13,49.32 123.55,47.9 v1(124.39,47.9)
  BOTTOM w0.203: U35.AU45 v2(115.78,104.53)
M_A_CS#1: length 71
  IN1 w0.079: 118,93.39 118,93.76 118.2,93.95 118.2,98.91 118.62,99.32 118.62,99.97 117.98,100.61 117.98,101.03 115.78,103.24 v2(115.78,103.9)
  IN1 w0.216: v1(124.34,49.93) 124.47,49.93 124.62,50.08 124.62,50.94 125.63,51.94 126.55,52.87 126.55,54.23 126.4,54.38 125.85,54.38 125.73,54.51 125.73,54.77 125.85,54.9 126.4,54.9 126.55,55.05 126.55,55.27 126.4,55.42 125.83,55.42 125.7,55.55 125.7,55.81 125.83,55.94 126.97,55.94 127.08,56.05 127.08,56.32 126.95,56.45 126.66,56.45 126.55,56.56 126.55,63.15 126.04,63.67 126.04,68.16 126.37,68.5 126.37,73.4 125.67,74.1 125.67,74.27 125.82,74.42 126.22,74.42 126.37,74.58 126.37,74.79 126.22,74.94 125.82,74.94 125.67,75.1 125.67,75.31 125.82,75.47 126.22,75.47 126.37,75.62 126.37,75.83 126.22,75.99 125.82,75.99 125.67,76.14 125.67,76.35 125.82,76.51 126.22,76.51 126.37,76.66 126.37,76.88 126.22,77.03 125.82,77.03 125.67,77.18 125.67,78.58 125.44,78.82 125.44,79.03 125.48,79.08 125.48,79.26 125.29,79.44 125.11,79.44 125.03,79.37 124.86,79.37 124.67,79.56 124.67,79.73 124.74,79.81 124.74,79.99 124.55,80.18 124.37,80.18 124.3,80.1 124.12,80.1 123.93,80.29 123.93,80.47 123.99,80.53 123.99,80.75 123.84,80.9 123.62,80.9 123.56,80.84 123.38,80.84 123.19,81.03 123.19,81.21 123.27,81.29 123.27,81.47 123.08,81.65 122.9,81.65 122.86,81.61 122.65,81.61 122.29,81.96 122.29,85.61 118,89.9 118,93.39
  BOTTOM w0.191: JDIM1.157 123.72,50.21 124.01,49.93 v1(124.34,49.93)
  BOTTOM w0.203: v2(115.78,103.9) U35.AU43
M_A_DQ0: length 84.2
  IN1 w0.089: 91.29,108.46 93.19,108.46 93.58,108.86 95.83,108.86 v1(96.06,108.62)
  IN1 w0.14: v1(83.56,45.94) 83.56,48.52 83.78,48.73 83.78,50.8 83.24,51.33 82.45,51.33 81.08,52.7 81.08,56.15 79.44,57.8 79.44,72.41 79.64,72.62 80.13,72.62 80.25,72.73 80.25,72.89 80.13,73.01 79.64,73.01 79.53,73.12 79.53,73.29 79.64,73.4 80.26,73.4 80.38,73.52 80.38,78.8 81.59,80 81.59,99.22 90.83,108.46 91.29,108.46
  BOTTOM w0.079: U35.AL71 99.92,107.91 99.9,107.88 98.34,107.88 98.14,108.08 96.6,108.08 v1(96.06,108.62)
  BOTTOM w0.127: v1(83.56,45.94) 84.47,45.03 JDIM1.8
M_A_DQ1: length 84.8
  IN1 w0.089: 91.12,109.16 93.06,109.16 93.19,109.3 97.15,109.3 97.57,108.88 v1(97.57,108.74)
  IN1 w0.14: 91.12,109.16 90.48,109.16 80.73,99.4 80.73,80.33 78.72,78.32 78.72,77.98 78.83,77.86 79.21,77.86 79.33,77.75 79.33,77.59 79.21,77.47 78.83,77.47 78.72,77.36 78.72,77.19 78.83,77.08 79.2,77.08 79.32,76.96 79.32,76.8 79.2,76.68 78.83,76.68 78.72,76.57 78.72,76.41 78.83,76.29 79.37,76.29 79.49,76.17 79.49,76.01 79.37,75.9 78.83,75.9 78.72,75.78 78.72,57.53 80.37,55.87 80.37,51.77 82.32,49.81 82.68,49.81 82.89,50.02 v1(82.89,50.11)
  BOTTOM w0.079: U35.AL68 102.46,108.23 102.46,108.78 102.28,108.96 101.13,108.96 101.04,108.87 100.47,108.87 100.32,108.8 99.46,108.8 99.19,109.07 98.6,109.07 98.52,109.15 97.97,109.15 97.57,108.75 v1(97.57,108.74)
  BOTTOM w0.127: JDIM1.3 83.22,50.45 v1(82.89,50.11)
M_A_DQ2: length 85.5
  IN1 w0.14: v1(96.12,107.07) 95.63,106.59 91.61,106.59 83.67,98.65 83.67,79.14 82.45,77.92 82.45,70.3 82.34,70.18 81.61,70.18 81.49,70.07 81.49,69.91 81.61,69.79 82.34,69.79 82.45,69.68 82.45,69.51 82.34,69.4 81.61,69.4 81.49,69.28 81.49,69.12 81.61,69 82.42,69 82.54,68.89 82.54,68.73 82.42,68.61 81.61,68.61 81.49,68.49 81.49,62.46 83.12,60.84 83.12,60.39 83.24,60.27 83.37,60.27 83.5,60.14 83.5,53.74 85.72,51.51 85.72,46.92 v1(85.5,46.7)
  BOTTOM w0.079: v1(96.12,107.07) 96.79,106.4 97.98,106.4 98.22,106.17 99.86,106.17 99.86,106.17 100.86,106.17 101.07,106.39 101.63,106.39 101.93,106.68 U35.AN68
  BOTTOM w0.127: v1(85.5,46.7) 87.47,44.72 JDIM1.20
M_A_DQ3: length 84.3
  IN1 w0.079: v1(98.8,107.07) 98.77,107.07 97.6,105.89 92.39,105.89
  IN1 w0.14: v1(86.47,49.99) 86.52,49.99 86.71,50.19 86.71,51.58 84.68,53.61 84.68,54.65 84.8,54.76 85.2,54.76 85.32,54.88 85.32,55.04 85.2,55.16 84.8,55.16 84.68,55.27 84.68,55.44 84.8,55.55 85.2,55.55 85.32,55.67 85.32,55.83 85.2,55.95 84.8,55.95 84.68,56.06 84.68,56.22 84.8,56.34 85.2,56.34 85.32,56.45 85.32,56.62 85.2,56.73 84.8,56.73 84.68,56.85 84.68,57.01 84.8,57.13 85.2,57.13 85.32,57.24 85.32,57.41 85.2,57.52 84.8,57.52 84.68,57.64 84.68,57.8 84.8,57.91 85.2,57.91 85.32,58.03 85.32,58.19 85.2,58.31 84.8,58.31 84.68,58.42 84.68,62.53 83.4,63.81 83.4,66.21 83.82,66.64 83.82,66.98 83.93,67.09 84.66,67.09 84.77,67.21 84.77,67.37 84.66,67.49 83.93,67.49 83.82,67.6 83.82,67.77 83.93,67.88 84.66,67.88 84.77,68 84.77,68.16 84.66,68.28 83.93,68.28 83.82,68.39 83.82,68.55 83.93,68.67 84.57,68.67 84.68,68.78 84.68,68.95 84.57,69.06 83.93,69.06 83.82,69.18 83.82,69.34 83.93,69.46 84.49,69.46 84.61,69.57 84.61,69.74 84.49,69.85 83.93,69.85 83.82,69.97 83.82,77.69 84.77,78.65 84.77,80.54 84.42,80.9 84.42,98.41 91.9,105.89 92.39,105.89
  BOTTOM w0.079: U35.AN69 101.19,106.68 100.96,106.91 100.53,106.91 100.32,107.02 99.96,107.02 99.62,106.68 99.18,106.68 v1(98.8,107.07)
  BOTTOM w0.127: v1(86.47,49.99) 86.72,50.24 JDIM1.17
M_A_DQ4: length 84.9
  IN1 w0.089: 91.12,108.82 93.13,108.82 93.41,109.1 96.73,109.1 96.86,108.97 96.86,108.75 v1(96.8,108.7)
  IN1 w0.14: 91.12,108.82 90.68,108.82 81.09,99.23 81.09,80.11 79.89,78.9 79.89,75.55 79.77,75.44 79.17,75.44 79.06,75.32 79.06,75.16 79.17,75.04 79.77,75.04 79.89,74.93 79.89,74.76 79.77,74.65 79.17,74.65 79.06,74.53 79.06,74.37 79.17,74.25 79.77,74.25 79.89,74.14 79.89,73.98 79.77,73.86 79.17,73.86 79.07,73.76 79.07,57.68 80.74,56.01 80.74,52.2 82.22,50.73 83.08,50.73 83.34,50.46 83.34,48.97 83.13,48.76 v1(82.94,48.76)
  BOTTOM w0.079: v1(96.8,108.7) 97.21,108.29 98.31,108.29 98.54,108.06 99.74,108.06 99.79,108.11 99.93,108.11 100.09,108.18 100.29,108.18 100.41,108.13 100.62,108.13 U35.AL70
  BOTTOM w0.127: JDIM1.7 84.22,49.95 83.04,48.76 v1(82.94,48.76)
M_A_DQ5: length 85.2
  IN1 w0.089: 91.18,109.5 97.41,109.5 98.19,108.72 v1(98.23,108.72)
  IN1 w0.14: v1(83.47,44.52) 82.99,45 82.99,47.82 82.12,48.69 82.12,49.43 80.03,51.52 80.03,55.73 78.34,57.42 78.34,78.73 80.34,80.73 80.34,99.51 90.34,109.5 91.18,109.5
  BOTTOM w0.079: v1(98.23,108.72) 98.7,108.25 99.42,108.25 99.45,108.28 99.9,108.28 100.06,108.35 100.31,108.35 100.42,108.3 100.73,108.3 U35.AL69
  BOTTOM w0.127: v1(83.47,44.52) JDIM1.4
M_A_DQ6: length 83.7
  IN1 w0.14: v1(86.47,48.67) 86.03,49.11 86.03,51.74 84.38,53.39 84.38,62.12 81.88,64.63 81.88,65.67 81.99,65.79 82.63,65.79 82.75,65.9 82.75,66.07 82.63,66.18 81.99,66.18 81.88,66.3 81.88,66.46 81.99,66.58 83,66.58 83.11,66.69 83.11,66.86 83,66.97 81.99,66.97 81.88,67.09 81.88,67.25 81.99,67.36 83,67.36 83.11,67.48 83.11,67.64 83,67.76 81.99,67.76 81.88,67.87 81.88,68.04 81.99,68.15 83,68.15 83.11,68.27 83.11,77.75 84.38,79.02 84.38,80.43 84.05,80.77 84.05,98.53 91.76,106.24 97.29,106.24 v1(98.13,107.07)
  BOTTOM w0.079: U35.AN70 100.68,106.74 100.54,106.74 100.29,106.85 100.02,106.85 99.67,106.5 98.7,106.5 v1(98.13,107.07)
  BOTTOM w0.127: JDIM1.21 87.72,49.46 86.93,48.67 v1(86.47,48.67)
M_A_DQ7: length 82.8
  IN1 w0.14: v1(96.78,107.07) 96.32,107.53 95.76,107.53 95.16,106.93 91.46,106.93 83.31,98.78 83.31,79.39 82.06,78.14 82.06,71.55 81.95,71.43 81.29,71.43 81.18,71.32 81.18,71.15 81.29,71.04 81.95,71.04 82.06,70.92 82.06,70.76 81.95,70.64 81.24,70.64 81.09,70.49 81.09,62.08 82.86,60.31 82.86,60.11 83.11,59.86 83.11,53.53 85.38,51.26 85.38,47.58 84.76,46.96 84.76,45.49 84.89,45.37 v1(85.46,45.37)
  BOTTOM w0.079: v1(96.78,107.07) 97.2,106.65 98.12,106.65 98.43,106.33 99.75,106.33 100,106.58 U35.AN71
  BOTTOM w0.127: v1(85.46,45.37) 85.83,45.37 86.47,44.72 JDIM1.16
M_A_DQ8: length 76.4
  IN1 w0.079: v1(95.39,104.93) 94.93,104.47 92.6,104.47 92.39,104.25
  IN1 w0.14: 92.39,104.25 92.15,104.25 85.84,97.94 85.84,81.83 86.11,81.57 86.11,62.74 86.16,62.68 86.16,55.65 87.84,53.97 87.84,52.09 87.95,51.97 88.12,51.97 88.24,51.85 88.24,51.69 88.12,51.58 87.95,51.58 87.84,51.46 87.84,51.3 87.95,51.18 88.12,51.18 88.24,51.07 88.24,50.9 88.12,50.79 87.95,50.79 87.84,50.67 87.84,48.66 87.96,48.53 88.37,48.53 88.5,48.66 v1(88.5,48.78)
  BOTTOM w0.079: v1(95.39,104.93) 95.39,105.3 95.5,105.4 96.02,105.4 96.09,105.48 96.09,105.73 96.2,105.84 96.35,105.84 96.46,105.73 96.46,105.45 96.56,105.35 96.7,105.35 96.8,105.45 96.8,105.75 96.88,105.83 100.56,105.83 U35.AR70
  BOTTOM w0.127: JDIM1.29 89.72,49.52 89.61,49.41 89.05,49.41 88.94,49.3 88.94,49.14 89.05,49.03 89.42,49.03 89.52,48.92 89.52,48.78 89.42,48.67 88.6,48.67 v1(88.5,48.78)
M_A_DQ9: length 77.3
  IN1 w0.14: v1(88.48,44.69) 87.87,44.69 87.13,45.44 87.13,53.69 85.58,55.24 85.58,62.17 85.42,62.33 85.42,80.84 85.14,81.12 85.14,98.22 92.06,105.14 93.87,105.14 94.12,105.39 96.94,105.39 v1(97.4,104.93)
  BOTTOM w0.079: v1(97.4,104.93) 97.83,105.35 99.88,105.35 100.07,105.16 101.69,105.16 101.98,105.45 U35.AR68
  BOTTOM w0.127: v1(88.48,44.69) 88.47,44.7 JDIM1.24
M_A_DQ10: length 74.6
  IN1 w0.079: v1(96.47,102.91) 96.47,102.57 96.31,102.4 92.96,102.4 92.66,102.1
  IN1 w0.14: 92.66,102.1 87.74,97.18 87.74,90.44 88.08,90.1 88.08,77.1 88.2,76.99 88.61,76.99 88.72,76.87 88.72,76.71 88.61,76.59 88.2,76.59 88.08,76.48 88.08,76.32 88.2,76.2 88.61,76.2 88.72,76.08 88.72,75.92 88.61,75.81 88.2,75.81 88.08,75.69 88.08,75.53 88.2,75.41 88.61,75.41 88.72,75.3 88.72,75.13 88.61,75.02 88.2,75.02 88.08,74.9 88.08,74.74 88.2,74.62 88.61,74.62 88.72,74.51 88.72,74.35 88.61,74.23 88.2,74.23 88.08,74.12 88.08,73.95 88.2,73.84 88.61,73.84 88.72,73.72 88.72,73.56 88.61,73.44 88.2,73.44 88.08,73.33 88.08,73.17 88.2,73.05 88.61,73.05 88.72,72.93 88.72,72.77 88.61,72.66 88.2,72.66 88.08,72.54 88.08,72.38 88.2,72.26 88.61,72.26 88.72,72.15 88.72,71.98 88.61,71.87 88.2,71.87 88.08,71.75 88.08,71.59 88.2,71.48 88.61,71.48 88.72,71.36 88.72,62.96 89.21,62.47 89.21,55.36 90.11,54.46 90.11,49.95 v1(90.63,49.44)
  BOTTOM w0.079: U35.AU71 100.12,104.17 98.92,104.17 98.52,103.76 97.33,103.76 v1(96.47,102.91)
  BOTTOM w0.127: JDIM1.37 91.72,49.9 91.26,49.44 v1(90.63,49.44)
M_A_DQ11: length 76.2
  IN1 w0.089: v1(98.3,102.27) 97.52,101.48 93.54,101.48 93.41,101.36
  IN1 w0.14: 93.41,101.36 88.8,96.74 88.8,90.93 89.11,90.62 89.11,88.06 89.23,87.95 89.64,87.95 89.75,87.83 89.75,87.67 89.64,87.55 89.23,87.55 89.11,87.44 89.11,87.27 89.23,87.16 89.64,87.16 89.75,87.04 89.75,86.88 89.64,86.76 89.23,86.76 89.11,86.65 89.11,86.49 89.23,86.37 89.64,86.37 89.75,86.26 89.75,86.09 89.64,85.98 89.23,85.98 89.11,85.86 89.11,85.7 89.23,85.58 89.64,85.58 89.75,85.47 89.75,85.31 89.64,85.19 89.23,85.19 89.11,85.07 89.11,84.91 89.23,84.8 89.64,84.8 90.1,84.33 90.1,63.11 91.12,62.1 91.12,53.89 91.9,53.1 91.9,46.98 92.46,46.43 92.46,45.36 v1(91.85,44.75)
  BOTTOM w0.079: 100.3,103.2 100.3,103.21 100.96,103.21 101.13,103.38 101.13,103.57 101.38,103.82 101.64,103.82 102.07,104.25 U35.AU68
  BOTTOM w0.114: 100.3,103.2 99.81,103.2 98.88,102.27 v1(98.3,102.27)
  BOTTOM w0.127: v1(91.85,44.75) 91.97,44.63 JDIM1.38
M_A_DQ12: length 75
  IN1 w0.079: v1(96.74,104.93) 96.27,104.45 95.54,104.45 95.22,104.13 92.76,104.13 92.52,103.9
  IN1 w0.14: v1(88.51,50.09) 88.51,52.16 88.22,52.44 88.22,54.11 86.49,55.84 86.49,62.85 86.61,62.97 87.21,62.97 87.32,63.08 87.32,63.25 87.21,63.36 86.61,63.36 86.49,63.48 86.49,63.64 86.61,63.75 87.21,63.75 87.32,63.87 87.32,64.03 87.21,64.15 86.61,64.15 86.49,64.26 86.49,66.22 86.61,66.33 87.03,66.33 87.15,66.45 87.15,66.61 87.03,66.73 86.61,66.73 86.49,66.84 86.49,67.01 86.61,67.12 87.03,67.12 87.15,67.24 87.15,67.4 87.03,67.51 86.61,67.51 86.49,67.63 86.49,67.79 86.61,67.91 87.03,67.91 87.15,68.02 87.15,68.19 87.03,68.3 86.61,68.3 86.49,68.42 86.49,68.58 86.61,68.7 87.03,68.7 87.15,68.81 87.15,68.97 87.03,69.09 86.61,69.09 86.49,69.2 86.49,69.37 86.61,69.48 86.92,69.48 87.03,69.6 87.03,69.76 86.9,69.89 86.68,69.89 86.55,70.02 86.55,81.85 86.19,82.21 86.19,97.8 92.29,103.9 92.52,103.9
  BOTTOM w0.079: v1(96.74,104.93) 97.37,105.55 U35.AR71
  BOTTOM w0.127: v1(88.51,50.09) 88.72,50.31 JDIM1.25
M_A_DQ13: length 76.3
  IN1 w0.14: v1(94.72,104.91) 94.6,104.79 92.2,104.79 85.49,98.08 85.49,81.69 85.76,81.42 85.76,62.51 85.87,62.41 85.87,55.43 87.49,53.81 87.49,47.01 v1(88.5,46)
  BOTTOM w0.079: U35.AR69 101.37,105.45 100.83,105.99 97.86,105.99 97.76,106.09 95.9,106.09 v1(94.72,104.91)
  BOTTOM w0.127: v1(88.5,46) 88.85,46 89.47,45.38 JDIM1.28
M_A_DQ14: length 75
  IN1 w0.079: v1(97.21,102.89) 96.4,102.08 93.13,102.08 92.91,101.86
  IN1 w0.14: v1(90.63,48.11) 91.12,48.6 91.12,50.57 90.45,51.23 90.45,61.71 89.07,63.1 89.07,77.33 88.95,77.45 88.54,77.45 88.42,77.56 88.42,77.73 88.54,77.84 88.95,77.84 89.07,77.96 89.07,78.12 88.95,78.24 88.54,78.24 88.42,78.35 88.42,78.51 88.54,78.63 88.95,78.63 89.07,78.74 89.07,78.91 88.95,79.02 88.54,79.02 88.42,79.14 88.42,79.3 88.54,79.42 88.95,79.42 89.07,79.53 89.07,79.7 88.95,79.81 88.54,79.81 88.42,79.93 88.42,80.09 88.54,80.2 88.95,80.2 89.07,80.32 89.07,80.48 88.95,80.6 88.54,80.6 88.42,80.71 88.42,90.29 88.1,90.62 88.1,97.05 92.91,101.86
  BOTTOM w0.079: v1(97.21,102.89) 97.86,103.54 98.57,103.54 98.98,103.95 100.56,103.95 U35.AU70
  BOTTOM w0.127: JDIM1.41 92.72,49.41 91.43,48.11 v1(90.63,48.11)
M_A_DQ15: length 75.4
  IN1 w0.079: v1(97.97,102.89) 97.82,102.73 97.82,102.25 97.35,101.78 93.35,101.78 93.16,101.6
  IN1 w0.14: v1(91.88,46.07) 91.55,46.4 91.55,50.7 90.8,51.45 90.8,61.84 89.64,63.01 89.64,81.58 89.29,81.93 88.88,81.93 88.77,82.04 88.77,82.21 88.88,82.32 89.29,82.32 89.41,82.44 89.41,82.6 89.29,82.71 88.88,82.71 88.77,82.83 88.77,82.99 88.88,83.11 89.29,83.11 89.41,83.22 89.41,83.39 89.29,83.5 88.88,83.5 88.77,83.62 88.77,83.78 88.88,83.9 89.29,83.9 89.41,84.01 89.41,84.17 89.29,84.29 88.88,84.29 88.77,84.4 88.77,90.46 88.44,90.78 88.44,96.88 93.16,101.6
  BOTTOM w0.079: U35.AU69 101.4,104.23 101.02,103.85 100.72,103.85 100.64,103.77 99.04,103.77 98.38,103.11 98.2,103.11 v1(97.97,102.89)
  BOTTOM w0.127: v1(91.88,46.07) 92.23,46.07 92.97,45.33 JDIM1.42
M_A_DQ16: length 71.5
  IN1 w0.14: v1(99.36,97.41) 99.19,97.41 98.23,98.38 93.36,98.38 90.54,95.56 90.54,92.2 92.78,89.96 92.78,69.46 93.08,69.17 93.08,64.3 93.49,63.89 93.49,53.83 93.95,53.37 93.95,49.5 93.81,49.37 93.81,47.26 94.32,46.75 94.32,45.2 v1(93.92,44.79)
  BOTTOM w0.079: v1(99.36,97.41) 99.39,97.39 99.72,97.39 99.87,97.53 99.87,98.63 100.36,99.12 101.71,99.12 102.07,99.49 102.49,99.49 103.84,100.84 103.84,100.99 U35.BB65
  BOTTOM w0.127: v1(93.92,44.79) 93.97,44.74 JDIM1.46
M_A_DQ17: length 73.3
  IN1 w0.14: v1(99.64,99.95) 99.28,99.59 92.59,99.59 89.45,96.45 89.45,91.42 90.54,90.34 90.54,85.49 90.88,85.15 90.88,69.05 91.42,68.51 91.42,63.27 92.03,62.66 92.03,53.7 92.4,53.33 92.4,47.69 93.74,46.35 v1(93.88,46.35)
  BOTTOM w0.079: v1(99.64,99.95) 100.4,100.72 102,100.72 102.31,101.02 102.31,101.22 102.48,101.4 102.76,101.4 103.09,101.73 103.38,101.73 103.49,101.85 103.55,101.97 103.55,102.33 103.73,102.72 U35.AW65
  BOTTOM w0.127: v1(93.88,46.35) 94.97,45.26 JDIM1.50
M_A_DQ18: length 74.3
  IN1 w0.079: 99.43,94.42 99.43,94.87 99.78,95.22 99.78,97.49 v1(100.62,98.33)
  IN1 w0.14: 99.43,94.42 99.43,92.63 95.52,88.73 95.52,62.7 95.82,62.4 95.82,59.39 95.67,59.24 95.31,59.24 95.2,59.13 95.2,58.97 95.31,58.85 95.89,58.85 96.01,58.73 96.01,58.57 95.89,58.46 95.45,58.46 95.34,58.34 95.34,58.18 95.45,58.06 95.89,58.06 96.01,57.95 96.01,56.49 95.89,56.37 95.3,56.37 95.18,56.26 95.18,56.1 95.3,55.98 95.89,55.98 96.01,55.87 96.01,55.7 95.89,55.59 95.36,55.59 95.24,55.47 95.24,55.31 95.36,55.19 95.89,55.19 96.01,55.08 96.01,49.84 95.89,49.73 95.72,49.73 95.61,49.61 95.61,49.45 95.72,49.33 95.89,49.33 96.01,49.22 96.01,48.85 96.6,48.25 96.6,46.76 96.49,46.65 96.13,46.65 96.02,46.53 96.02,46.37 96.13,46.25 96.49,46.25 96.6,46.14 96.6,45.97 96.49,45.86 96.13,45.86 96.02,45.74 96.02,45.58 96.13,45.47 97.28,45.47 v1(97.67,45.08)
  BOTTOM w0.079: v1(100.62,98.33) 101.62,98.33 102.19,98.9 102.7,98.9 103.79,99.99 104.9,99.99 105.18,100.28 105.18,100.69 104.99,100.89 104.99,101.17 105.06,101.31 105.06,101.34 104.99,101.57 104.99,102.12 104.85,102.26 104.85,102.72 U35.AW63
  BOTTOM w0.127: JDIM1.62 97.97,44.77 v1(97.67,45.08)
M_A_DQ19: length 73.4
  IN1 w0.079: v1(100.59,95.63) 100.59,94.86 100.52,94.79 100.52,94.42
  IN1 w0.14: v1(97.43,50) 97.59,49.83 97.74,49.83 97.92,50.02 97.92,50.21 96.97,51.16 96.97,58.97 97.59,59.6 97.59,62.9 97.29,63.21 97.29,65.73 97.7,66.15 97.7,76.97 97.59,77.08 96.99,77.08 96.87,77.2 96.87,77.36 96.99,77.48 97.59,77.48 97.7,77.59 97.7,77.75 97.59,77.87 96.99,77.87 96.87,77.98 96.87,78.15 96.99,78.26 97.59,78.26 97.7,78.38 97.7,78.54 97.59,78.66 96.99,78.66 96.87,78.77 96.87,78.94 96.99,79.05 97.59,79.05 97.7,79.17 97.7,79.33 97.59,79.44 96.99,79.44 96.87,79.56 96.87,79.72 96.99,79.84 97.59,79.84 97.7,79.95 97.7,80.12 97.59,80.23 96.99,80.23 96.87,80.35 96.87,80.51 96.99,80.63 97.59,80.63 97.7,80.74 97.7,80.9 97.59,81.02 96.99,81.02 96.87,81.13 96.87,81.3 96.99,81.41 97.59,81.41 97.7,81.53 97.7,81.69 97.59,81.81 96.99,81.81 96.87,81.92 96.87,82.08 96.99,82.2 97.59,82.2 97.7,82.32 97.7,82.48 97.59,82.59 96.99,82.59 96.87,82.71 96.87,82.87 96.99,82.99 97.59,82.99 97.7,83.1 97.7,83.27 97.59,83.38 96.99,83.38 96.87,83.5 96.87,83.66 96.99,83.78 97.59,83.78 97.7,83.89 97.7,84.05 97.59,84.17 96.99,84.17 96.74,84.42 96.74,88.09 100.52,91.88 100.52,94.42
  BOTTOM w0.079: v1(100.59,95.63) 101.15,96.18 101.15,96.8 102.69,98.34 102.9,98.34 104.02,99.46 105.06,99.46 105.7,100.1 105.7,101.74 105.17,102.27 U35.AY63
  BOTTOM w0.127: v1(97.43,50) 97.22,50.2 JDIM1.59
M_A_DQ20: length 72.4
  IN1 w0.14: v1(93.23,49.46) 93.36,49.46 93.66,49.76 93.66,50.47 93.12,51.01 93.12,52.04 93.24,52.15 93.33,52.15 93.45,52.27 93.45,52.43 93.33,52.55 93.24,52.55 93.12,52.66 93.12,56.72 93,56.83 92.77,56.83 92.66,56.95 92.66,57.11 92.77,57.23 93,57.23 93.12,57.34 93.12,57.51 93,57.62 92.77,57.62 92.66,57.74 92.66,57.9 92.77,58.01 93,58.01 93.12,58.13 93.12,58.29 93,58.41 92.77,58.41 92.66,58.52 92.66,58.69 92.77,58.8 93,58.8 93.12,58.92 93.12,59.08 93,59.2 92.77,59.2 92.66,59.31 92.66,59.47 92.77,59.59 93,59.59 93.12,59.7 93.12,59.87 93,59.98 92.77,59.98 92.66,60.1 92.66,60.26 92.77,60.38 93,60.38 93.12,60.49 93.12,60.66 93,60.77 92.77,60.77 92.66,60.89 92.66,61.05 92.77,61.16 92.98,61.16 93.09,61.28 93.09,61.44 92.98,61.56 92.77,61.56 92.66,61.67 92.66,61.84 92.77,61.95 92.89,61.95 93,62.07 93,62.23 92.89,62.35 92.77,62.35 92.7,62.41 92.7,68.92 92.32,69.31 92.32,89.67 90.18,91.81 90.18,95.89 93.06,98.76 98.67,98.76 v1(99.36,98.07)
  BOTTOM w0.079: U35.BA65 103.94,101.51 103.71,101.28 103.71,101.28 103.66,101.15 103.66,100.89 102.49,99.71 102.06,99.71 101.63,99.29 100.29,99.29 99.7,98.7 99.7,98.3 99.47,98.07 v1(99.36,98.07)
  BOTTOM w0.127: v1(93.23,49.46) 93.72,49.96 JDIM1.45
