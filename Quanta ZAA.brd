# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ31: length 55.7
  IN2 w0.114: v2(106.62,103.87) 106.62,102.49 105.08,100.94
  IN2 w0.14: v1(102.97,57.36) 102,57.36 101.86,57.5 101.86,58.01 101.98,58.12 102.38,58.12 102.5,58.24 102.5,58.4 102.38,58.51 101.98,58.51 101.86,58.63 101.86,58.79 101.98,58.91 102.45,58.91 102.57,59.02 102.57,59.19 102.45,59.3 101.87,59.3 101.76,59.42 101.76,59.58 101.87,59.7 102.45,59.7 102.57,59.81 102.57,59.97 102.45,60.09 101.98,60.09 101.86,60.2 101.86,66.02 101.94,66.1 101.94,90.07 105.08,93.21 105.08,100.94
  BOTTOM w0.127: v1(102.97,57.36) 103.47,56.86 JDIM2.84 ; U35.AU60 v2(106.62,103.87)
M_B_DQ32: length 56.8
  IN2 w0.079: v2(117.63,103.9) 117.63,103.89 117.63,101.59 120.35,98.87 120.35,94.15 121.11,93.4
  IN2 w0.14: 121.11,93.4 125.58,88.92 125.58,86.13 126.28,85.44 126.28,84.87 130.84,80.31 130.84,76.58 131.16,76.27 131.16,69.86 130.43,69.14 130.43,68.38 129.25,67.19 129.25,59.6 v1(127.15,57.51)
  BOTTOM w0.127: v1(127.15,57.51) 127.43,57.51 127.97,56.97 JDIM2.174 ; U35.AU40 117.63,103.9 v2(117.63,103.9)
M_B_DQ33: length 57.3
  IN2 w0.079: v2(117.63,104.53) 117.25,104.14 117.25,101.75 120.19,98.81 120.19,93.94 120.86,93.27
  IN2 w0.14: 120.86,93.27 125.23,88.89 125.23,86.01 125.83,85.41 125.83,84.82 130.35,80.29 130.35,76.58 130.8,76.12 130.8,70.18 128.89,68.26 128.89,60.52 v1(127.15,58.78)
  BOTTOM w0.127: v1(127.15,58.78) 126.67,58.3 126.67,56.72 126.97,56.42 JDIM2.170 ; U35.AT40 v2(117.63,104.53)
M_B_DQ34: length 58.2
  IN2 w0.079: 125.14,92.49 124.77,92.85 124.62,92.85 124.35,93.12 124.35,98.62 122.8,100.16 122.57,100.16 119.87,102.86 119.87,104.14 v2(119.48,104.53)
  IN2 w0.14: 125.14,92.49 128.23,89.4 128.23,87.2 128.87,86.56 128.87,85.99 134,80.86 134,68.14 132.25,66.39 132.25,64.63 132.42,64.46 132.42,60.1 130.58,58.26 130.58,57.32 130.16,56.89 129.81,56.89 129.77,56.93 v1(129.74,56.93)
  BOTTOM w0.127: JDIM2.182 129.97,56.69 v1(129.74,56.93) ; U35.AT37 v2(119.48,104.53)
M_B_DQ35: length 57.4
  IN2 w0.079: v2(119.48,103.87) 119.48,102.99 122.56,99.92 122.56,99.24 124.04,97.76 124.04,93.08 124.83,92.29
  IN2 w0.14: v1(129.74,58.2) 129.77,58.2 132.06,60.48 132.06,64.36 131.89,64.53 131.89,66.52 133.65,68.28 133.65,80.7 128.51,85.84 128.51,86.41 127.88,87.05 127.88,89.24 124.83,92.29
  BOTTOM w0.127: JDIM2.186 130.97,57.41 130.19,58.2 v1(129.74,58.2) ; U35.AU37 v2(119.48,103.88)
M_B_DQ36: length 57.9
  IN2 w0.079: v2(117.63,105.18) 117.09,104.64 117.09,101.68 120.02,98.74 120.02,93.71 120.62,93.11
  IN2 w0.14: 120.62,93.11 124.87,88.86 124.87,85.88 125.48,85.27 125.48,84.66 129.22,80.92 129.22,79.4 129.34,79.29 129.5,79.29 129.61,79.4 129.61,80.08 129.73,80.19 129.89,80.19 130.01,80.08 130.01,76.43 130.28,76.16 130.28,70.14 128.53,68.39 128.53,61.72 127.23,60.41 v1(127.15,60.41)
  BOTTOM w0.127: U35.AR40 v2(117.63,105.18) ; JDIM2.173 127.72,62.65 127.89,62.49 127.89,61.15 v1(127.15,60.41)
M_B_DQ37: length 58.8
  IN2 w0.079: 120.38,92.94 119.86,93.46 119.86,98.63 116.32,102.17 116.32,105.51 116.68,105.87 v2(117.61,105.87)
  IN2 w0.14: v1(127.15,61.68) 128.18,62.71 128.18,68.52 129.92,70.26 129.92,76.03 129.67,76.29 129.67,78.83 129.55,78.95 129.39,78.95 129.27,78.83 129.27,77.09 129.16,76.98 128.99,76.98 128.88,77.09 128.88,80.77 125.13,84.52 125.13,85.14 124.52,85.75 124.52,88.8 120.38,92.94
  BOTTOM w0.127: v1(127.15,61.68) 126.67,62.17 126.67,62.58 126.72,62.63 JDIM2.169 ; v2(117.61,105.87) U35.AP40
M_B_DQ38: length 59.7
  IN2 w0.079: 122.09,98.56 122.09,99.31 122.13,99.35 122.13,99.84 118.94,103.03 118.94,105.28 v2(119.48,105.83)
  IN2 w0.14: v1(131.28,62.29) 131.44,62.46 131.44,64.07 131.19,64.32 131.19,66.79 132.19,67.79 132.19,68.07 131.98,68.28 131.98,68.49 132.93,69.44 132.93,77.87 132.81,77.98 132.56,77.98 132.44,78.1 132.44,78.26 132.56,78.38 132.81,78.38 132.93,78.49 132.93,78.65 132.81,78.77 132.56,78.77 132.44,78.88 132.44,79.05 132.56,79.16 132.81,79.16 132.93,79.28 132.93,79.44 132.81,79.56 132.61,79.56 132.5,79.67 132.5,79.83 132.61,79.95 132.81,79.95 132.93,80.07 132.93,80.2 132.8,80.32 132.65,80.32 132.52,80.45 132.52,80.81 127.83,85.51 127.83,86.1 127.18,86.75 127.18,88.88 123.36,92.69 123.36,96.99 122.91,97.44 122.91,98.19 122.79,98.3 122.62,98.3 122.5,98.19 122.5,95.98 122.38,95.86 122.21,95.86 122.09,95.98 122.09,98.56
  BOTTOM w0.127: v1(131.28,62.29) 131.25,62.29 131.22,62.31 JDIM2.187 ; U35.AP37 v2(119.48,105.83)
M_B_DQ39: length 59.1
  IN2 w0.079: v2(119.48,105.18) 119.1,104.79 119.1,103.12 122.4,99.83 122.4,99.17 123.76,97.81 123.76,92.84 124.54,92.05
  IN2 w0.14: v1(131.28,61.02) 131.28,60.76 130.25,59.73 130.25,59.56 130.39,59.41 130.57,59.41 131.76,60.59 131.76,64.2 131.55,64.41 131.55,66.66 133.27,68.38 133.27,80.57 128.17,85.68 128.17,86.24 127.52,86.89 127.52,89.08 124.54,92.05
  BOTTOM w0.127: v1(131.28,61.02) 131.24,60.99 130.99,60.99 130.29,61.68 130.29,62.56 130.22,62.63 JDIM2.183 ; U35.AR37 v2(119.48,105.18)
M_B_DQ40: length 59.6
  IN2 w0.079: v2(121.32,104.53) 121.71,104.14 121.71,102.19 124.21,99.69 124.97,99.69 125.81,98.85 125.81,93.84 126.18,93.47
  IN2 w0.114: v1(132.11,57.99) 132.29,57.99
  IN2 w0.14: 126.18,93.47 129.95,89.69 129.95,88 130.62,87.33 130.62,86.66 136.42,80.86 136.42,72.63 136.31,72.52 135.83,72.52 135.71,72.4 135.71,72.24 135.83,72.13 136.09,72.13 136.2,72.01 136.2,71.85 136.09,71.73 135.93,71.73 135.8,71.61 135.8,67.42 134.44,66.06 134.44,60.92 132.62,59.1 132.62,58.32 132.29,57.99
  BOTTOM w0.127: U35.AT33 v2(121.32,104.53) ; JDIM2.194 132.97,56.53 132.57,56.94 132.57,57.75 132.33,57.99 v1(132.11,57.99)
M_B_DQ41: length 59.2
  IN2 w0.079: v2(121.32,103.88) 121.54,103.66 121.54,102.13 124.14,99.52 124.9,99.52 125.64,98.79 125.64,93.5 125.89,93.26
  IN2 w0.14: 125.89,93.26 129.6,89.54 129.6,87.87 130.28,87.19 130.28,86.51 136.08,80.71 136.08,73.37 135.34,72.63 135.34,69.62 135.46,69.51 135.46,67.56 134.07,66.18 134.07,61.04 133.02,59.99 132.86,59.99 131.21,58.34 131.21,56.64 131.33,56.52 131.51,56.52 131.63,56.64 131.63,56.78 131.76,56.91 131.98,56.91 132.11,56.78 v1(132.11,56.72)
  BOTTOM w0.127: v1(132.11,56.72) 131.97,56.59 JDIM2.190 ; U35.AU33 v2(121.32,103.88)
M_B_DQ42: length 58.2
  IN2 w0.079: 128.98,95.64 128.98,95.78 128.79,95.97 128.79,97.26 126.58,99.47 126.39,99.47 123.41,102.45 123.41,103.52 v2(123.05,103.88)
  IN2 w0.14: 128.98,95.64 128.98,92.96 129.59,92.35 129.59,91.34 131.53,89.4 131.53,88.61 132.17,87.97 132.17,87.31 138.89,80.59 138.89,77.33 138.78,77.22 138.61,77.22 138.5,77.33 138.5,80.37 138.38,80.49 138.22,80.49 138.11,80.37 138.11,76.16 138.01,76.07 138.01,71.48 137.38,70.85 137.38,66.84 136.8,66.27 136.8,64.5 135.9,63.59 v1(135.9,62.32)
  BOTTOM w0.127: v2(123.05,103.88) U35.AU30 ; JDIM2.207 136.22,62.65 v1(135.9,62.32)
M_B_DQ43: length 59.2
  IN2 w0.079: 129.27,95.67 129.27,95.77 128.95,96.08 128.95,97.32 126.63,99.64 126.46,99.64 123.59,102.51 123.59,103.88 123.27,104.2 123.27,104.31 v2(123.05,104.53)
  IN2 w0.14: v1(135.9,61.05) 136.34,61.49 136.34,63.49 137.2,64.35 137.2,66.16 137.72,66.68 137.72,70.68 138.45,71.41 138.45,76.76 138.57,76.88 138.72,76.88 138.85,76.75 138.85,75.17 138.96,75.06 139.13,75.06 139.24,75.17 139.24,80.75 132.51,87.48 132.51,88.11 131.88,88.74 131.88,89.55 130.03,91.4 130.03,92.36 129.27,93.12 129.27,95.67
  BOTTOM w0.127: v1(135.9,61.05) 135.37,61.05 135.22,61.19 JDIM2.203 ; v2(123.05,104.53) U35.AT30
M_B_DQ44: length 60.4
  IN2 w0.079: 125.62,93.01 125.48,93.16 125.48,98.72 124.86,99.34 124.1,99.34 121.37,102.06 121.37,103.06 120.93,103.5 120.93,104.8 v2(121.32,105.18)
  IN2 w0.14: 125.62,93.01 129.24,89.39 129.24,87.74 129.93,87.05 129.93,86.36 135.74,80.55 135.74,76.41 135.62,76.29 135.16,76.29 135.05,76.18 135.05,76.02 135.16,75.9 135.62,75.9 135.74,75.78 135.74,75.62 135.62,75.51 135.16,75.51 135.05,75.39 135.05,75.23 135.16,75.11 135.62,75.11 135.74,75 135.74,74.83 135.62,74.72 135.16,74.72 135.05,74.6 135.05,74.44 135.16,74.33 135.62,74.33 135.74,74.21 135.74,73.51 135,72.77 135,69.48 135.11,69.37 135.11,67.71 133.72,66.31 133.72,61.25 133.45,60.99 v1(133.29,60.99)
  BOTTOM w0.127: U35.AR33 v2(121.32,105.18) ; JDIM2.191 132.22,60.68 132.35,60.55 133.16,60.55 133.29,60.68 v1(133.29,60.99)
M_B_DQ45: length 61.4
  IN2 w0.079: v2(121.32,105.83) 120.77,105.29 120.77,103.42 121.2,103 121.2,102 124.03,99.17 124.79,99.17 125.31,98.65 125.31,92.87 125.43,92.75
  IN2 w0.14: v1(133.29,62.26) 132.94,62.26 132.85,62.35 132.85,62.66 132.97,62.79 133.24,62.79 133.37,62.92 133.37,63.06 133.25,63.18 132.88,63.18 132.77,63.29 132.77,63.46 132.88,63.57 133.25,63.57 133.37,63.69 133.37,63.85 133.25,63.96 132.88,63.96 132.77,64.08 132.77,64.24 132.88,64.36 133.25,64.36 133.37,64.47 133.37,66.45 134.77,67.85 134.77,69.23 134.66,69.34 134.66,76.64 134.77,76.75 135.28,76.75 135.4,76.87 135.4,77.03 135.28,77.15 134.77,77.15 134.66,77.26 134.66,77.42 134.77,77.54 135.28,77.54 135.4,77.65 135.4,77.82 135.28,77.93 134.77,77.93 134.66,78.05 134.66,78.21 134.77,78.33 135.28,78.33 135.4,78.44 135.4,78.61 135.28,78.72 134.77,78.72 134.66,78.84 134.66,79 134.77,79.11 135.28,79.11 135.4,79.23 135.4,79.39 135.28,79.51 134.77,79.51 134.66,79.62 134.66,79.79 134.77,79.9 135.28,79.9 135.4,80.02 135.4,80.18 135.28,80.3 134.74,80.3 134.65,80.39 134.65,80.6 134.74,80.69 134.8,80.69 134.89,80.78 134.89,80.91 129.59,86.21 129.59,86.91 128.89,87.61 128.89,89.3 125.43,92.75
  BOTTOM w0.127: JDIM2.195 133.22,62.32 v1(133.29,62.26) ; U35.AP33 v2(121.32,105.83)
M_B_DQ46: length 59.3
  IN2 w0.079: v2(123.05,105.18) 123.44,104.79 123.44,104.26 123.77,103.93 123.77,102.57 126.53,99.8 126.7,99.8 129.12,97.38 129.12,96.17 129.41,95.88 129.53,95.88 129.59,95.82 129.59,95.68
  IN2 w0.14: 129.59,95.68 129.59,93.27 130.44,92.42 130.44,91.44 132.24,89.64 132.24,88.87 132.85,88.25 132.85,87.64 139.82,80.68 139.82,75.19 138.8,74.16 138.8,71.27 138.07,70.54 138.07,66.52 137.58,66.02 137.58,64.16 136.69,63.27 136.69,58.64 136.2,58.15 v1(136.22,58.15)
  BOTTOM w0.127: v2(123.05,105.18) U35.AR30 ; JDIM2.204 135.47,57.41 v1(136.22,58.15)
M_B_DQ47: length 60.4
  IN2 w0.079: v2(123.05,105.83) 123.59,105.28 123.59,104.33 123.95,103.98 123.95,102.64 126.61,99.98 126.76,99.98 129.99,96.75 129.99,95.98 129.95,95.94 129.95,95.66
  IN2 w0.14: 129.95,95.66 129.95,93.39 130.83,92.52 130.83,91.51 132.59,89.74 132.59,89 133.2,88.4 133.2,87.79 140.16,80.82 140.16,74.23 140.04,74.1 139.27,74.1 139.14,73.97 139.14,71.12 138.46,70.45 138.46,66.38 137.96,65.88 137.96,64 137.06,63.09 137.06,57.73 136.2,56.88 v1(136.22,56.88)
  BOTTOM w0.127: v2(123.05,105.83) U35.AP30 ; v1(136.22,56.88) 136.47,56.62 JDIM2.208
M_B_DQ48: length 59.6
  IN2 w0.079: 131.19,95.7 131.19,95.98 131.29,96.07 131.29,96.62 130.64,97.26 130.4,97.26 127.72,99.95 127.72,100.75 126.53,101.94 125.79,101.94 124.91,102.82 v2(124.91,103.89)
  IN2 w0.14: v1(138.53,60.99) 139.12,61.58 139.12,62.08 139.23,62.2 139.37,62.2 139.49,62.31 139.49,62.48 139.37,62.59 139.23,62.59 139.12,62.71 139.12,63.09 140.19,64.16 140.19,68.42 140.51,68.74 140.68,68.74 140.75,68.67 140.91,68.67 141.03,68.78 141.03,68.95 140.84,69.13 140.84,69.3 140.96,69.41 141.12,69.41 141.31,69.23 141.47,69.23 141.58,69.34 141.58,69.51 141.51,69.58 141.51,69.74 141.77,69.99 141.77,70.03 141.89,70.16 141.99,70.16 142.11,70.28 142.11,70.45 141.99,70.58 141.88,70.58 141.76,70.69 141.76,70.86 141.88,70.98 141.97,70.98 142.1,71.1 142.1,71.28 141.98,71.39 141.9,71.39 141.79,71.51 141.79,71.67 141.9,71.79 141.98,71.79 142.1,71.9 142.1,72.07 141.98,72.18 141.88,72.18 141.77,72.3 141.77,72.46 141.88,72.57 141.98,72.57 142.1,72.69 142.1,72.85 141.98,72.97 141.83,72.97 141.71,73.08 141.71,73.25 141.83,73.36 141.98,73.36 142.1,73.48 142.1,81.44 134.87,88.66 134.87,89.09 134.32,89.64 134.32,90.08 132.34,92.06 132.34,92.93 131.19,94.08 131.19,95.7
  BOTTOM w0.127: v1(138.53,60.99) 137.77,60.99 137.22,61.53 JDIM2.211 ; v2(124.91,103.89) U35.AU27
M_B_DQ49: length 60.1
  IN2 w0.079: v2(124.91,104.54) 124.91,104.44 124.5,104.04 124.5,103 125.73,101.77 126.47,101.77 127.53,100.71 127.53,99.9 130.47,96.96 130.47,96.08 130.84,95.7 130.84,95.57
  IN2 w0.14: v1(138.53,62.3) 138.53,63.03 139.84,64.33 139.84,68.97 139.95,69.08 140.37,69.08 140.49,69.2 140.49,69.36 140.37,69.48 139.95,69.48 139.84,69.59 139.84,69.78 139.97,69.91 140.38,69.91 140.51,70.03 140.51,72.66 140.62,72.78 140.79,72.78 140.9,72.66 140.9,70.21 141.02,70.1 141.18,70.1 141.3,70.21 141.3,73.47 141.75,73.92 141.75,81.28 134.53,88.49 134.53,88.95 133.97,89.51 133.97,89.9 131.96,91.91 131.96,92.78 130.84,93.9 130.84,95.57
  BOTTOM w0.127: JDIM2.215 138.22,62.61 v1(138.53,62.3) ; v2(124.91,104.54) U35.AT27
M_B_DQ50: length 58.8
  IN2 w0.079: v2(125.84,104.54) 126.33,104.05 126.33,103.39 131.98,97.74 131.98,95.28 132.12,95.14
  IN2 w0.14: 132.12,95.14 134.97,92.29 134.97,92.13 134.87,92.02 134.87,91.86 134.98,91.75 135.14,91.75 135.25,91.85 135.41,91.85 135.53,91.73 135.53,91.57 135.43,91.47 135.43,91.31 135.54,91.19 135.71,91.19 135.81,91.29 135.97,91.29 136.08,91.18 136.08,91.01 135.96,90.89 135.96,90.73 136.08,90.61 136.24,90.61 136.36,90.74 136.53,90.74 136.77,90.49 136.77,89.52 137.3,88.99 137.46,88.99 137.57,89.09 137.73,89.09 137.84,88.98 137.84,88.81 137.74,88.71 137.74,88.55 137.86,88.43 138.02,88.43 138.12,88.54 138.29,88.54 138.4,88.42 138.4,88.26 138.3,88.15 138.3,87.99 138.41,87.87 138.58,87.87 138.68,87.98 138.84,87.98 138.96,87.86 138.96,87.7 138.85,87.59 138.85,87.43 138.97,87.32 139.13,87.32 139.24,87.42 139.4,87.42 139.52,87.31 139.52,87.14 139.41,87.04 139.41,86.87 139.53,86.76 139.69,86.76 139.79,86.86 139.96,86.86 140.07,86.75 140.07,86.59 139.97,86.48 139.97,86.32 140.08,86.2 140.25,86.2 140.35,86.31 140.52,86.31 140.63,86.19 140.63,86.03 140.53,85.92 140.53,85.76 140.64,85.64 140.8,85.64 140.91,85.75 141.07,85.75 141.19,85.63 141.19,85.47 141.08,85.37 141.08,85.2 141.2,85.09 141.36,85.09 141.47,85.19 141.63,85.19 141.75,85.08 141.75,84.91 141.64,84.81 141.64,84.65 144.13,82.16 144.13,69.24 142.38,67.48 142.38,64.16 141.37,63.15 v1(141.37,62.18)
  BOTTOM w0.127: v1(141.37,62.18) 141.2,62.18 140.72,62.66 JDIM2.225 ; v2(125.84,104.54) U35.AT25
M_B_DQ51: length 58.4
  IN2 w0.079: 131.99,94.72 131.8,94.91 131.8,97.69 125.84,103.65 v2(125.84,103.89)
  IN2 w0.14: 131.99,94.72 133.59,93.12 133.59,92.38 134.46,91.51 134.67,91.51 136.41,89.77 136.41,89.36 143.78,82 143.78,69.37 142.03,67.62 142.03,64.31 140.87,63.15 140.87,59.05 v1(141.37,58.55)
  BOTTOM w0.127: v2(125.84,103.89) U35.AU25 ; JDIM2.224 140.47,56.35 140.56,56.44 140.56,57.83 141.29,58.55 v1(141.37,58.55)
M_B_DQ52: length 60.9
  IN2 w0.079: 130.54,95.62 130.54,95.77 130.31,96 130.31,96.89 127.35,99.84 127.35,100.65 126.41,101.6 125.67,101.6 124.34,102.93 124.34,104.1 124.52,104.28 124.52,105.46 v2(124.91,105.84)
  IN2 w0.14: 130.54,95.62 130.54,93.75 131.6,92.69 131.6,91.75 133.61,89.73 133.61,89.38 134.19,88.81 134.19,88.33 141.18,81.34 141.18,73.84 140.17,72.83 140.17,70.75 139.46,70.04 139.46,64.48 138.11,63.13 138.11,58.4 v1(138.54,57.97)
  BOTTOM w0.127: JDIM2.212 137.47,57.51 137.93,57.97 v1(138.54,57.97) ; v2(124.91,105.84) U35.AP27
M_B_DQ53: length 61.2
  IN2 w0.079: 130.26,95.65 130.26,95.82 130.15,95.94 130.15,96.82 127.15,99.82 127.15,100.62 126.34,101.43 125.6,101.43 124.17,102.86 124.17,104.17 124.37,104.36 124.37,105.95 v2(124.91,106.49)
  IN2 w0.14: 130.26,95.65 130.26,93.58 131.23,92.61 131.23,91.6 133.25,89.58 133.25,89.26 133.84,88.66 133.84,88.09 140.84,81.09 140.84,73.98 139.81,72.96 139.81,70.88 139.11,70.18 139.11,64.7 137.45,63.03 137.45,57.79 v1(138.54,56.7)
  BOTTOM w0.127: v1(138.54,56.7) 138.47,56.64 JDIM2.216 ; v2(124.91,106.49) U35.AN27
M_B_DQ54: length 61
  IN2 w0.079: 132.65,95.62 132.32,95.95 132.32,97.87 127.12,103.07 127.12,105.34 125.97,106.5 v2(125.84,106.5)
  IN2 w0.14: 132.65,95.62 137.48,90.79 137.48,90.31 144.82,82.97 144.82,68.44 143.07,66.68 143.07,63.74 142.17,62.84 142.17,58.08 141.41,57.32 v1(141.41,57.25)
  BOTTOM w0.127: v2(125.84,106.5) U35.AN25 ; v1(141.41,57.25) 141.47,57.18 JDIM2.228
M_B_DQ55: length 60.1
  IN2 w0.079: v2(125.84,105.85) 126.26,105.42 126.26,104.37 126.51,104.12 126.51,103.44 132.14,97.81 132.14,95.61 132.43,95.33
  IN2 w0.14: 132.43,95.33 137.13,90.63 137.13,90.18 142.3,85.01 142.3,84.84 142.2,84.74 142.2,84.58 142.31,84.46 142.48,84.46 142.58,84.56 142.74,84.56 142.86,84.45 142.86,84.29 142.76,84.18 142.76,84.02 142.87,83.9 143.04,83.9 143.14,84.01 143.3,84.01 143.42,83.89 143.42,83.73 143.31,83.62 143.31,83.46 144.48,82.29 144.48,69.1 144.05,68.67 144.05,68.51 144.11,68.45 144.11,68.26 143.97,68.12 143.81,68.12 143.74,68.19 143.57,68.19 143.46,68.08 143.46,67.91 143.53,67.84 143.53,67.68 143.41,67.57 143.25,67.57 143.18,67.64 143.01,67.64 142.9,67.52 142.9,67.36 142.97,67.29 142.97,67.12 142.73,66.88 142.73,63.91 141.81,62.99 141.81,60.74 141.73,60.66 141.58,60.66 141.37,60.87 v1(141.37,60.91)
  BOTTOM w0.127: JDIM2.229 141.72,62.7 141.96,62.46 141.96,61.39 141.48,60.91 v1(141.37,60.91) ; v2(125.84,105.85) U35.AP25
M_B_DQ56: length 61.5
  IN2 w0.079: v2(128.54,104.52) 128.13,104.12 128.13,103.72 128.8,103.05 128.8,102.18 132.9,98.08 132.9,97.3 133.32,96.88
  IN2 w0.14: 133.32,96.88 138.88,91.33 138.88,90.86 146.66,83.08 146.66,68.01 145.6,66.95 145.24,66.95 144.48,66.19 144.48,62.98 144.6,62.87 144.76,62.87 144.88,62.98 144.88,64.16 144.99,64.27 145.16,64.27 145.27,64.16 145.27,62.74 144.48,61.95 144.48,60.65 144.17,60.33 143.82,60.33 v1(143.19,60.97)
  BOTTOM w0.127: v1(143.19,60.97) 142.72,61.43 JDIM2.233 ; v2(128.54,104.52) U35.AT22
M_B_DQ57: length 61.3
  IN2 w0.14: v2(128.54,103.87) 129.27,103.14 129.27,102.49 133.99,97.77 133.99,96.73 139.24,91.48 139.24,90.98 147,83.22 147,67.86 146,66.86 146,62.98 145,61.98 145,60.22 144.73,59.95 143.69,59.95 143.56,59.82 143.56,59.63 143.69,59.5 144.7,59.5 144.82,59.37 144.82,59.16 144.7,59.03 143.9,59.03 143.78,58.9 143.78,58.78 v1(143.17,58.17)
  BOTTOM w0.127: JDIM2.232 142.47,57.6 143.04,58.17 143.16,58.17 v1(143.17,58.17) ; v2(128.54,103.87) U35.AU22
M_B_DQ58: length 59.9
  IN2 w0.079: v2(129.47,104.53) 130.12,103.87 130.12,103.13 132.17,101.08 132.93,101.08 133.07,100.94
  IN2 w0.14: 133.07,100.94 135.49,98.52 135.49,97.4 135.73,97.16 135.94,97.37 136.1,97.37 136.21,97.25 136.21,97.09 136.09,96.97 136.09,96.8 136.2,96.69 136.37,96.69 136.49,96.81 136.66,96.81 136.77,96.7 136.77,96.53 136.65,96.41 136.65,96.25 137.34,95.55 137.5,95.55 137.84,95.88 138,95.88 138.11,95.77 138.11,95.6 137.78,95.27 137.78,95.11 137.9,94.99 138.06,94.99 138.44,95.38 138.61,95.38 138.72,95.26 138.72,95.1 138.34,94.72 138.34,94.55 138.45,94.44 138.62,94.44 138.98,94.8 139.14,94.8 139.26,94.68 139.26,94.52 138.9,94.16 138.9,94 140.77,92.12 140.77,91.68 148.53,83.92 148.53,67.13 147.53,66.13 147.53,62.27 v1(146.97,61.72)
  BOTTOM w0.127: v1(146.97,61.72) 146.39,61.72 145.72,62.38 JDIM2.245 ; v2(129.47,104.53) U35.AU21
M_B_DQ59: length 61
  IN2 w0.079: 132.5,101.39 132.31,101.39 130.35,103.35 130.35,104.29 v2(129.47,105.18)
  IN2 w0.14: 132.5,101.39 133.11,101.39 139.62,94.89 139.62,93.85 141.13,92.34 141.13,91.82 148.88,84.07 148.88,66.94 147.88,65.95 147.88,64.52 148,64.4 148.55,64.4 148.67,64.29 148.67,64.12 148.55,64.01 148,64.01 147.88,63.89 147.88,63.73 148,63.62 148.55,63.62 148.67,63.5 148.67,63.34 148.55,63.22 148,63.22 147.88,63.11 147.88,61.35 v1(146.97,60.45)
  BOTTOM w0.127: v2(129.47,105.18) U35.AT21 ; JDIM2.249 146.72,62.61 147.63,61.7 147.63,61.1 v1(146.97,60.45)
M_B_DQ60: length 63
  IN2 w0.079: 132.95,96.25 132.51,96.69 132.51,98.01 128.45,102.07 128.45,102.93 127.79,103.59 127.79,105.65 v1(128.54,106.41)
  IN2 w0.14: v1(143.17,56.9) 143.06,56.9 142.68,57.29 142.68,62.47 143.73,63.51 143.73,66.42 144.94,67.64 145.31,67.64 145.97,68.3 145.97,68.71 145.64,69.04 145.64,79.74 145.76,79.86 145.86,79.86 145.97,79.97 145.97,80.13 145.86,80.25 145.76,80.25 145.64,80.37 145.64,80.53 145.76,80.64 145.86,80.64 145.97,80.76 145.97,80.92 145.86,81.04 145.76,81.04 145.64,81.15 145.64,81.32 145.76,81.43 145.86,81.43 145.97,81.55 145.97,81.71 145.86,81.82 145.76,81.82 145.64,81.94 145.64,82.1 145.76,82.22 145.86,82.22 145.97,82.33 145.97,82.5 145.86,82.61 145.86,82.91 138.15,90.61 138.15,91.05 132.95,96.25
  BOTTOM w0.127: JDIM2.236 143.47,56.79 143.36,56.9 143.17,56.9 v1(143.17,56.9) ; v1(128.54,106.41) U35.AN22
M_B_DQ61: length 62.9
  IN2 w0.079: 133.16,96.53 132.73,96.96 132.73,98.01 128.62,102.13 128.62,103.01 127.96,103.66 127.96,105.19 v1(128.54,105.77)
  IN2 w0.14: 133.16,96.53 138.51,91.18 138.51,90.73 146.31,82.93 146.31,79.55 146.2,79.43 146.12,79.43 146,79.32 146,79.15 146.12,79.04 146.2,79.04 146.31,78.92 146.31,78.76 146.2,78.64 146.12,78.64 146,78.53 146,78.36 146.12,78.25 146.2,78.25 146.31,78.13 146.31,77.97 146.2,77.86 146.12,77.86 146,77.74 146,77.58 146.12,77.46 146.2,77.46 146.31,77.35 146.31,77.18 146.2,77.07 146.12,77.07 146,76.95 146,76.79 146.12,76.67 146.2,76.67 146.31,76.56 146.31,76.4 146.2,76.28 146.12,76.28 146,76.17 146,76 146.12,75.89 146.2,75.89 146.31,75.77 146.31,75.61 146.2,75.49 146.12,75.49 146,75.38 146,75.21 146.12,75.1 146.2,75.1 146.31,74.98 146.31,74.82 146.2,74.71 146.12,74.71 146,74.59 146,74.43 146.12,74.31 146.2,74.31 146.31,74.2 146.31,74.03 146.2,73.92 146.12,73.92 146,73.8 146,73.64 146.12,73.52 146.2,73.52 146.31,73.41 146.31,73.25 146.2,73.13 146.12,73.13 146,73.02 146,72.85 146.12,72.74 146.2,72.74 146.31,72.62 146.31,72.46 146.2,72.34 146.12,72.34 146,72.23 146,72.07 146.12,71.95 146.2,71.95 146.31,71.83 146.31,71.67 146.2,71.56 146.12,71.56 146,71.44 146,71.28 146.12,71.16 146.2,71.16 146.31,71.05 146.31,70.88 146.2,70.77 146.12,70.77 146,70.65 146,70.49 146.12,70.38 146.2,70.38 146.31,70.26 146.31,70.1 146.2,69.98 146.12,69.98 146,69.87 146,69.7 146.12,69.59 146.2,69.59 146.31,69.47 146.31,68.15 145.46,67.29 145.09,67.29 144.12,66.33 144.12,60.98 144,60.86 143.8,60.86 143.67,60.98 143.67,62.1 143.53,62.24 v1(143.19,62.24)
  BOTTOM w0.127: v1(143.19,62.24) 143.48,62.24 143.72,62.48 JDIM2.237 ; v1(128.54,105.77) U35.AP22
M_B_DQ62: length 61.9
  IN2 w0.079: 132.5,101.76 132.4,101.76 130.55,103.6 130.55,104.4 129.89,105.07 129.89,106.03 v2(129.47,106.45)
  IN2 w0.14: v1(146.97,59.18) 147.1,59.18 148.85,60.93 148.85,62.79 149.33,63.27 149.33,65.99 149.22,66.1 149.07,66.1 148.95,66.22 148.95,66.38 149.07,66.5 149.22,66.5 149.33,66.61 149.33,84.1 141.48,91.96 141.48,93.51 133.23,101.76 132.5,101.76
  BOTTOM w0.127: v2(129.47,106.45) U35.AP21 ; v1(146.97,59.18) JDIM2.250
M_B_DQ63: length 63.3
  IN2 w0.14: v1(129.47,107.08) 129.73,107.08 130.85,105.95 130.85,103.68 132.27,102.26 133.22,102.26 141.84,93.63 141.84,92.08 149.68,84.25 149.68,63.13 149.21,62.66 149.21,60.78 148.07,59.64 148.07,59.32 v1(145.51,56.76)
  BOTTOM w0.127: JDIM2.246 145.97,56.3 145.51,56.76 v1(145.51,56.76) ; v1(129.47,107.08) 129.19,106.8 U35.AN21
M_B_DQS0: length 83.6
  IN2 w0.079: 89.24,113.43 89.34,113.54 96.96,113.54 97.29,113.21 98.3,113.21 100.97,110.54 102.59,110.54 102.81,110.31 103.24,110.31 v1(103.76,109.8)
  IN2 w0.127: 89.24,113.43 81.92,106.12 81.92,80.89 82.62,80.2 82.62,68.87 82.88,68.6 83.6,68.6 83.73,68.47 83.73,68.09 83.6,67.97 82.88,67.97 82.62,67.7 82.62,67.12 82.88,66.85 83.6,66.85 83.73,66.72 83.73,66.34 83.6,66.21 82.88,66.21 82.62,65.94 82.62,64.46 83.04,64.04 83.93,64.04 84.13,63.84 84.13,60.73 84.38,60.47 84.61,60.47 85.12,59.96 v1(85.12,59.84)
  BOTTOM w0.079: U35.AH65 v1(103.76,109.8)
  BOTTOM w0.127: v1(85.12,59.84) 85.12,60.23 85.25,60.36 85.88,60.36 86.15,60.63 86.15,62.1 85.72,62.52 JDIM2.13
M_B_DQS1: length 70.9
  IN2 w0.127: v1(89.99,58.65) 89.87,58.53 89.87,58.18 90,58.05 90.21,58.05 90.35,58.19 90.42,58.19 90.58,58.35 90.58,59.43 90.28,59.74 90.28,64.09 89.49,64.88 89.49,79.51 86.37,82.63 86.37,103.67 86.44,103.74 86.44,103.74 90.59,107.88 90.59,108.39 92.77,110.57 95.13,110.57 v2(95.54,110.17)
  BOTTOM w0.079: U35.AG70 100.96,110.09 100.78,110.09 100.57,110.19 100.47,110.19 100.31,110.12 99.96,110.12 99.53,110.55 95.89,110.55 95.54,110.19 v2(95.54,110.17)
  BOTTOM w0.127: JDIM2.34 90.97,56.35 90.82,56.5 90.82,57.93 90.53,58.22 90.15,58.22 89.99,58.37 v1(89.99,58.65)
M_B_DQS2: length 62
  IN2 w0.079: 102.87,102.34 102.89,102.34 102.92,102.37 103.14,102.37 103.53,102.76 103.53,104.18 103.46,104.25 103.46,104.78 103.57,104.89 103.57,105.09 103.64,105.16 103.82,105.16 v2(103.83,105.15)
  IN2 w0.127: v1(95.35,60.35) 95.35,60.76 95.44,60.85 95.44,60.85 95.48,60.89 95.81,60.89 96.18,61.26 96.18,62.6 95.8,62.98 95.8,66.01 95.21,66.61 95.21,86.52 94.88,86.84 93.58,86.84 93.45,86.97 93.45,87.35 93.58,87.48 94.84,87.48 95.11,87.75 95.11,88.33 94.84,88.6 93.66,88.6 93.53,88.72 93.53,89.1 93.66,89.23 95.14,89.23 98.99,93.09 98.99,94.99 98.74,95.24 98.74,100.01 99.19,100.46 99.97,100.46 100.65,101.14 100.65,102.19 101.15,102.68 101.61,102.68 101.95,102.34 102.87,102.34
  BOTTOM w0.127: v2(103.83,105.15) U35.AR65 ; JDIM2.55 96.22,62.7 96.12,62.59 96.12,61.02 95.86,60.76 95.49,60.76 95.35,60.62 v1(95.35,60.35)
M_B_DQS3: length 55.4
  IN2 w0.079: 103.86,92.58 103.9,92.58 104.24,92.92 104.24,100.6 104.61,100.98 104.77,100.98 106.39,102.6 106.39,102.61 106.39,102.62 106.39,103.45 106.24,103.6 106.24,105.01 106.41,105.17 v2(106.6,105.17)
  IN2 w0.127: v1(100.46,58.58) 100.53,58.51 100.53,58.31 100.4,58.19 100.19,58.19 100.03,58.35 100.03,59.63 100.29,59.89 100.7,59.89 101.22,60.41 101.22,89.94 103.86,92.58
  BOTTOM w0.127: U35.AR60 v2(106.6,105.17) ; JDIM2.76 101.47,56.27 101.35,56.4 101.35,57.7 100.98,58.06 100.66,58.06 100.46,58.26 v1(100.46,58.58)
M_B_DQS4: length 58
  IN2 w0.079: 123.78,91.31 123.78,91.36 122.99,92.15 122.68,92.15 121.61,93.23 121.61,98.84 118.47,101.98 118.47,102.99 118.01,103.45 118.01,104.26 118.12,104.37 118.12,104.73 v2(118.56,105.18)
  IN2 w0.127: 123.78,91.31 126.26,88.83 126.26,86.37 126.92,85.7 126.92,85.15 131.49,80.59 131.49,76.86 131.97,76.37 131.97,69.77 131.07,68.87 131.07,67.94 130.48,67.34 130.31,67.34 129.99,67.03 129.99,66.73 130.29,66.44 130.29,64.32 130.18,64.21 129.91,64.21 129.69,63.98 129.69,63.37 129.92,63.13 130.76,63.13 130.83,63.05 130.83,62.81 130.54,62.51 130.54,61.18 130.43,61.07 129.9,61.07 129.72,61.25 v1(129.72,61.68)
  BOTTOM w0.127: v1(129.72,61.68) 129.72,61.35 129.6,61.23 129.18,61.23 129.05,61.36 129.05,62.56 129.22,62.73 JDIM2.179 ; U35.AR38 v2(118.56,105.18)
M_B_DQS5: length 59.9
  IN2 w0.079: v1(122.11,105.16) 122.11,105.15 122.66,104.6 122.66,103.49 122.61,103.44 122.61,102.47 123.86,101.22 124.33,101.22 126.4,99.15 126.54,99.15 127.46,98.23 127.46,97.4 127.48,97.38 127.48,97.34 127.52,97.31
  IN2 w0.127: 127.52,97.31 127.53,97.29 127.53,92.88 130.87,89.54 130.87,88.49 130.86,88.48 130.86,88.34 131.5,87.7 131.5,87.07 137.31,81.26 137.31,71.68 136.69,71.06 136.69,67.06 135.32,65.7 135.32,59.21 134.47,58.36 134.39,58.36 v1(134.09,58.07)
  BOTTOM w0.127: v1(122.11,105.16) U35.AR32 ; v1(134.09,58.07) 134.09,58.39 134,58.47 133.85,58.47 133.66,58.28 133.66,57.1 134.47,56.28 JDIM2.200
M_B_DQS6: length 59.6
  IN2 w0.079: 131.89,93.97 131.85,94.01 131.85,94.05 131.48,94.42 131.48,97.48 125.29,103.66 125.29,105.03 125.13,105.19 v2(124.91,105.19)
  IN2 w0.127: v1(139.8,60.84) 139.8,60.09 139.86,60.03 140,60.03 140.24,60.27 140.24,63.65 140.83,64.25 140.83,67.68 142.76,69.61 142.76,81.7 135.51,88.95 135.51,89.36 132.69,92.19 132.69,93.14 131.89,93.93 131.89,93.97
  BOTTOM w0.127: v1(139.8,60.84) 139.8,60.57 139.68,60.45 139.45,60.45 139.29,60.61 139.29,61.64 139.63,61.98 139.63,62.57 139.72,62.67 JDIM2.221 ; v2(124.91,105.19) 125.23,105.19 125.35,105.32 U35.AR27
M_B_DQS7: length 61.4
  IN2 w0.079: 132.14,100.6 132.04,100.6 129.83,102.82 129.83,103.37 129.08,104.11 129.08,105.42 v1(129.47,105.8)
  IN2 w0.127: v1(145.51,58.05) 145.51,58.22 145.7,58.41 145.88,58.41 146.27,58.8 146.27,61.93 146.88,62.55 146.88,66.48 147.88,67.48 147.88,83.66 140.13,91.41 140.13,91.85 134.81,97.18 134.81,97.93 132.14,100.6
  BOTTOM w0.127: JDIM2.242 144.97,56.3 144.83,56.44 144.83,58.11 145.25,58.53 145.36,58.53 145.51,58.38 v1(145.51,58.05) ; v1(129.47,105.8) 129.05,105.5 U35.AR21
M_B_DQS8: length 4.2
  TOP w0.127: v1(106.71,62.26) 106.71,62.4 v1(106.03,63.08) 105.34,63.77 R10926.2
  BOTTOM w0.127: JDIM2.97 106.71,63.58 v1(106.71,62.26)
M_B_DQS#0: length 83.5
  IN2 w0.079: v1(103.11,109.8) 103.22,109.9 103.22,110.02 103.1,110.13 102.77,110.13 102.73,110.17 102.52,110.38 100.9,110.38 98.23,113.05 97.22,113.05 96.9,113.38 89.54,113.38 89.47,113.31
  IN2 w0.127: 89.47,113.31 82.17,106.01 82.17,80.98 82.86,80.3 82.86,68.97 82.98,68.84 83.7,68.84 83.97,68.57 83.97,67.99 83.7,67.72 82.98,67.72 82.86,67.6 82.86,67.22 82.98,67.09 83.7,67.09 83.97,66.82 83.97,66.24 83.7,65.97 82.98,65.97 82.86,65.84 82.86,64.57 83.16,64.27 84.02,64.27 84.38,63.91 84.38,60.86 84.51,60.73 84.68,60.73 84.96,60.44 85.45,60.44 85.58,60.57 85.58,60.98 85.45,61.11 v1(85.12,61.11)
  BOTTOM w0.079: U35.AH66 v1(103.11,109.8)
  BOTTOM w0.127: JDIM2.11 85.22,62.68 85.91,62 85.91,60.73 85.78,60.6 85.05,60.6 84.92,60.73 84.92,60.98 85.05,61.11 v1(85.12,61.11)
M_B_DQS#1: length 70.9
  IN2 w0.127: v1(94.89,110.15) 94.71,110.33 92.87,110.33 90.83,108.29 90.83,107.78 86.61,103.57 86.61,82.73 89.73,79.61 89.73,64.98 90.52,64.19 90.52,59.84 90.82,59.53 90.82,58.25 90.52,57.94 90.43,57.94 89.99,57.51 v1(89.99,57.38)
  BOTTOM w0.079: U35.AG69 101.54,110.07 101.42,110.07 101.22,110.26 100.8,110.26 100.59,110.36 100.43,110.36 100.27,110.29 100.02,110.29 99.6,110.71 95.45,110.71 v1(94.89,110.15)
  BOTTOM w0.127: v1(89.99,57.38) 89.99,57.81 90.16,57.98 90.43,57.98 90.58,57.83 90.58,56.47 90.47,56.36 JDIM2.32
M_B_DQS#2: length 62
  IN2 w0.079: v2(102.97,105.8) 103.4,105.36 103.4,104.95 103.3,104.86 103.3,104.19 103.37,104.12 103.37,102.83 103.07,102.53 102.99,102.53 102.94,102.58 102.92,102.58
  IN2 w0.127: v1(95.35,61.62) 95.35,61.36 95.58,61.13 95.71,61.13 95.94,61.36 95.94,62.5 95.56,62.88 95.56,65.91 94.97,66.51 94.97,86.42 94.78,86.6 93.48,86.6 93.21,86.87 93.21,87.45 93.48,87.72 94.74,87.72 94.86,87.85 94.86,88.23 94.74,88.36 93.56,88.36 93.29,88.62 93.29,89.2 93.56,89.47 95.04,89.47 98.75,93.19 98.75,94.89 98.49,95.14 98.49,100.11 99.09,100.71 99.87,100.71 100.41,101.24 100.41,102.29 101.05,102.93 101.71,102.93 102.05,102.58 102.92,102.58
  BOTTOM w0.127: v1(95.35,61.62) 95.35,61.19 95.54,61 95.76,61 95.88,61.12 95.88,62.53 95.72,62.68 JDIM2.53 ; v2(102.97,105.8) U35.AR66
M_B_DQS#3: length 55.4
  IN2 w0.079: 103.72,92.72 104.08,93.09 104.08,100.66 104.5,101.09 104.55,101.13 104.7,101.13 105.47,101.9 106.23,102.66 106.23,103.38 106.08,103.53 106.08,104.83 v2(105.69,105.21)
  IN2 w0.127: v1(100.46,57.31) 100.46,57.66 100.18,57.94 100.09,57.94 99.79,58.25 99.79,59.73 100.18,60.13 100.6,60.13 100.98,60.51 100.98,89.99 103.72,92.72
  BOTTOM w0.127: JDIM2.74 100.97,56.3 101.1,56.43 101.1,57.6 100.88,57.82 100.58,57.82 100.46,57.7 v1(100.46,57.31) ; U35.AR61 v2(105.69,105.21)
M_B_DQS#4: length 58.1
  IN2 w0.079: 123.95,91.53 123.84,91.53 123.06,92.31 122.75,92.31 121.77,93.29 121.77,98.91 118.63,102.04 118.63,103.06 118.17,103.52 118.17,104.14 v2(118.56,104.53)
  IN2 w0.127: 123.95,91.53 126.5,88.97 126.5,86.47 127.16,85.8 127.16,85.25 131.73,80.69 131.73,76.96 132.22,76.47 132.22,69.67 131.31,68.77 131.31,67.84 130.58,67.1 130.41,67.1 130.23,66.93 130.23,66.83 130.53,66.54 130.53,64.22 130.27,63.97 130.01,63.97 129.93,63.89 129.93,63.46 130.02,63.37 130.87,63.37 131.08,63.17 131.08,62.7 130.78,62.41 130.78,61.08 130.53,60.83 129.82,60.83 129.72,60.73 v1(129.72,60.41)
  BOTTOM w0.127: U35.AT38 v2(118.56,104.53) ; JDIM2.177 128.72,62.67 128.81,62.59 128.81,61.26 129.08,60.99 129.53,60.99 129.72,60.79 v1(129.72,60.41)
M_B_DQS#5: length 59.8
  IN2 w0.079: v2(122.11,104.51) 122.51,104.12 122.51,103.55 122.45,103.5 122.45,102.41 123.79,101.07 124.26,101.07 126.33,99 126.47,99 127.3,98.17 127.3,97.31
  IN2 w0.127: v1(134.09,59.34) 134.09,58.73 134.2,58.62 134.38,58.62 135.08,59.32 135.08,65.8 136.45,67.16 136.45,71.16 137.07,71.78 137.07,81.16 131.26,86.97 131.26,87.6 130.62,88.24 130.62,88.48 130.61,88.49 130.61,89.46 127.3,92.77 127.3,97.31
  BOTTOM w0.127: v2(122.11,104.51) 122.46,104.51 122.61,104.66 U35.AT32 ; v1(134.09,59.34) 134.09,58.88 133.92,58.71 133.75,58.71 133.42,58.38 133.42,57 133.97,56.44 JDIM2.198
M_B_DQS#6: length 59.6
  IN2 w0.079: 132,94.15 131.97,94.15 131.63,94.49 131.63,97.55 125.45,103.74 125.45,104.81 v2(125.84,105.19)
  IN2 w0.127: v1(139.8,59.57) 139.8,59.62 139.98,59.8 140.11,59.8 140.48,60.17 140.48,63.57 141.08,64.16 141.08,67.58 143.01,69.51 143.01,81.8 135.77,89.04 135.77,89.49 132.93,92.32 132.93,93.22 132,94.15
  BOTTOM w0.127: v2(125.84,105.19) U35.AR25 ; v1(139.8,59.57) 139.8,59.75 139.48,60.07 139.48,60.08 139.05,60.51 139.05,61.74 139.39,62.08 139.39,62.47 139.22,62.63 JDIM2.219
M_B_DQS#7: length 61.4
  IN2 w0.079: v1(128.54,105.14) 128.64,105.24 128.77,105.24 128.92,105.09 128.92,104.05 129.67,103.3 129.67,102.75 131.96,100.46 131.96,100.44 131.97,100.43
  IN2 w0.127: v1(145.51,59.32) 145.51,58.85 145.7,58.65 145.78,58.65 146.03,58.9 146.03,62.03 146.64,62.65 146.64,66.58 147.64,67.58 147.64,83.56 139.89,91.31 139.89,91.75 134.57,97.08 134.57,97.82 131.97,100.42 131.97,100.43 131.97,100.43
  BOTTOM w0.127: v1(145.51,59.32) 145.51,59.01 145.27,58.77 145.15,58.77 144.59,58.21 144.59,56.4 144.47,56.29 JDIM2.240 ; U35.AR22 128.1,105.28 128.27,105.14 v1(128.54,105.14)
M_B_DQS#8: length 6
  TOP w0.127: v1(106.7,60.99) 105.72,61.97 105.72,62.5 105.34,62.88 R10929.2
  BOTTOM w0.127: v1(106.7,60.99) 106.22,61.47 JDIM2.95
M_B_EVENT#: length 15.4
  TOP w0.127: v1(115.5,57.04) 115.5,56.42 R10928.2 115.51,55.89 116.91,54.49 116.91,47.78 116.01,46.88 116.01,46.5 115.63,46.12 v1(115.42,46.12) 115.12,46.12 114.69,45.69 R10921.1
  BOTTOM w0.203: v1(115.5,57.04) 115.97,56.57 JDIM2.134
M_B_ODT0_DIMM: length 57.3
  IN2 w0.079: v1(116.92,97.57) 118.22,96.26 118.22,93.29 119.13,92.38 119.36,92.38 119.48,92.26
  IN2 w0.216: v1(125.24,61.04) 125.37,61.17 125.37,62.39 125.97,62.99 125.97,68.15 126.48,68.66 126.48,69.19 128.24,70.96 128.24,73.81 128.09,73.97 127.87,73.97 127.72,73.81 127.72,71.22 127.6,71.09 127.33,71.09 127.2,71.22 127.2,79.92 122.81,84.3 122.81,88.93 119.48,92.26
  BOTTOM w0.079: U35.BA42 117.39,101.59 117.53,101.45 117.53,101.44 117.55,101.44 117.68,101.15 117.68,100.14 117.35,99.81 117.35,98 v1(116.92,97.57)
  BOTTOM w0.191: v1(125.24,61.04) 125.03,60.83 124.59,60.83 123.22,62.2 JDIM2.155
M_B_ODT1_DIMM: length 59
  IN2 w0.079: 119.75,92.48 119.59,92.64 119.17,92.64 118.47,93.34 118.47,96.78 117.03,98.22 v1(116.92,98.22)
  IN2 w0.216: 119.75,92.48 123.32,88.91 123.32,84.57 127.7,80.19 127.7,74.72 127.85,74.57 128.07,74.57 128.22,74.72 128.22,75.53 128.34,75.66 128.61,75.66 128.74,75.53 128.74,70.75 126.98,68.99 126.98,68.39 126.42,67.84 126.42,62.87 125.89,62.34 125.89,60.04 125.61,59.76 v1(125.24,59.76)
  BOTTOM w0.079: U35.AW42 117.16,102.8 117.16,102.58 117.11,102.53 117.11,102.25 117.16,102.2 117.16,101.94 117.12,101.84 117.12,101.64 117.18,101.51 117.18,101.3 117.16,101.28 117.16,101.27 117.12,101.18 117.12,100.91 117.33,100.7 117.33,100.25 116.64,99.57 116.64,99.38 116.34,99.08 116.34,98.62 116.74,98.22 v1(116.92,98.22)
  BOTTOM w0.191: v1(125.24,59.76) 125.39,59.61 125.69,59.61 125.79,59.71 125.79,62.33 125.66,62.45 124.97,62.45 124.72,62.7 JDIM2.161
M_B_PARITY: length 60.4
  IN2 w0.079: 115.81,90.95 115.32,91.44 115.32,102.48 116.16,103.32 116.16,105.58 116.67,106.09 v2(116.67,106.56)
  IN2 w0.216: 115.81,90.95 116.64,90.12 116.64,81.25 119.96,77.94 119.96,75.55 120.23,75.27 120.43,75.27 120.58,75.12 120.58,74.9 120.43,74.75 120.23,74.75 120.08,74.6 120.08,74.38 120.23,74.23 120.43,74.23 120.58,74.08 120.58,73.86 120.43,73.71 120.23,73.71 120.08,73.56 120.08,73.34 120.23,73.19 120.43,73.19 120.58,73.04 120.58,72.82 120.43,72.67 120.23,72.67 120.08,72.52 120.08,72.3 120.23,72.15 120.43,72.15 120.58,72 120.58,71.78 120.43,71.63 120.23,71.63 120.08,71.47 120.08,71.26 120.23,71.11 120.43,71.11 120.58,70.95 120.58,70.74 120.43,70.59 120.23,70.59 120.08,70.43 120.08,70.16 120.21,70.03 120.47,70.03 120.59,69.91 120.59,68.63 120.72,68.51 120.96,68.51 121.09,68.38 121.09,68.11 120.93,67.96 120.55,67.96 120.4,67.81 120.4,67.59 120.55,67.44 120.93,67.44 121.09,67.29 121.09,67.07 120.93,66.92 120.55,66.92 120.4,66.77 120.4,66.55 120.55,66.4 120.93,66.4 121.09,66.25 121.09,63.29 120.93,63.14 120.63,63.14 120.52,63.24 120.52,65.61 v1(120.59,65.68)
  BOTTOM w0.191: JDIM2.143 118.22,64.59 v1(119.31,65.68) 119.57,65.68 119.7,65.55 119.7,65.12 119.83,64.99 120.04,64.99 120.17,65.12 120.17,65.55 120.3,65.68 v1(120.59,65.68)
  BOTTOM w0.203: U35.AP43 116.26,106.15 v2(116.67,106.56)
M_B_RAS#: length 55.7
  IN2 w0.079: 116.39,91.6 116.12,91.87 116.12,94.57 v1(115.73,94.97)
  IN2 w0.216: 116.39,91.6 118.14,89.85 118.14,82.26 121.3,79.1 121.3,76.35 121.94,75.71 121.94,68.73 121.8,68.59 121.8,66.9 122.18,66.52 122.18,66.24 121.8,65.86 121.8,63.79 122,63.6 122,63.17 120.97,62.14 120.97,59.67 120.45,59.15 120.45,58.38 120.58,58.26 120.88,58.26 121.01,58.38 121.01,58.95 121.49,59.43 v1(121.49,59.59)
  BOTTOM w0.079: U35.AW44 116.16,102.89 116,102.73 115.9,102.51 115.85,102.38 115.85,102 115.63,101.78 115.63,99.77 115.34,99.48 115.34,97.78 115.02,97.45 115.02,95.68 v1(115.73,94.97)
  BOTTOM w0.191: v1(121.49,59.59) 122.47,58.61 JDIM2.152
M_B_WE#: length 56.9
  IN2 w0.216: v1(116.92,94.32) 116.92,92.61 120.57,88.97 120.57,83.28 120.72,83.13 120.72,83.11 124.36,79.47 124.36,70.28 123.93,69.84 123.93,68.42 124.14,68.21 124.14,64.65 124.01,64.52 123.62,64.52 123.5,64.39 123.5,64.1 123.62,63.97 124.01,63.97 124.14,63.84 124.14,63.58 122.8,62.25 v1(122.71,62.25)
  BOTTOM w0.079: U35.AY44 116.16,102.21 116.22,102.16 116.34,101.81 116.34,101.68 116.28,101.45 116.28,101.31 116.35,101.16 116.35,100.94 116.13,100.72 116.13,99.56 115.84,99.28 115.84,97.88 116.13,97.59 116.13,94.89 116.7,94.32 v1(116.92,94.32)
  BOTTOM w0.191: JDIM2.151 122.22,62.59 122.09,62.45 122.09,61.43 123.37,60.14 123.88,60.14 124.21,59.81 124.21,58.84 124.38,58.67 124.62,58.67 124.78,58.84 124.78,60.18 122.89,62.07 122.89,62.07 v1(122.71,62.25)
MAIND: length 258.8
  TOP w0.127: v1(46.21,33.04) 46.21,33.7 v1(46.23,33.73) 46.59,33.73 46.77,33.55 PQ3.3 ; v1(34.85,54.53) 34.45,54.12 PQ6058.3
  TOP w0.254: PR148.2 47.51,35.11 PC103.2 PQ3.3
  IN1 w0.254: v1(157.33,53.82) 157.26,53.74 157.26,51.3 157.99,50.57 157.99,47.41 154.04,43.46 154.04,42.47 149.17,37.6 142.59,37.6 141.03,36.04 115.3,36.04 114.54,35.28 112.51,35.28 112.11,35.68 84.56,35.68 80.5,31.62 77.55,31.62 73.89,27.96 63.4,27.96 60.2,24.76 54.74,24.76 52.66,26.84 49.51,26.84 46.51,29.84 46.51,32.74 v1(46.21,33.04)
  IN2 w0.254: v1(65.6,96.26) 66.65,95.22 66.65,93.16 68.7,91.1 76.16,91.1 76.81,91.76 v1(77.07,91.76)
  BOTTOM w0.127: v1(46.21,33.04) 45.52,33.04 45.43,33.13 40.21,33.13 36.29,37.05 36.29,40.85 36.94,41.5 36.94,46.61 34.72,48.83 34.72,54.02 34.85,54.16 v1(34.85,54.53)
  BOTTOM w0.203: v1(77.07,91.76) 77.07,92.15 PQ26.4
  BOTTOM w0.254: v1(157.33,53.82) 157.79,53.36 157.79,52.7 PQ6065.2 ; v1(65.6,96.26) 65.24,96.62 65.24,96.97 64.56,97.66 50.65,97.66 47.2,94.2 47.2,83.05 46.79,82.65 46.79,81.19 47.19,80.79 48.22,80.79 51.07,77.93 51.07,70.71 45.03,64.67 45.03,62.76 44.56,62.3 41.74,62.3 34.85,55.42 v1(34.85,54.53)
MAINON: length 101.4
  IN1 w0.14: v1(187.46,28.42) 187.46,28.73 185.03,31.16 185.03,31.25 184.75,31.52 183.02,31.52 182.65,31.9 177.17,31.9 172.15,26.88 172.04,26.88 171.95,26.79 170,26.79 168.45,25.24 160.27,25.24 159.22,26.28 156.94,26.28 151.68,21.02 151.19,21.02 151.06,20.89 126.16,20.89 125.97,20.7 116.71,20.7 v1(113.9,23.51)
  BOTTOM w0.127: v1(187.46,28.42) 187.46,28.26 187.93,27.79 R791.2 189.63,27.79 189.87,27.54 191.23,27.54 191.47,27.78 191.47,29.72 ; 191.47,29.72 v1(192.07,29.72) 192.75,29.72 193.3,30.27 193.3,31.82 192.74,32.38 192.74,34.61 192.93,34.8 U49.1 ; 191.47,29.72 190.77,29.72 190.43,29.38 189.89,29.38 189.41,29.86 R389.1 189.34,29.8 U45.30 ; U1006.10 114.08,23.33 v1(113.9,23.51)
MAINON_ON_G: length 265.4
  TOP w0.254: PQ4.2 v1(37.09,38.93) 37.09,38.24 37.73,37.6 37.73,35.81 37.04,35.12 v1(37.04,32.81) 37.04,32.38 PQ10.2 38.03,31.52 38.97,32.46 39.45,32.46 39.73,32.74 39.73,34.01 40.38,34.67 PQ11.3 43.85,34.67 44.29,35.11 PR151.2 PR150.1 44.8,33.26 PQ3.2 46.54,30.98 v1(45.95,30.4) ; PQ5.2 68.94,95.09 v1(68.64,95.4)
  IN1 w0.254: v1(50.98,101.8) 50.98,100.55 47.64,97.21 47.64,83.51 46.46,82.33 46.46,80.61 49.15,77.92 49.15,69.96 48.32,69.13 47.63,69.13 44.09,65.6 42.71,65.6 36.99,59.88 36.99,48.87 37.98,47.88 37.98,43.68 36.11,41.8 36.11,35.73 37.04,34.79 v1(37.04,32.81) ; v1(157.31,57.93) 157.33,57.93 157.66,57.6 157.66,54.22 157.92,53.97 157.92,52.17 158.39,51.69 158.39,47.25 154.44,43.29 154.44,42.31 149.33,37.21 142.83,37.21 141.2,35.57 121.82,35.57 121.13,34.89 112.35,34.89 111.95,35.29 84.82,35.29 80.69,31.15 77.83,31.15 74.22,27.55 63.57,27.55 60.37,24.35 54.57,24.35 52.51,26.41 49.38,26.41 46.13,29.66 46.11,29.66 46.11,29.69 45.95,29.84 v1(45.95,30.4) ; v1(53.07,102.46) 55.96,99.56 66.55,99.56 68.64,97.48 v1(68.64,95.4)
  IN2 w0.254: v1(50.98,101.8) 52.41,101.8 v1(53.07,102.46)
  BOTTOM w0.203: PQ6066.2 156.77,57.4 v1(157.31,57.93)
MAINON_R: length 268.4
  TOP w0.127: v1(49.05,15.79) 49.05,16.28 50.83,18.05 50.83,26.05 48.7,28.19 48.7,29.23 48.47,29.46 46.08,29.46 44.9,30.64 42.49,30.64 PR147.1 41.81,31.32 PQ11.2 ; v1(79.08,19.43) 78.68,19.82 74.52,19.82 72.22,17.52 72.22,17.19 71.86,16.83 67.8,16.83 66.48,18.15 v1(66.48,19.01)
  TOP w0.203: PR37.1 48.32,46.64 48.65,46.31 v1(48.83,46.31) 53.33,50.82 60.31,50.82 v1(61.86,52.37) 62.09,52.61 PR6294.2 ; PR257.2 41.23,52.84 40.77,53.29 v1(40.77,54.11)
  TOP w0.254: v1(40.34,33.7) 40.34,33.52 41.18,32.68 PQ11.2
  IN2 w0.14: v1(49.05,15.79) 50.4,15.79 51.92,17.32 61.78,17.32 61.91,17.44 64.83,17.44 66.4,19.01 v1(66.48,19.01) ; v1(79.08,19.43) 79.3,19.2 81.6,19.2 90.08,27.68 102.59,27.68 108.18,22.09 108.18,20.23 108.18,19.2 110.83,16.56 113.01,16.56 113.85,17.39 124.95,17.39 127.62,20.06 135.62,20.06 135.85,20.29 138.82,20.29 140.62,18.49 146.49,18.49 147.45,17.52 149.99,17.52 150.91,18.43 158.44,18.43 163.93,23.92 170.54,23.92 171.63,25.01 171.92,25.01 174.01,27.1 176.98,27.1 178.76,28.87 186.37,28.87 v1(186.8,28.44)
  BOTTOM w0.127: v1(66.48,19.01) 66.99,19.01 67.25,19.28 PR6291.2 ; U49.4 195.98,36.1 196.2,35.88 196.2,31.87 193.15,28.82 193.15,27.85 191.94,26.64 189.82,26.64 189.45,27.01 R791.1 188.23,27.01 v1(186.8,28.44)
  BOTTOM w0.254: 40.77,54.14 41.77,53.14 41.77,48.49 43.59,46.67 48.28,46.67 48.63,46.31 v1(48.83,46.31) ; 40.77,54.14 v1(40.77,54.11) ; 40.77,54.14 40.39,54.52 35.66,54.52 35.03,53.89 35.03,48.97 38.16,45.84 38.16,42.16 36.61,40.61 36.61,37.18 40.09,33.7 v1(40.34,33.7)
MBCLK: length 314.1
  TOP w0.127: PR7.2 152.85,170.15 153.24,170.15 153.6,170.5 154.04,170.5 PD2.1 ; PR7.2 151.97,171.02 151.97,172.4 151.48,172.89 150.82,172.89 150.63,173.08 150.63,174.53 150.9,174.8 151.34,174.8 151.69,175.15 151.69,177.3 151.24,177.76 151.24,178.52 149.84,179.92 149.84,182.2 150.19,182.54 150.86,182.54 PR178.1 ; PR7.2 152.79,169.06 PC9.1 152.59,169.04 152.3,168.75 152.3,167.86 153.02,167.15 154.12,167.15 155.39,165.89 155.39,165.68 155.39,165.68 155.39,165.52 v1(155.62,165.29) ; v1(188.6,45.94) 188.39,45.73 188.17,45.73 186.12,43.68 182.56,43.68 182.27,43.97 179.85,43.97 179.47,44.34 179.47,44.58 179.21,44.84 178.65,44.84 v1(178.38,44.57)
  IN2 w0.14: v1(188.6,45.94) 188.74,45.94 190.79,43.89 191.29,43.89 193.41,41.76 199.36,41.76 201.15,39.97 206.53,39.97 208.41,41.84 208.98,41.84 214.31,47.16 214.31,50.39 213.72,50.97 213.72,54.75 212.86,55.61 212.86,58.76 213.49,59.38 213.49,60.38 215.24,62.13 215.24,64.68 216.68,66.12 216.68,67.65 217.34,68.31 217.34,69.53 219.22,71.41 219.22,85.7 214.46,90.46 214.46,98.65 215.51,99.7 219.92,99.7 222.95,102.72 222.95,104.91 226.74,108.71 226.74,112.47 226.28,112.93 226.28,158.2 223.25,161.23 223.25,167.22 230.41,174.38 230.41,185.69 227.92,188.18 213.02,188.18 210.15,185.31 207.47,182.63 205.4,182.63 204.69,183.34 201.04,183.34 197.35,179.65 194.24,179.65 193.94,179.35 193.53,179.35 189.17,174.99 181.58,174.99 179.86,173.26 160.73,173.26 155.33,167.86 155.33,165.57 v1(155.62,165.29)
  BOTTOM w0.127: U45.110 v1(178.38,44.57) 178.38,45.13 R731.1
MBDATA: length 315.8
  TOP w0.127: PR177.1 150.63,182.82 150.07,182.82 149.56,182.31 149.56,179.8 150.96,178.4 150.96,177.64 151.42,177.18 151.42,175.27 151.22,175.08 150.78,175.08 150.35,174.65 150.35,172.97 150.7,172.61 151.36,172.61 151.69,172.28 151.69,170.98 PD1.1 150.8,170.67 150.35,170.23 PR6.2 PC8.1 151.7,169.28 152.03,168.96 152.03,167.75 152.9,166.87 154.01,166.87 155.11,165.77 155.11,165.46 v1(154.93,165.29) ; v1(188.6,45.28) 188.44,45.45 188.28,45.45 186.24,43.4 182.44,43.4 182.15,43.69 179.73,43.69 v1(179.03,44.39)
  IN2 w0.14: v1(188.6,45.28) 188.98,45.28 190.67,43.59 191.17,43.59 193.29,41.47 199.24,41.47 201.03,39.68 206.65,39.68 208.53,41.55 209.1,41.55 214.6,47.04 214.6,50.51 214.01,51.09 214.01,54.87 213.16,55.73 213.16,58.63 213.78,59.26 213.78,60.25 215.53,62.01 215.53,64.56 216.97,66 216.97,67.53 217.63,68.19 217.63,69.41 219.51,71.29 219.51,85.82 214.75,90.58 214.75,98.53 215.63,99.41 220.04,99.41 223.24,102.6 223.24,104.79 227.03,108.59 227.03,112.59 226.57,113.05 226.57,158.32 223.54,161.35 223.54,167.09 230.7,174.26 230.7,185.81 228.04,188.48 212.9,188.48 210.03,185.6 207.35,182.93 205.52,182.93 204.81,183.64 200.92,183.64 197.22,179.94 194.12,179.94 193.82,179.64 193.41,179.64 189.05,175.28 181.46,175.28 179.74,173.55 160.61,173.55 155.04,167.98 155.04,165.39 v1(154.93,165.29)
  BOTTOM w0.127: R732.1 179.2,44.57 v1(179.03,44.39) 179.03,44.27 178.78,44.02 U45.111
MDI_0+: length 13.3
  TOP w0.102: U15.1 40.1,76.36 40.23,76.48 40.23,80.09 39.8,80.53 39.46,80.53 v1(39.25,80.74)
  BOTTOM w0.102: U42.11 34.52,78.4 34.7,78.58 34.7,79.45 35.74,80.49 39,80.49 v1(39.25,80.74)
MDI_0-: length 13.3
  TOP w0.102: v1(39.27,79.98) 39.43,80.13 39.73,80.13 39.93,79.93 39.93,76.6 39.7,76.37 U15.2
  BOTTOM w0.102: U42.12 33.93,77.4 34.15,77.63 34.15,78.02 34.24,78.11 34.64,78.11 34.99,78.46 34.99,79.32 35.87,80.19 39.06,80.19 v1(39.27,79.98)
MDI_1+: length 12.9
  TOP w0.102: v1(38.01,81.88) 37.69,81.55 37.69,81.04 38.83,79.9 38.83,76.54 38.9,76.46 U15.4
  BOTTOM w0.102: v1(38.01,81.88) 38,81.88 37.69,82.19 37.69,82.53 37.39,82.82 36.35,82.82 34.92,81.4 U42.8
MDI_1-: length 12.9
  TOP w0.102: v1(37.15,81.88) 37.39,81.63 37.39,80.92 38.54,79.78 38.54,76.47 38.5,76.44 U15.5
  BOTTOM w0.102: U42.9 34.08,80.4 34.18,80.5 34.18,80.98 34.31,81.11 35.04,81.11 36.47,82.53 37.27,82.53 37.39,82.41 37.39,82.12 v1(37.15,81.88)
MDI_2+: length 13
  TOP w0.102: v1(36.62,83.71) 36.44,83.53 36.44,81.14 38.02,79.57 38.02,76.51 38.1,76.42 U15.6
  BOTTOM w0.102: v1(36.62,83.71) 36.62,83.75 36.42,83.95 36.42,84.31 36.09,84.64 35.05,84.64 34.81,84.4 U42.5
MDI_2-: length 13
  TOP w0.102: v1(35.97,83.71) 36.15,83.53 36.15,81.02 37.73,79.45 37.73,76.55 37.7,76.53 U15.7
  BOTTOM w0.102: U42.6 33.96,83.4 34.11,83.55 34.11,83.98 34.24,84.11 34.93,84.11 35.17,84.35 35.97,84.35 36.12,84.19 36.12,83.87 v1(35.97,83.71)
MDI_3+: length 14.4
  TOP w0.102: U15.9 36.9,76.43 36.86,76.47 36.86,76.91 36.54,77.23 36.54,79.26 35.27,80.53 35.27,85.26 v1(35.56,85.54)
  BOTTOM w0.102: v1(35.56,85.54) 35.27,85.82 35.27,86.81 34.68,87.4 U42.2
MDI_3-: length 14.5
  TOP w0.102: v1(34.7,85.54) 34.98,85.26 34.98,80.41 36.25,79.14 36.25,77.11 36.57,76.79 36.57,76.47 36.5,76.41 U15.10
  BOTTOM w0.102: v1(34.7,85.54) 34.98,85.83 34.98,86.68 34.56,87.11 34.26,87.11 34.09,86.94 34.09,86.58 33.91,86.4 U42.3
ME_WR#: length 95.9
  IN1 w0.14: v1(171.07,44.38) 171.07,45.16 169.58,46.65 169.58,48.43 170.57,49.42 170.57,51.96 170.28,52.24 170.28,53 169.95,53.33 163.07,53.33 161.58,54.82 161.58,59.75 163.15,61.32 163.15,63.95 162.74,64.36 161.8,64.36 160.1,66.06 160.1,70.66 160.69,71.24 160.69,73.86 160.99,74.16 160.99,76.18 160.2,76.97 v1(160.2,77.03)
  BOTTOM w0.127: U45.109 177.98,41.78 177.51,41.31 175.41,41.31 175.32,41.4 175.32,41.4 175.11,41.6 174.6,41.6 174.3,41.3 174.3,41.02 174.05,40.76 173.39,40.76 173.26,40.89 173.26,41.18 172.98,41.46 172.98,41.86 172.73,42.11 172.73,42.99 171.34,44.38 v1(171.07,44.38) ; R737.1 130.61,94.63 131.12,94.13 131.12,91.05 145.16,77.01 152.61,77.01 152.63,77.03 152.68,77.03 153.96,78.3 v1(156.94,78.3) 158.93,78.3 v1(160.2,77.03)
MIC2-VREFO: length 16.8
  IN2 w0.381: v1(204.64,16.55) 205.19,17.1 205.19,20.68 204.53,21.34 204.53,25.85 v1(204.31,26.07)
  BOTTOM w0.203: 205,26.76 U23.29
  BOTTOM w0.381: v1(204.64,16.55) 204.64,16.36 v1(205.03,15.97) 205.1,15.9 R407.1 R424.1 ; v1(204.31,26.07) 205,26.76
MOD_EN_5V: length 16.4
  TOP w0.127: v1(222.28,106.98) 222.28,107.06 223.6,108.38 v1(223.78,108.38) C752.1 225.2,109.67 R686.1
  BOTTOM w0.127: Q34.3 221.21,102.5 221.9,103.19 221.9,106.6 v1(222.28,106.98) 222.05,107.21 222.05,110.66 223.36,111.97 Q37.6
MPHY_EXT_PWR: length 33.1
  TOP w0.076: 139.2,108.48 139.15,108.42 136.3,108.42 135.95,108.78 135.26,108.78 v2(135.16,108.88)
  TOP w0.127: R195.2 157.89,109.14 157.38,108.63 154.59,108.63 154.34,108.38 v1(154.34,108.2) 154.34,107.41 153.37,106.45 152.96,106.45 152.71,106.2 152.71,104.79 152.08,104.16 147.68,104.16 146.8,105.04 146.66,105.18 145.09,105.18 144.68,104.77 144.14,104.77 143.71,105.2 142.34,105.2 140.26,107.28 140.26,108.1 139.88,108.48 139.2,108.48
  BOTTOM w0.102: U35.AM10 135.41,108 135.16,108.25 v2(135.16,108.88)
MULTISTRAP_REF_GND: length 9.3
  BOTTOM w0.127: R4344.2 R4345.2 190.36,111.83 190.36,112.48 190.49,112.61 190.49,112.98 190.33,113.14 v1(190.33,113.43)
  BOTTOM w0.14: v1(190.33,113.43) 190.33,115.06 189.46,115.92 189.46,118.6 U3002.J1
MX0: length 50
  IN1 w0.14: v1(178.19,15.82) 178.19,17.19 v1(178.77,17.85) 178.77,18.24 177.13,19.88 175.32,19.88 174.22,20.97 174.22,23.03 175.88,24.68 175.88,26.03 v1(175.72,26.18)
  BOTTOM w0.127: 197.42,23.68 198.17,22.94 v1(198.5,22.94) 199.4,22.04 199.83,22.04 199.96,21.91 CN2019.1 199.96,20.4 197.86,18.3 179.22,18.3 v1(178.77,17.85) ; 197.42,23.68 198.46,24.72 198.46,26.36 196.79,28.03 RP1.2 ; 197.42,23.68 C4809.1 ; CN20.1 178.42,15.58 v1(178.19,15.82) ; v1(175.72,26.18) 175.58,26.32 U45.58
MX1: length 47.5
  IN1 w0.14: v1(175.35,25.65) 175.35,24.61 173.89,23.16 173.89,20.9 175.19,19.6 176.82,19.6 178.11,18.31 v1(178.11,17.85) 177.43,17.16 v1(177.43,15.84)
  BOTTOM w0.127: 196.46,23.68 197.24,22.91 197.84,22.91 198.96,21.79 CN2019.2 198.96,20.26 197.25,18.55 178.81,18.55 v1(178.11,17.85) ; 196.46,23.68 196.96,24.18 196.96,24.71 197.54,25.29 197.54,25.84 196.62,26.76 RP1.4 ; 196.46,23.68 C4810.1 ; v1(177.43,15.84) 177.43,15.74 177.42,15.74 CN20.2 ; v1(175.35,25.65) 175.27,25.72 175.27,26.24 175.18,26.33 U45.59
