# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_UTIL: length 10.2
  IN1 w0.14: v1(110.52,130.75) 110.42,130.65 110.42,129.28 110.93,128.77 110.93,126.66 v1(110.9,126.64)
  BOTTOM w0.076: 111.23,124.43 111.65,124.01 111.65,123.33 U35.B52
  BOTTOM w0.127: v1(110.52,130.75) 110.52,130.8 110.25,131.07 R553.2 R546.2 ; v1(110.9,126.64) 110.93,126.64 111.05,126.51 111.05,124.61 111.23,124.43
DPWROK_R: length 9.2
  BOTTOM w0.127: U35.BB20 129.85,100.75 129.89,100.71 129.89,100.23 132.34,97.78 132.34,97.1 133.28,96.16 134.17,96.16 134.5,95.83 134.5,94.94 134.69,94.75 R661.1
EC_FPBACK#: length 368.7
  TOP w0.127: Q4.2 109.73,159.18 108.74,158.19 108.74,155.7 107.8,154.76 107.8,153.77 106.25,152.22 v1(106.25,151.84)
  IN1 w0.14: v1(31.34,16.09) 29.91,17.52 28.43,17.52 27.36,18.59 27.36,23.08 27.95,23.67 27.95,27.25 31.03,30.33 31.03,35.14 32.98,37.08 32.98,51.29 32.45,51.82 32.45,52.74 24.52,60.68 24.52,61.27 25.22,61.97 25.22,64.79 29.42,68.99 29.42,69.45 31.83,71.86 33.67,71.86 34.78,72.97 34.78,75.2 34.4,75.58 34.4,77.1 36,78.7 36,82.35 36.71,83.06 37.01,83.06 37.62,83.66 37.62,85.42 40.44,88.25 40.44,109.49 49.41,118.46 61.14,118.46 63.39,120.71 69.4,120.71 70.6,121.9 72.59,121.9 81.35,130.66 81.8,130.97 83.17,131.46 87.23,134.08 89.36,134.08 90.05,134.77 90.05,136.09 90.96,137 91.62,137 103.08,148.46 103.08,150.57 104.35,151.84 v1(106.25,151.84) ; v1(174.86,38.07) 174.81,38.07 174.1,37.36 174.1,36.6 173.2,35.69 172.16,35.69 170.2,33.73 170.17,33.73 168.9,32.46 167.67,32.46 167.19,32.94 164.86,32.94 164.35,32.43 155.32,32.43 146.04,23.16 140.24,23.16 139.11,24.29 124.45,24.29 122.31,26.44 119.77,26.44 118.32,24.99 115.42,24.99 113.9,26.51 107.36,26.51 104.76,29.1 88.6,29.1 80.83,21.33 71.99,21.33 67.5,16.84 65.33,16.84 64.44,17.73 44.81,17.73 43.67,18.87 v1(41.97,18.87)
  BOTTOM w0.127: v1(31.34,16.09) 31.63,16.38 v1(33.43,16.38) 39.48,16.38 v1(41.97,18.87) ; v1(174.86,38.07) 174.34,37.54 172.71,37.54 172.56,37.4 U45.86
EC_GND: length 41.1
  TOP w0.508: v1(188.55,43.12) 188.31,43.12 186.93,41.75 185.95,41.75 185.38,42.32 181.99,42.32 181.73,42.59 178.97,42.59 177.6,41.22 176.6,41.22 176.02,41.8 v1(175.85,41.8) 175.29,42.36 172.8,42.36 v1(172.17,41.73) 172.09,41.73 171.53,41.17 170.72,41.17 169.73,40.18 169.73,39.29 v1(170.36,38.65)
  IN2 w0.381: v1(175.85,41.8) 175.6,42.06 v1(175.6,44.52)
  BOTTOM w0.178: v1(175.6,44.52) 175.6,44.27 175.98,43.88 U45.104
  BOTTOM w0.203: U45.27 188.43,31 v1(188.6,30.83) ; v1(170.36,38.65) 170.36,39.03 170.73,39.4 U45.91 ; U45.49 179.18,29.26 v1(179.58,29.66) ; U45.1 188.07,41.4 188.55,41.88 v1(188.55,43.12)
  BOTTOM w0.381: L11.1 166.09,28.46 166.35,28.72 v1(166.35,28.75)
  BOTTOM w0.508: R784.1 189.88,43.2 188.63,43.2 v1(188.55,43.12) ; R782.1 188.65,30.88 v1(188.6,30.83) ; v1(169.68,35.53) 169.52,35.69 R783.1 ; R785.1 175.11,45 v1(175.6,44.52)
EC_ODD_EJ#: length 129.4
  TOP w0.127: CN9.11 231.28,108.76 v1(230.31,107.79) R209.1 230.86,106.96 232.66,105.16 232.66,91.08 232.02,90.44 232.02,89.62 221.49,79.09 221.49,69.59 221.88,69.21 221.88,61.35 221.52,60.99 219.11,60.99 218.21,60.09 215.78,60.09 214.1,58.41 214.1,53.61 210.1,49.62 v1(208.78,49.62)
  IN2 w0.14: v1(181.84,40.94) 181.84,41.27 184.63,44.05 184.63,50.46 188.9,54.73 192.18,54.73 196.71,50.2 201.89,50.2 203.28,48.81 204.65,48.81 205.09,49.25 207.71,49.25 207.87,49.09 208.25,49.09 208.41,49.25 v1(208.78,49.62)
  BOTTOM w0.127: v1(181.84,40.94) 181.84,40.52 180.93,39.61 180.08,39.61 179.66,40.02 173.95,40.02 173.73,40.24 173.05,40.24 172.75,40.54 172.75,40.97 172.47,41.25 172.47,41.65 171.9,42.22 171.9,42.66 171.24,43.31 R746.1
EC_ODD_EJ#_R: length 4.9
  BOTTOM w0.127: v1(169.22,42.54) 170,42.54 C799.1 R746.2 170.9,42.36 170.34,41.8 170.34,40.84 170.58,40.6 U45.94
EC_PECR_R: length 10.4
  IN1 w0.14: v1(179.84,41.7) 179.84,42.11 181.77,44.04 181.77,44.93 180.65,46.04 180.65,47.19 v1(180.57,47.26)
  BOTTOM w0.127: R738.1 179.91,47.93 v1(180.57,47.26) ; U45.117 181.18,42.21 180.68,41.7 v1(179.84,41.7)
EC_PWROK: length 133.2
  TOP w0.127: v1(183.52,33.95) v1(185.38,33.95) 185.59,33.95 186.02,34.38 186.02,36.15 R130.2 184.99,36.71 184.23,35.96 U8.2 182.94,35.96 182.76,36.14 182.76,36.8 182.43,37.13 182.05,37.13 181.96,37.22 R560.2 182.01,37.92 182.99,37.92 v1(183.57,38.5)
  IN1 w0.14: v1(183.57,38.5) 184.03,38.04 184.82,38.04 185.69,38.91 185.69,46.22 184.71,47.19 184.71,49.55 184.51,49.75 v1(183.44,49.75)
  IN2 w0.14: v1(151.44,120.29) 152.38,121.23 156.04,121.23 157.04,120.23 158.82,120.23 163.37,115.68 163.92,115.68 167.68,111.92 167.68,111.59 168.55,110.73 168.88,110.73 172.33,107.27 172.33,101.4 172.93,100.8 172.93,91.27 173.27,90.94 173.27,89.69 172.9,89.33 172.9,88.82 173.7,88.02 173.7,82.32 172.88,81.5 172.55,81.5 172.27,81.22 172.27,80.59 172.68,80.17 172.68,69.66 176.35,66 176.35,65.62 177.58,64.38 179.67,62.29 179.67,61.4 183.44,57.63 v1(183.44,49.75)
  BOTTOM w0.127: R131.2 148.88,123.97 151.77,121.08 151.77,120.62 v1(151.44,120.29) ; U45.33 185.58,28.62 185.15,29.05 183.19,29.05 182.56,29.69 182.56,32.63 183.52,33.59 v1(183.52,33.95)
EC_PWROK_R: length 8.7
  BOTTOM w0.127: U35.BA20 129.84,101.74 129.55,101.44 129.55,100.76 129.68,100.63 129.68,100.15 132.14,97.69 132.14,96.79 132.9,96.03 R643.2 R647.1
EC_RCIN#: length 14
  BOTTOM w0.076: 133.19,100.71 133.06,100.84 133.06,101.23 133.08,101.26 133.11,101.34 133.11,101.46 133.05,101.68 133.05,101.82 133.1,101.98 133.1,102.43 133.49,102.82 U35.AW13
  BOTTOM w0.079: 133.19,99.84 133.19,100.71
  BOTTOM w0.127: R652.2 138.99,94.14 138.99,95.27 139.5,95.78 R639.2 139.37,95.79 137.98,97.17 135.85,97.17 133.19,99.84
EC_TYPEC_CHG_HI: length 304.2
  TOP w0.127: v1(37.65,111.83) 37.73,111.91 37.73,113.48 37.39,113.81 R11280.2
  IN2 w0.14: v1(188.47,40.43) 189.11,39.8 189.11,39.09 188.44,38.42 187.83,38.42 185.22,35.82 179.55,35.82 179.13,35.4 178.7,35.4 178.17,34.86 176.79,34.86 176.4,35.25 175.64,35.25 175.56,35.17 173.19,35.17 171.39,33.37 171.39,32.84 170.01,31.47 169.25,31.47 168.24,30.45 167.62,30.45 166.72,29.54 159.4,29.54 154.15,24.29 151.9,24.29 151.48,23.87 142.95,23.87 142.36,23.28 141.98,23.28 141.71,23.55 141.71,23.81 141.37,24.15 125.36,24.15 123.07,21.86 113.39,21.86 110.93,24.33 110.93,25.04 109.88,26.09 108.92,26.09 108.34,26.67 108.34,28.12 105.98,30.47 88.91,30.47 81.4,22.97 78.14,22.97 76.7,21.53 72.97,21.53 69.88,18.45 69.88,16.85 66.69,13.66 61.12,13.66 59.09,11.63 54.96,11.63 54,12.59 45.24,12.59 44.08,13.76 42.91,13.76 42.67,13.52 36.07,13.52 35.34,14.25 35.34,16.18 27.5,24.01 27.5,26.9 26.54,27.86 24.11,27.86 23.22,28.75 23.22,35.5 22.79,35.94 22.79,37.94 20.49,40.24 19.91,40.24 18.69,41.46 18.69,42.83 19.86,44 19.86,45.27 16.16,48.97 16.16,57.8 17.47,59.11 17.47,62.21 18.6,63.34 21.77,63.34 23.9,65.47 24.94,65.47 27.58,68.11 27.58,69.74 31.45,73.61 31.45,74.63 33.55,76.72 33.88,77.06 33.88,96.93 33.86,96.96 33.86,97.34 33.88,97.37 33.88,99.11 v1(33.08,99.92)
  BOTTOM w0.102: 187.51,40.6 U45.3
  BOTTOM w0.127: v1(33.08,99.92) 33.08,103.52 34.63,105.07 v1(34.63,107.84) 37.65,110.87 v1(37.65,111.83) ; v1(188.47,40.43) 188.31,40.6 187.51,40.6
EC_TYPEC_EN: length 271.4
  TOP w0.127: R11153.1 v1(38.41,111.14)
  IN1 w0.14: v1(30.59,16.15) 29.67,17.06 28.5,17.06 27.08,18.48 27.08,23.2 27.67,23.79 27.67,27.37 30.75,30.45 30.75,35.39 32.65,37.28 32.65,51.23 32.17,51.71 32.17,52.54 24.24,60.47 24.24,61.38 24.94,62.09 24.94,64.91 29.14,69.1 29.14,69.57 31.71,72.14 33.55,72.14 34.48,73.06 34.48,75.11 34.12,75.47 34.12,77.21 35.03,78.12 35.03,79.33 35.5,79.81 35.5,83.98 36.2,84.68 36.48,84.68 37.65,85.85 37.65,89.38 36.61,90.42 36.61,92.37 39.73,95.5 39.73,109.82 v1(38.41,111.14) ; v1(40.86,20.15) 42.42,21.71 45.9,21.71 48.77,18.85 64.9,18.85 65.79,17.96 67.04,17.96 71.53,22.45 80.24,22.45 88.02,30.22 105.23,30.22 106.8,28.65 109.86,28.65 110.49,28.01 114.13,28.01 114.66,28.54 122.45,28.54 125.29,25.7 146.59,25.7 154.72,33.83 163.73,33.83 164.28,34.37 167.15,34.37 167.47,34.69 168.04,34.69 169.56,36.21 v1(170.34,36.21)
  BOTTOM w0.127: U45.80 170.67,35 170.48,35.19 170.48,35.92 170.34,36.06 v1(170.34,36.21) ; v1(30.59,16.15) 31.27,16.83 38.61,16.83 41.18,19.4 41.18,19.83 v1(40.86,20.15)
EC_TYPEC_EN_R: length 5.4
  TOP w0.127: U28.6 34.45,109.85 v1(34.93,110.33) 35.24,110.64 36.45,110.64 R11153.2 36.95,111.82 37.24,112.11 R11278.1
ECAGND:
  vias: v1(167.85,28.67) v1(168.51,28.67) v1(170.36,33.27) v1(170.39,31.92)
EDP_AUX#_C: length 5.6
  BOTTOM w0.114: CN5.22 122.99,171.85 123.24,171.85 123.88,171.21 123.88,170.19 R450.1 124.13,169.81 123.75,169.44 123.75,169.3 R449.2 124.13,167.93 C2.2
EDP_AUX_C: length 5.6
  BOTTOM w0.114: C4.2 123.12,168.87 R448.2 123.5,169.25 123.5,169.59 R447.1 123.65,170.39 123.65,171.14 123.19,171.6 122.53,171.6 CN5.23
EDP_AUXN: length 70.4
  IN2 w0.114: v2(114.84,121.28) 115.08,121.04 115.23,121.04 115.47,121.27 115.67,121.27 115.77,121.37 115.77,122.28 114.73,123.32 114.73,125.48 115.07,125.83 115.56,125.83 v1(115.77,126.03) ; v1(119.72,167.23) 119.56,167.38 118.55,167.38 114.23,163.06 114.23,160.06 113.16,158.99 113.16,157.06 112.66,156.56 112.66,156 112.66,155.99 112.66,155.97 113.19,155.44 113.19,154.63 v1(112.68,154.12)
  BOTTOM w0.076: v1(115.77,126.03) 115.54,126.26 115.54,128.86 115.92,129.24 115.92,129.77 115.94,129.79 115.94,129.81
  BOTTOM w0.079: v2(114.84,121.28) 114.92,121.36 115.22,121.36 115.29,121.28 U35.E45
  BOTTOM w0.114: 115.94,129.81 115.94,130.54 113.94,132.55 113.94,134.58 112.71,135.81 106.66,135.81 105.91,136.56 105.91,144 112.58,150.67 112.58,152.52 112.12,152.98 112.12,154.22 112.27,154.38 112.43,154.38 v1(112.68,154.12) ; C2.1 123.74,166.74 123.74,166.65 123.74,166.57 123.46,166.3 121.2,166.3 120.08,167.42 119.91,167.42 v1(119.72,167.23)
EDP_AUXP: length 70.4
  IN2 w0.114: v1(112.68,154.78) 112.97,155.07 112.97,155.35 112.45,155.88 112.45,155.91 112.44,155.91 112.44,156.65 112.95,157.15 112.95,159.08 114.01,160.15 114.01,163.15 118.46,167.6 119.45,167.6 v1(119.74,167.89) ; v2(114.84,120.64) 115.02,120.82 115.32,120.82 115.55,121.05 115.76,121.05 115.98,121.28 115.98,122.37 114.94,123.41 114.94,125.39 115.16,125.61 115.41,125.61 v1(115.65,125.37)
  BOTTOM w0.076: 115.73,129.81 115.73,129.79 115.75,129.77 115.75,129.31 115.37,128.92 115.37,125.65 v1(115.65,125.37)
  BOTTOM w0.079: U35.F45 115.14,120.34 v2(114.84,120.64)
  BOTTOM w0.114: v1(112.68,154.78) 112.49,154.59 112.19,154.59 111.91,154.31 111.91,152.89 112.36,152.43 112.36,150.76 105.7,144.09 105.7,136.47 106.57,135.59 112.62,135.59 113.72,134.49 113.72,132.46 115.73,130.45 115.73,129.81 ; C4.1 123.52,166.74 123.52,166.66 123.37,166.52 121.29,166.52 120.17,167.63 120.05,167.63 119.79,167.89 v1(119.74,167.89)
EDP_HPD: length 117
  TOP w0.127: v1(147.02,120.9) 147.11,120.98 R563.2 148.79,120.98 v1(148.95,120.82) ; R457.1 C804.2 122.24,173.61 v1(122.43,173.81)
  IN1 w0.076: 137.5,117.77 137.45,117.73 136.47,117.73 135.94,117.19 v2(135.81,117.19)
  IN1 w0.14: 137.5,117.77 137.75,118.03 138.64,118.03 139.63,119.02 147.58,119.02 148.09,119.53 148.09,119.98 148.95,120.85 v1(148.95,120.82) 149.03,120.9 149.03,121.91 147.99,122.96 147.99,128.19 138.69,137.48 127.49,137.48 125.36,139.62 125.36,141.73 122.74,144.34 118.32,144.34 114.59,148.08 114.59,156.7 114.23,157.06 114.23,158.83 114.84,159.44 114.84,162.96 117.53,165.65 124.64,165.65 127.29,168.29 131.07,168.29 131.73,168.96 131.73,170.12 130.87,170.99 127.26,170.99 126.45,171.8 124.44,171.8 v1(122.43,173.81)
  BOTTOM w0.127: U35.L10 135.48,117.52 v2(135.81,117.19)
EDP_HPD_R: length 2.8
  TOP w0.127: v1(121.44,171.09) 121.46,171.11 R457.2 121.23,172.08 v1(120.63,172.08)
  BOTTOM w0.127: v1(120.63,172.08) 120.64,172.08 CN5.25
EDP_RCOMP: length 7.7
  TOP w0.508: R154.1 117.62,120.6 v1(117.6,120.63)
  IN1 w0.508: v1(117.6,120.63) 116.63,120.63 115.3,121.97 112.28,121.97 v2(111.86,121.54)
  BOTTOM w0.305: v2(111.86,121.54) 111.64,121.32 U35.E52
EDP_TXN0: length 74.4
  IN2 w0.114: v1(127.51,172.49) 127.08,172.49 126.36,173.21 122.57,173.21 118.8,169.44 118.52,169.44 112.67,163.58 112.67,160.7 111.09,159.13 111.09,156.57 110.62,156.1 110.62,155.21 110.54,155.13 110.38,155.13 v1(110.17,155.34)
  BOTTOM w0.076: 113.65,125.44 113.66,125.42 113.66,125.35 113.81,125.2 113.81,124.54 113.52,124.25 113.52,124.25 113.43,124.16 113.43,123.56 113.43,123.56 113.45,123.49 113.45,123.28 113.42,123.2 113.42,122.95 113.49,122.77 113.71,122.55 113.85,122.41 U35.C47
  BOTTOM w0.114: v1(127.51,172.49) 127.14,172.49 126.82,172.8 C12.1 ; 113.65,125.44 113.65,128.66 112.65,129.67 112.63,129.67 112.42,129.88 112.42,129.99 111.57,130.84 109.57,132.86 105.08,132.86 102.74,135.21 102.74,145.35 107.35,149.96 107.35,154.05 108.39,155.09 109.91,155.09 v1(110.17,155.34)
EDP_TXN0_C: length 2.1
  BOTTOM w0.114: CN5.16 125.56,173.52 C12.2
EDP_TXN1: length 75.9
  IN2 w0.114: v1(126.18,170.98) 125.77,170.98 124.39,172.36 122.81,172.36 119.03,168.57 118.65,168.57 113.3,163.23 113.3,160.44 112.24,159.37 112.24,157.45 111.73,156.94 111.73,155.2 111.97,154.96 111.97,152.06 111.87,151.96 111.49,151.96 111.39,152.06 111.39,152.98 111.19,153.17 110.53,153.17 v1(110.39,153.31)
  BOTTOM w0.076: 115.16,125.21 115.16,125.19 115.14,125.17 115.14,124.38 115.44,124.09 115.44,123.64 115.38,123.47 115.38,123.33 115.44,123.1 115.44,122.97 115.36,122.79 115.36,122.36 115.09,122.09 U35.D46
  BOTTOM w0.114: C8.1 125.55,171.24 125.81,170.98 v1(126.18,170.98) ; v1(110.39,153.31) 110.61,153.09 110.99,153.09 111.3,152.79 111.3,152.05 109.96,150.72 109.96,149.29 105.16,144.49 105.16,136.21 106.34,135.03 112.19,135.03 113.23,133.99 113.23,132.27 115.16,130.34 115.16,125.21
EDP_TXN1_C: length 2.1
  BOTTOM w0.114: CN5.19 124.03,172.93 124.03,172.74 124.52,172.25 C8.2
EDP_TXN2: length 78.8
  IN2 w0.114: v1(130.17,175.01) 129.76,175.01 129.62,175.16 127.04,175.16 126.62,174.73 123.41,174.73 122.93,175.22 119.98,175.22 116.59,171.83 116.59,171.09 112.93,167.43 111.39,164.23 111.39,163.06 110.9,162.58 110.72,162.41 110.3,161.99 110.23,161.88 110.11,161.69 109.9,161.34 108.34,157.75 108.33,157.74 108.11,157.22 108.07,156.91 108.06,156.78 108.07,156.4 108.07,152.69 108.76,152 109.54,152 v1(109.76,151.78)
  BOTTOM w0.114: U35.A45 114.84,123.57 114.71,123.57 114.66,123.62 114.66,124 114.74,124.07 114.74,129.85 112.8,131.78 110.21,134.37 105.91,134.37 104.36,135.92 104.36,144.71 109.23,149.57 109.23,151.91 109.34,152.03 109.52,152.03 v1(109.76,151.78) ; C3225.1 129.62,175.31 129.91,175.01 v1(130.17,175.01)
EDP_TXN2_C: length 2.1
  BOTTOM w0.114: CN5.7 128.31,177.14 128.31,176.74 128.73,176.32 C3225.2
EDP_TXN3: length 82.6
  IN2 w0.114: v1(130.36,172.36) 130.07,172.65 130.07,172.96 129.78,173.25 129.01,173.25 128.16,174.1 123.11,174.1 122.65,174.56 120.39,174.56 117.47,171.64 117.47,170.8 116.27,169.6 116.27,168.18 112.03,163.94 112.03,160.97 110.43,159.37 110.43,156.83 109.44,155.84 109.44,154.19 109.25,153.99 109.07,153.99 v1(108.82,154.25)
  BOTTOM w0.076: 114.09,125.64 114.08,125.63 114.11,125.6 114.11,125.57 114.17,125.5 114.17,124.4 113.86,124.1 U35.A47
  BOTTOM w0.114: 114.09,125.64 114.09,126.96 114.1,126.98 114.1,129.27 109.85,133.52 105.44,133.52 103.38,135.58 103.38,145.05 108.06,149.73 108.06,153.74 108.31,153.99 108.57,153.99 v1(108.82,154.25) ; v1(130.36,172.36) 130.07,172.65 130.07,173.92 131.41,175.27 131.41,176.54 131.14,176.81 C3226.1
EDP_TXN3_C: length 2.1
  BOTTOM w0.114: CN5.4 129.42,178.15 129.59,178.15 129.9,177.84 C3226.2
EDP_TXP0: length 74.4
  IN2 w0.114: v1(110.17,154.58) 110.42,154.83 110.55,154.83 110.84,155.12 110.84,156.01 111.31,156.48 111.31,159.04 112.88,160.61 112.88,163.49 118.61,169.22 118.89,169.22 122.66,172.99 126.27,172.99 127.03,172.23 v1(127.03,171.98)
  BOTTOM w0.076: 113.85,125.43 113.98,125.3 113.98,124.45 113.59,124.07 113.59,123.59 113.62,123.53 113.62,123.24 113.58,123.17 113.58,122.98 113.63,122.87 113.76,122.74 114.43,122.74 U35.C46
  BOTTOM w0.114: v1(127.03,171.98) 127.03,172.29 126.88,172.44 126.29,172.44 C13.1 ; 113.85,125.43 113.85,128.75 112.79,129.81 112.73,129.87 112.71,129.87 112.7,129.89 112.64,129.95 112.64,130.1 109.69,133.08 105.17,133.08 102.95,135.3 102.95,145.26 107.56,149.87 107.56,153.96 108.48,154.87 109.87,154.87 v1(110.17,154.58)
EDP_TXP0_C: length 2.1
  BOTTOM w0.114: C13.2 125.64,173.14 125.16,173.62 124.76,173.62 CN5.17
EDP_TXP1: length 75.9
  IN2 w0.114: v1(110.42,152.39) 110.21,152.6 110.21,152.76 110.31,152.86 110.58,152.86 110.68,152.95 111.1,152.95 111.17,152.89 111.17,151.97 111.4,151.75 111.96,151.75 112.18,151.97 112.18,155.05 111.94,155.29 111.94,156.85 112.45,157.36 112.45,159.28 113.52,160.35 113.52,163.14 118.74,168.36 119.12,168.36 122.9,172.14 124.3,172.14 125.61,170.83 v1(125.61,170.42)
  BOTTOM w0.076: U35.C45 114.77,122.41 114.72,122.47 114.72,122.67 114.77,122.73 115.09,122.73 115.19,122.83 115.28,123 115.28,123.08 115.24,123.2 115.21,123.31 115.21,123.5 115.27,123.67 115.27,124.02 114.98,124.31 114.98,125.17 114.96,125.19 114.96,125.21
  BOTTOM w0.114: C10.1 125.42,171.07 125.61,170.87 v1(125.61,170.42) ; v1(110.42,152.39) 110.42,152.8 110.5,152.88 110.9,152.88 111.08,152.7 111.08,152.14 109.75,150.81 109.75,149.38 104.95,144.58 104.95,136.12 106.25,134.82 112.1,134.82 113.01,133.9 113.01,132.18 114.96,130.23 114.96,125.21
EDP_TXP1_C: length 2.1
  BOTTOM w0.114: C10.2 124.37,172.1 123.86,172.61 123.64,172.61 123.18,173.07
EDP_TXP2: length 78.8
  IN2 w0.114: v1(129.61,174.45) 129.61,174.86 129.53,174.94 127.13,174.94 126.71,174.52 123.32,174.52 122.84,175 120.07,175 116.81,171.74 116.81,171 113.15,167.34 111.6,164.14 111.6,162.97 111.05,162.42 110.87,162.25 110.47,161.86 110.41,161.77 110.29,161.57 110.09,161.24 108.53,157.66 108.53,157.65 108.32,157.17 108.29,156.89 108.28,156.78 108.29,156.4 108.29,152.78 108.85,152.22 109.53,152.22 v1(109.76,152.45)
  BOTTOM w0.114: C3224.1 129.49,175.13 129.61,175.02 v1(129.61,174.45) ; v1(109.76,152.45) 109.56,152.24 109.25,152.24 109.01,152 109.01,149.66 104.15,144.8 104.15,135.83 105.82,134.16 110.12,134.16 114.53,129.74 114.53,124.16 114.46,124.08 114.46,123.53 114.63,123.36 114.69,123.36 U35.B45
EDP_TXP2_C: length 2.1
  BOTTOM w0.114: C3224.2 128.43,176.31 CN5.8
EDP_TXP3: length 82.6
  IN2 w0.114: v1(108.82,153.54) 109.06,153.78 109.34,153.78 109.66,154.1 109.66,155.75 110.65,156.74 110.65,159.28 112.25,160.88 112.25,163.85 116.49,168.09 116.49,169.51 117.68,170.71 117.68,171.55 120.48,174.34 122.56,174.34 123.02,173.88 128.07,173.88 128.92,173.03 129.69,173.03 129.85,172.87 129.85,172.46 129.75,172.36 v1(129.56,172.36)
  BOTTOM w0.076: 114.31,125.65 114.34,125.62 114.34,124.34 114.13,124.13 114.13,123.33 U35.B47
  BOTTOM w0.114: v1(108.82,153.54) 108.58,153.78 108.4,153.78 108.27,153.65 108.27,149.64 103.6,144.96 103.6,135.67 105.53,133.74 109.94,133.74 114.31,129.37 114.31,125.65 ; C3227.1 130.99,176.65 131.2,176.45 131.2,175.36 129.85,174.01 129.85,172.46 129.75,172.36 v1(129.56,172.36)
EDP_TXP3_C: length 2.1
  BOTTOM w0.114: CN5.5 128.95,177.91 129.53,177.91 129.96,177.48 C3227.2
EDP_VDD_EN: length 109.8
  IN1 w0.076: 135.53,121.04 135.39,120.9 135.39,118.38 135.01,118 133.56,118 132.77,117.22 132.77,115.77 133.06,115.48 v2(133.06,115.32)
  IN1 w0.14: 135.53,121.04 136.33,121.84 139.35,121.84 140.11,121.08 145.04,121.08 145.4,121.43 145.4,124.33 147.43,126.36 147.43,127.78 138.59,136.62 127.54,136.62 124.77,139.39 124.77,141.37 122.54,143.61 117.51,143.61 114.56,140.66 114.56,137.84 112.23,135.5 111.68,135.5 108.85,132.68 108.85,132.24 108.48,131.86 108.09,131.86 107.82,132.14 107.82,133.29 113.82,139.29 113.82,141.35 115.55,143.07 115.55,146.28 114.03,147.81 114.03,155.24 v1(113.11,156.15)
  BOTTOM w0.127: v2(133.06,115.32) 133.53,114.85 U35.U13 ; R37.1 113.34,156.66 113.11,156.43 v1(113.11,156.15)
EDP_VDD_EN_R: length 3.3
  BOTTOM w0.127: U1.3 111.81,158.52 R38.2 113.34,158.51 R37.2 113.89,157.64 v1(114.05,157.47)
ENSWREG: length 4.6
  TOP w0.127: U15.34 39.3,68.57 39.34,68.53 39.34,68.34 39.67,68.01 39.67,67.71 40.14,67.25 40.14,67.18 40.14,67.18 40.14,66.77 39.43,66.06 39.29,66.06 R11258.1
EVDD10:
  vias: v1(31.07,71.93)
FAN1_DAC: length 280.3
  IN1 w0.14: v1(175.71,31.1) 175.71,31.04 171.74,27.07 169.88,27.07 168.33,25.52 160.38,25.52 159.34,26.56 156.34,26.56 151.14,21.36 150.94,21.17 126.04,21.17 125.86,20.98 117.09,20.98 113.95,24.12 109.18,24.12 v1(108.51,24.78) ; v1(49.66,25.83) 52.61,25.83 54.44,24 60.51,24 62.41,25.9 78.62,25.9 v1(79.43,26.72)
  BOTTOM w0.127: U45.81 174.25,35.4 174.76,34.89 174.76,31.85 174.96,31.64 175.16,31.64 v1(175.71,31.1) ; v1(79.43,26.72) 106.28,26.72 108.21,24.78 v1(108.51,24.78) ; U12.4 70.41,119 71.58,117.83 71.58,113.68 58.38,100.48 49.76,100.48 43.52,94.23 43.52,79.8 44.94,78.38 44.94,78.15 45.44,77.64 46.36,77.64 48.08,75.93 48.08,72.78 45.65,70.36 45.65,68.73 31.86,54.93 31.86,43.84 34.59,41.11 34.59,36.41 34.97,36.03 34.97,29.65 35.49,29.13 47.48,29.13 47.82,29.47 v1(48.67,29.47) 49.04,29.47 49.82,28.7 49.82,25.98 v1(49.66,25.83)
FAN1_RPM: length 323.2
  IN1 w0.14: v1(35.57,29.79) 35.57,28.49 34.4,27.32 33.74,27.32 32.8,26.39 32.8,21.61 30.79,19.6 v1(28.99,19.6)
  IN2 w0.14: v1(181.74,30.5) 181.24,31.01 176.68,31.01 175.84,30.16 174.92,30.16 169.51,24.76 163.58,24.76 158.14,19.32 141.15,19.32 139.07,21.41 135.72,21.41 135.21,20.9 127.27,20.9 124.32,17.95 112.71,17.95 102.42,28.24 89.85,28.24 82.34,20.73 79.07,20.73 77.62,19.28 73.92,19.28 72.14,17.5 72.14,15.91 66.44,10.21 37.13,10.21 33.7,13.63 33.7,15.3 29.39,19.6 v1(28.99,19.6)
  BOTTOM w0.127: CN8.2 64.3,120.4 C719.2 64.62,120.08 65.11,120.57 66.02,120.57 R609.2 67.36,120.92 69.81,120.92 71.99,118.74 71.99,113.73 58.48,100.22 49.87,100.22 43.77,94.13 43.77,79.91 45.19,78.48 45.19,78.25 45.55,77.9 46.47,77.9 48.33,76.04 48.33,72.68 45.9,70.25 45.9,68.62 32.11,54.83 32.11,43.94 34.84,41.21 34.84,36.52 35.57,35.8 v1(35.57,30.42) v1(35.57,29.79) ; U45.47 179.98,28.58 181.72,30.32 181.72,30.47 v1(181.74,30.5)
FB_CAL_PD_VDDQ: length 1.4
  TOP w0.381: v1(188.9,140.86) 188.79,140.75 R859.2
  BOTTOM w0.14: v1(188.9,140.86) 189.32,140.44 U3002.J27
FB_CAL_PU_GND: length 1.4
  TOP w0.127: v1(189.76,140.81) 189.86,140.71 R860.2
  BOTTOM w0.305: U3002.H27 190.13,140.44 v1(189.76,140.81)
FB_CAL_TERM_GND: length 1.3
  TOP w0.508: v1(189.82,138.28) 189.82,137.68 R861.2
  BOTTOM w0.305: v1(189.82,138.28) 190.23,138.69 U3002.H25
FB_DLL_AVDD: length 27.8
  TOP w0.508: C1211.1 189.92,139.21 v1(189.67,139.47)
  IN1 w0.508: v1(189.67,139.47) 190.18,139.47 190.56,139.08 191.83,139.08 192.59,139.85 193.99,139.85 194.75,140.61 194.75,143.73 v1(204.7,153.69)
  BOTTOM w0.305: U3002.K27 188.69,140.23 188.91,140.23 v1(189.67,139.47)
  BOTTOM w0.508: L26.1 206.25,154.57 206.2,154.61 C1212.1 205.52,154.5 v1(204.7,153.69)
FB_GND_SENSE: length 10.3
  BOTTOM w0.102: 191.45,118.96 191.45,119.06 191.83,119.45 U3002.F2
  BOTTOM w0.14: R858.1 196.75,112.65 v1(196.75,113.58) 195.95,114.38 195.95,114.61 194.85,115.72 194.24,115.72 191.45,118.51 191.45,118.96
FB_PLL_AVDD: length 15.1
  TOP w0.508: v1(189.31,132.81) 189.55,132.57 C4112.2
  IN1 w0.381: v1(189.31,132.81) 189.31,132.84 188.17,133.98 188.17,138.07 187.94,138.3 183.97,138.3 v1(182.24,140.03)
  BOTTOM w0.305: v1(189.31,132.81) 189.31,132.58 189.59,132.3 189.97,132.3 U3002.H17
  BOTTOM w0.381: U3002.U27 182.24,140.05 v1(182.24,140.03)
FB_VDDQ_SENSE: length 9.8
  BOTTOM w0.14: R857.1 197.82,112.7 197.82,113.56 v1(196.5,114.88) 196.31,115.07 195.4,115.98 194.48,115.98 191.83,118.64 U3002.F1
FBA_CMD0: length 32
  IN1 w0.102: 200.03,159.02 199.11,159.02 199.11,159.02 198.54,159.02 v2(198.15,159.41) ; v2(183.07,143.36) 182.66,143.76 182.66,145.06 184.08,146.48 184.18,146.48
  IN1 w0.17: 200.03,159.02 200.54,158.52 200.54,153.79 196.4,149.65 190.96,149.65 189.46,148.15 188.88,148.15 187.2,146.48 184.18,146.48
  BOTTOM w0.152: v2(198.15,159.41) 197.75,159.81 U5.G12
  BOTTOM w0.178: U3002.U30 182.65,142.94 v2(183.07,143.36)
FBA_CMD1: length 33.9
  IN1 w0.102: v2(196.55,160.21) 196.95,159.81 199.6,159.81 199.62,159.83 200.07,159.83 200.08,159.81 ; 183.98,145.99 183.07,145.09 v2(183.07,144.12)
  IN1 w0.17: 200.08,159.81 201.02,158.87 201.02,153.51 196.58,149.07 191.22,149.07 188.14,145.99 183.98,145.99
  BOTTOM w0.152: v2(196.55,160.21) 196.15,160.61 U5.H10
  BOTTOM w0.178: U3002.T31 183.45,143.74 v2(183.07,144.12)
FBA_CMD2: length 36.4
  IN1 w0.102: v2(197.35,160.21) 197.41,160.21 197.87,160.67 198.1,160.67 ; 184.18,145.51 183.9,145.51 183.48,145.08 183.48,144.75 183.49,144.75 183.49,142.92 v1(183.05,142.48)
  IN1 w0.17: 184.18,145.51 188.8,145.51 191.78,148.48 196.75,148.48 201.5,153.23 201.5,159.43 200.26,160.67 198.1,160.67
  BOTTOM w0.152: U5.H11 197.35,160.22 v2(197.35,160.21) ; 183.02,142.48 v1(183.05,142.48)
  BOTTOM w0.178: U3002.U29 183.02,142.48
FBA_CMD3: length 29.5
  IN1 w0.17: v1(184.36,147.38) 184.7,147.04 185.4,147.04 185.81,147.44 186.15,147.44 186.4,147.19 187.13,147.19 190.1,150.16 193.41,150.16 195.91,152.66 196.11,152.66 196.3,152.47 196.5,152.47 196.63,152.6 196.63,152.8 196.44,152.99 196.44,153.19 196.78,153.53 196.78,154.55 196.65,154.68 196.2,154.68 196.07,154.81 196.07,155.02 196.21,155.16 196.74,155.16 196.88,155.3 196.88,155.49 196.74,155.63 196.21,155.63 196.07,155.77 196.07,160.5 196.32,160.75 196.75,160.75 196.88,160.88 196.88,161.08 196.75,161.21 196.4,161.21 196.25,161.36 196.25,161.59 196.47,161.81 v2(196.55,161.81)
  BOTTOM w0.152: v2(196.55,161.81) U5.K11
  BOTTOM w0.178: U3002.R34 184.46,146.27 184.46,147.28 v1(184.36,147.38)
FBA_CMD4: length 30.9
  IN1 w0.079: 184.84,147.95 184.66,147.77 184.16,147.77 184.15,147.77 183.62,147.77 183.5,147.64 183.5,147.44 183.59,147.35 v2(183.7,147.35)
  IN1 w0.17: v2(195.76,161.81) 195.59,161.65 195.59,154.09 195.59,153.9 195.94,153.55 195.94,153.36 195.8,153.22 195.6,153.22 195.26,153.56 195.06,153.56 194.92,153.42 194.92,153.22 195.27,152.88 195.27,152.68 195.13,152.54 194.93,152.54 194.59,152.89 194.39,152.89 194.25,152.75 194.25,152.55 194.59,152.21 194.59,152.01 194.45,151.87 194.26,151.87 193.91,152.22 193.72,152.22 193.58,152.08 193.58,151.88 193.92,151.54 193.92,151.34 193.78,151.2 193.59,151.2 193.24,151.54 193.05,151.54 192.17,150.67 189.94,150.67 187.22,147.95 184.84,147.95
  BOTTOM w0.152: U5.K10 196.15,162.2 v2(195.76,161.81)
  BOTTOM w0.178: v2(183.7,147.35) 183.73,147.35 184.16,146.93 184.16,146.53 183.93,146.3 183.93,145.74 U3002.R33
FBA_CMD5: length 28.8
  IN1 w0.17: v2(183.98,148.15) 184.13,148.3 184.46,148.3 184.61,148.46 187.05,148.46 189.85,151.25 192.08,151.25 195.12,154.29 195.12,162.14 195.36,162.38 197.11,162.38 v2(197.35,162.61)
  BOTTOM w0.152: v2(183.98,148.15) 183.93,148.1 183.82,148.1 183.8,148.08 ; v2(197.35,162.61) U5.L12
  BOTTOM w0.178: U3002.U32 183.07,144.98 183.07,145.6 183.32,145.86 183.32,146.41 183.31,146.42 183.31,146.43 183.22,146.52 183.22,147.5 183.8,148.08
FBA_CMD6: length 28
  IN1 w0.17: v1(184.16,148.79) 184.31,148.94 186.86,148.94 189.76,151.84 191.95,151.84 194.64,154.53 194.64,161.26 193.15,162.76 191.89,162.76 v2(191.75,162.61)
  BOTTOM w0.152: v2(191.75,162.61) U5.K4 ; 182.94,146.39 182.94,147.77 183.91,148.74 184.11,148.74 v1(184.16,148.79)
  BOTTOM w0.178: 182.94,146.39 183.04,146.29 183.04,145.97 182.63,145.56 U3002.U33
FBA_CMD7: length 30.4
  IN1 w0.102: 183.19,145.99 182.45,145.25 182.45,142.37 183.04,141.78 v2(183.04,141.63)
  IN1 w0.17: 183.19,145.99 183.25,146.04 183.25,148.68 184.06,149.5 186.75,149.5 189.6,152.34 191.73,152.34 194.17,154.79 194.17,161.05 193.12,162.1 v2(192.82,162.1)
  BOTTOM w0.152: U5.K5 192.26,162.1 v2(192.82,162.1)
  BOTTOM w0.178: v2(183.04,141.63) 182.65,141.24 U3002.U28
FBA_CMD8: length 30
  IN1 w0.102: 182.89,146.37 182.89,145.99 182.24,145.34 182.24,141.69 v2(182.25,141.68)
  IN1 w0.17: v2(191.75,161.81) 191.95,161.61 192.64,161.61 193.69,160.56 193.69,155.1 191.55,152.95 189.53,152.95 186.61,150.03 183.93,150.03 182.89,148.99 182.89,146.37
  BOTTOM w0.152: v2(182.25,141.68) 181.83,141.25 U3002.V28 ; v2(191.75,161.81) U5.J4
FBA_CMD9: length 31.1
  IN1 w0.102: v2(181.42,141.6) 181.42,141.91 182.02,142.51 182.02,145.54 182.48,145.99
  IN1 w0.17: v2(192.58,161.01) 192.46,161.01 192.26,160.8 192.26,160.32 192.64,159.94 193.1,159.94 193.22,159.82 193.22,159.1 193.08,158.96 192.85,158.96 192.73,158.83 192.73,158.61 192.85,158.49 193.08,158.49 193.22,158.35 193.22,158.15 193.08,158.01 192.85,158.01 192.73,157.88 192.73,157.66 192.85,157.54 193.08,157.54 193.22,157.4 193.22,157.2 193.08,157.06 192.85,157.06 192.73,156.93 192.73,156.71 192.85,156.59 193.08,156.59 193.22,156.45 193.22,155.36 191.39,153.54 189.04,153.54 186.06,150.55 183.77,150.55 182.5,149.28 182.5,146.02 182.48,145.99
  BOTTOM w0.152: v2(181.42,141.6) 181.83,142.01 U3002.V29 ; U5.J5 192.17,161.42 v2(192.58,161.01)
FBA_CMD10: length 28.9
  IN1 w0.079: 192.15,159.23 192.15,158.74 192.25,158.64
  IN1 w0.102: 192.15,159.23 192.15,159.79 v2(191.75,160.19) ; v2(181.42,143.32) 181.42,143.12 181.54,143 181.69,143 181.81,143.12 181.81,145.98 181.83,145.99
  IN1 w0.17: 192.25,158.64 192.25,156.22 192.39,156.08 192.59,156.08 192.74,155.93 192.74,155.73 192.62,155.6 192.41,155.6 192.25,155.44 192.25,155.22 191.13,154.1 188.93,154.1 188.59,153.76 188.4,153.76 188.21,153.95 188.03,153.95 187.87,153.8 187.87,153.62 188.06,153.42 188.06,153.23 187.92,153.09 187.73,153.09 187.55,153.27 187.37,153.27 187.21,153.11 187.21,152.93 187.39,152.75 187.39,152.55 187.25,152.42 187.05,152.42 186.89,152.58 186.71,152.58 186.55,152.43 186.55,152.25 186.72,152.08 186.72,151.88 186.01,151.17 183.72,151.17 182.03,149.48 182.03,146.19 181.83,145.99
  BOTTOM w0.152: U5.H4 191.35,160.59 v2(191.75,160.19) ; U3002.V30 181.79,142.94 v2(181.42,143.32)
FBA_CMD11: length 26.6
  IN1 w0.102: 188.29,159.01 188.36,159.01 188.47,159.13 188.47,159.39 188.59,159.51 188.74,159.51 188.86,159.39 188.86,159.13 188.97,159.01 191.11,159.01 191.35,159.25 191.35,160.96 191.42,161.03 v2(191.74,161.03)
  IN1 w0.17: 188.29,159.01 188.07,158.8 188.07,155.06 188.19,154.93 188.62,154.93 188.74,154.8 188.74,154.58 188.62,154.45 187.85,154.45 187.36,153.95 187.16,153.95 186.98,154.13 186.78,154.13 186.64,153.99 186.64,153.8 186.82,153.62 186.82,153.42 186.68,153.28 186.49,153.28 186.31,153.46 186.11,153.46 185.97,153.32 185.97,153.12 186.15,152.95 186.15,152.75 185.81,152.41 185.81,151.78 185.69,151.65 185.4,151.65 185.27,151.78 185.27,152.14 185.07,152.34 v1(184.33,152.34)
  BOTTOM w0.152: 182.63,147.84 183.57,148.79 183.57,149.6 183.95,149.98 183.95,150.49 184.41,150.95 v1(184.41,151.33) 184.41,152.27 v1(184.33,152.34) ; U5.H5 v2(191.74,161.03)
  BOTTOM w0.178: U3002.U34 182.63,147.84
FBA_CMD12: length 29.4
  IN1 w0.102: v2(190.95,159.41) 190.95,159.73 190.86,159.81 187.89,159.81
  IN1 w0.17: 187.89,159.81 187.82,159.81 187.55,159.54 187.55,159.01 187.41,158.87 187.08,158.87 186.95,158.74 186.95,158.52 187.08,158.39 187.41,158.39 187.55,158.26 187.55,158.06 187.41,157.92 187.1,157.92 186.98,157.79 186.98,157.57 187.1,157.44 187.41,157.44 187.55,157.31 187.55,157.11 187.41,156.97 187.08,156.97 186.95,156.84 186.95,156.62 187.08,156.49 187.41,156.49 187.55,156.36 187.55,156.16 187.41,156.02 187.08,156.02 186.95,155.89 186.95,155.67 187.08,155.54 187.41,155.54 187.55,155.41 187.55,154.93 187.22,154.6 187.04,154.6 186.58,155.07 186.38,155.07 186.24,154.93 186.24,154.73 186.39,154.59 186.39,154.41 186.23,154.25 186.05,154.25 185.9,154.39 185.71,154.39 185.57,154.26 185.57,154.06 185.71,153.91 185.71,153.73 185.56,153.58 185.38,153.58 185.23,153.72 185.04,153.72 184.9,153.58 184.9,153.39 185.13,153.15 185.13,152.98 184.97,152.82 184.79,152.82 184.56,153.05 184.36,153.05 183.83,152.51 183.83,151.91 v2(183.93,151.81)
  BOTTOM w0.152: 182.93,148.67 182.99,148.73 182.99,149.75 183.47,150.24 v1(183.47,150.44) 183.47,150.73 183.93,151.19 v2(183.93,151.81) ; U5.G3 190.55,159.81 v2(190.95,159.41)
  BOTTOM w0.178: 182.93,148.67 182.35,148.09 182.35,147.07 182.23,146.95 182.23,144.14 U3002.U31
FBA_CMD13: length 29.1
  TOP w0.152: v2(190.15,161.81) 190.3,161.97 R1466.1
  IN1 w0.102: v2(190.15,161.81) 190.39,161.81 190.54,161.67 190.54,160.85 190.3,160.61 187.89,160.61
  IN1 w0.17: v1(183.32,152.17) 183.27,152.22 183.27,152.63 186.48,155.83 186.48,156.31 186.34,156.45 185.73,156.45 185.6,156.58 185.6,156.8 185.73,156.92 186.34,156.92 186.48,157.06 186.48,157.26 186.34,157.4 185.71,157.4 185.58,157.53 185.58,157.75 185.71,157.87 186.34,157.87 186.48,158.01 186.48,158.21 186.34,158.35 185.73,158.35 185.6,158.48 185.6,158.7 185.73,158.82 186.4,158.82 186.52,158.95 186.52,159.17 186.4,159.3 185.76,159.3 185.63,159.43 185.63,159.65 185.76,159.77 186.34,159.77 186.48,159.91 186.48,160.29 186.8,160.61 187.89,160.61
  BOTTOM w0.152: v2(190.15,161.81) 190.15,161.78 189.75,161.39 U5.J2 ; U3002.V34 181.9,146.21 181.9,148.11 182.53,148.75 v1(182.53,149.32) 182.53,149.96 182.99,150.41 182.99,150.89 183.44,151.35 183.44,152.04 v1(183.32,152.17)
FBA_CMD14: length 27.6
  TOP w0.102: R1467.1 189.42,162.57 189.74,162.25 189.74,161.42 v2(190.15,161.01)
  IN1 w0.102: v2(190.15,161.01) 190.15,161.31 190.05,161.41 188.09,161.41
  IN1 w0.17: v1(182.5,151.12) 182.5,152.54 184.89,154.92 184.89,155.4 185.03,155.54 185.51,155.54 185.63,155.66 185.63,155.89 185.51,156.01 185.03,156.01 184.89,156.15 184.89,157.39 185.1,157.6 185.1,157.86 184.89,158.07 184.89,158.5 185.13,158.74 185.13,158.98 184.89,159.22 184.89,159.58 186.4,161.09 186.88,161.09 187,161.22 187,161.82 187.13,161.94 187.35,161.94 187.48,161.82 187.48,161.23 187.62,161.09 187.81,161.09 187.95,161.23 187.95,161.28 188.09,161.41
  BOTTOM w0.152: v2(190.15,161.01) U5.J3 ; v1(182.5,151.12) 182.5,150.59 182.05,150.13 182.05,148.74 181.62,148.31 181.62,146.48 181.4,146.27 181.4,145.76 U3002.V33
FBA_CMD15: length 26.2
  IN1 w0.102: 188.09,162.42 190.7,162.42 190.9,162.61 v2(190.95,162.61)
  IN1 w0.17: v1(181.97,150.72) 181.97,152.67 184.31,155.01 184.31,161.02 185.71,162.42 188.09,162.42
  BOTTOM w0.152: v2(190.95,162.62) U5.L3 ; v1(181.97,150.72) 181.59,150.34 181.59,148.72 181.17,148.3 181.17,147.6 180.65,147.09 180.65,146.6 180.8,146.45 180.8,145.73 180.55,145.48 180.55,145.11 180.13,144.69 U3002.Y32
FBA_CMD16: length 24
  IN1 w0.102: v2(170.8,159.39) 171.2,159 171.73,159 171.97,158.75 171.97,155.82 ; 177.71,142.95 178.39,142.95 178.77,143.33 v1(178.89,143.33)
  IN1 w0.17: 177.71,142.95 177.48,142.95 176.92,143.5 176.92,144.42 176.54,144.8 174.83,144.8 171.41,148.23 171.41,153.66 172.29,154.55 172.29,155.5 171.97,155.82
  BOTTOM w0.152: v2(170.8,159.39) 170.8,159.39 170.41,159.79 U7.L12
  BOTTOM w0.178: v1(178.89,143.33) 179.3,143.74 U3002.AA31
FBA_CMD17: length 26.8
  IN1 w0.102: 170.41,158.97 170.41,159.58 170.62,159.79 171.94,159.79 v2(172.37,160.22) ; v2(178.93,141.63) 178.6,141.63 178.22,141.24 177.78,141.24 177.53,141.5 177.53,142.23 176.82,142.94 176.24,142.94 176.23,142.95 176.03,142.95
  IN1 w0.17: 176.03,142.95 175.77,142.95 170.91,147.81 170.91,153.75 170.29,154.38 170.29,158.85 170.41,158.97
  BOTTOM w0.152: U7.K10 172,160.59 v2(172.37,160.22)
  BOTTOM w0.178: v2(178.93,141.63) 178.93,141.69 U3002.AA29
FBA_CMD18: length 29.5
  IN1 w0.102: 169.62,159.07 169.62,160.39 169.82,160.58 171.19,160.58 v2(171.58,160.19) ; v1(178.93,140.87) 178.88,140.87 178.44,140.43 178.24,140.43 178.22,140.41 177.88,140.41 177.64,140.64 177.64,140.67 177.17,141.14 177.17,141.55 176.61,142.11 175.9,142.11 175.82,142.03 175.49,142.03 175.19,142.33 175.19,142.69
  IN1 w0.17: 169.62,159.07 169.78,158.92 169.78,154.15 170.25,153.68 170.25,146.46 171.56,145.16 172.85,145.16 175.15,142.85 175.19,142.82 175.19,142.69
  BOTTOM w0.152: U7.K11 171.58,160.19 v2(171.58,160.19)
  BOTTOM w0.178: v1(178.93,140.87) 178.95,140.87 U3002.AA28
FBA_CMD19: length 20.5
  IN1 w0.102: v2(171.58,162.59) 172.25,161.92 172.78,161.92
  IN1 w0.17: v2(177.62,146.73) 176.82,146.73 175.19,148.35 175.19,151.75 173.52,153.43 173.52,161.51 173.1,161.92 172.78,161.92
  BOTTOM w0.152: v2(171.58,162.59) U7.H11
  BOTTOM w0.178: U3002.AC34 177.6,146.17 177.6,146.73 v2(177.62,146.73)
FBA_CMD20: length 21.2
  IN1 w0.17: v2(177.98,147.25) 176.98,147.25 175.67,148.56 175.67,151.95 173.99,153.63 173.99,161.72 173.38,162.33 v2(172.55,162.33)
  BOTTOM w0.152: v2(172.55,162.33) 172.12,162.33 U7.H10
  BOTTOM w0.178: v2(177.98,147.25) 178.06,147.17 178.06,145.77 U3002.AC33
FBA_CMD21: length 25.2
  IN1 w0.102: v2(170.8,162.58) 171.22,163 171.97,163
  IN1 w0.152: 171.97,163 172.19,162.78 172.78,162.78
  IN1 w0.17: 172.78,162.78 172.93,162.94 173.51,162.94 174.47,161.98 174.47,153.83 176.14,152.15 176.14,148.95 177.31,147.78 v2(177.66,147.78)
  BOTTOM w0.152: U3002.AA32 178.87,144.99 178.87,145.64 178.67,145.84 178.67,146.41 178.93,146.67 178.93,147.03 178.18,147.78 v2(177.66,147.78) ; v2(170.8,162.58) 170.39,162.99 U7.G12
FBA_CMD22: length 21.5
  IN1 w0.102: 179.81,158.19 178.54,158.19 178.39,158.34 178.39,158.74 178.14,158.98 177.83,158.98 177.59,159.23 177.59,159.54 177.33,159.8 177.02,159.8 176.79,160.03 176.79,161.36 v2(177.22,161.79)
  IN1 w0.17: v1(178.83,149.88) 178.84,149.88 178.84,153.71 180.63,155.5 180.63,157.73 180.17,158.19 179.81,158.19
  BOTTOM w0.152: U3002.AA33 179.33,145.58 178.95,145.96 178.95,146.3 179.2,146.55 179.2,147.26 178.57,147.9 178.57,149.61 178.84,149.88 v1(178.83,149.88) ; v2(177.22,161.79) 177.18,161.79 U7.H4
FBA_CMD23: length 24.2
  IN1 w0.17: v2(180.5,141.63) 179.38,142.75 179.38,144.9 179.03,145.26 179.03,147.08 177.59,148.51 177.3,148.51 176.62,149.19 176.62,152.34 174.94,154.02 174.94,161.44 v2(175.44,161.94)
  BOTTOM w0.152: v2(180.5,141.63) 180.5,141.59 180.15,141.24 U3002.Y28 ; v2(175.44,161.94) 175.69,162.19 U7.H5
FBA_CMD24: length 23.2
  IN1 w0.102: v2(176.4,161.82) 176.38,161.82 175.78,161.22 175.78,159.14 175.95,158.97 175.95,158.39
  IN1 w0.17: v1(180.55,142.49) 179.91,143.13 179.91,145.38 179.53,145.76 179.53,147.24 177.09,149.68 177.09,152.54 175.42,154.22 175.42,157.85 175.95,158.39
  BOTTOM w0.152: v2(176.4,161.82) 176.4,161.77 U7.J4
  BOTTOM w0.178: v1(180.55,142.49) 180.53,142.49 U3002.Y29
FBA_CMD25: length 21.2
  IN1 w0.102: 176.05,157.32 176.13,157.4 176.54,157.4 176.79,157.64 176.79,158.74 176.53,159 176.22,159 175.99,159.23 175.99,160.65 v2(176.33,161) ; v1(180.55,144.12) 180.37,144.29 180.37,145.33
  IN1 w0.17: 176.05,157.32 175.9,157.17 175.9,154.41 177.68,152.63 177.68,149.8 180.02,147.47 180.02,145.97 180.37,145.61 180.37,145.33
  BOTTOM w0.152: v2(176.33,161) 176.33,161.01 175.98,161.36 U7.J5
  BOTTOM w0.178: U3002.W31 180.6,144.12 v1(180.55,144.12)
FBA_CMD26: length 23.7
  IN1 w0.102: v2(180.55,143.3) 180.98,143.73 180.98,144.3 180.7,144.58 180.7,145.36 ; v2(177.18,160.19) 177.43,160.19 177.83,159.79 179.89,159.79
  IN1 w0.17: 180.7,145.36 180.7,146.45 180.63,146.53 180.63,147.62 179.71,148.53 179.71,149.42 179.96,149.68 179.96,150.18 179.84,150.31 179.84,153.23 181.78,155.17 181.78,159.16 181.16,159.79 179.89,159.79
  BOTTOM w0.152: v2(177.18,160.19) U7.K4
  BOTTOM w0.178: U3002.Y30 180.49,143.3 v2(180.55,143.3)
FBA_CMD27: length 19.1
  IN1 w0.102: v2(176.39,160.18) 176.39,160.06 176.79,159.66 176.79,159.23 177.03,158.98 177.34,158.98 177.57,158.75 177.59,158.74 177.59,157.59 177.8,157.38 179.8,157.38 179.81,157.37
  IN1 w0.17: 179.81,157.37 179.81,157.37 179.96,157.37 180.12,157.22 180.12,155.72 178.24,153.84 178.24,149.83 178.71,149.36 178.99,149.36 v1(179.13,149.22)
  BOTTOM w0.152: U7.K5 v2(176.39,160.18) ; U3002.AA34 179.48,146.29 179.48,147.57 179.13,147.93 v1(179.13,149.22)
FBA_CMD28: length 19.9
  IN1 w0.102: v2(177.98,159.39) 178.13,159.39 178.52,159 178.94,159 178.95,159 179.38,159 179.38,159 179.71,159 179.71,159 179.81,159
  IN1 w0.17: v1(179.48,149.88) 179.36,150.01 179.36,153.42 181.2,155.26 181.2,158.35 180.55,159 179.81,159
  BOTTOM w0.152: v1(179.48,149.88) 179.74,149.62 179.74,144.13 U3002.Y31 ; v2(177.98,159.39) U7.L3
FBA_CMD29: length 23.6
  TOP w0.076: 180.65,160.54 R1472.1
  TOP w0.102: v2(178,160.98) 178.38,160.59 179.76,160.59 179.81,160.54
  TOP w0.152: R1472.1 179.81,160.54 ; v1(181.52,160.54) 180.65,160.54
  IN1 w0.102: v2(178,160.98) 178.39,160.59 180.02,160.59
  IN1 w0.17: 180.02,160.59 181.03,160.59 182.34,159.28 182.34,155.06 180.5,153.22 180.5,149.6 180.19,149.3 180.19,148.71 v1(180.27,148.63)
  BOTTOM w0.152: v2(178,160.98) 178,161.01 U7.J2 ; v1(180.27,148.63) 180.27,148.1 179.99,147.82 179.99,146.27 U3002.Y34
FBA_CMD30: length 25.5
  TOP w0.102: v2(177.18,160.99) 176.79,160.6 176.05,160.6
  TOP w0.152: 176.05,160.6 175.88,160.6 175.69,160.41 R1473.1 v1(174.67,160.41)
  IN1 w0.102: v2(177.18,160.99) U7.J3 180.02,161.39
  IN1 w0.17: v1(181.04,149.75) 180.98,149.82 180.98,153.03 182.82,154.86 182.82,159.47 180.9,161.39 180.02,161.39
  BOTTOM w0.152: v1(181.04,149.75) 181.13,149.66 181.13,148.81 180.73,148.41 180.73,147.77 180.29,147.34 180.29,146.53 180.52,146.3 180.52,145.99 180.13,145.59 U3002.Y33 ; v2(177.18,160.99) U7.J3
FBA_CMD31: length 25
  IN1 w0.102: v2(181.42,144.16) 181.42,144.24 180.98,144.67 180.98,145.18 181.11,145.31 181.11,145.94 181.26,146.09
  IN1 w0.17: 181.26,146.09 181.55,146.39 181.55,150.05 181.49,150.11 181.49,152.86 183.33,154.7 183.33,160.08 181.08,162.33 180.19,162.33 179.13,163.39 v2(177.98,163.39)
  BOTTOM w0.152: v2(177.98,163.39) U7.G3 ; v2(181.42,144.16) 181.83,143.74 U3002.V31
FBA_DBI0: length 17.9
  IN2 w0.102: v2(189.36,156.99) 189.36,156.74 189.24,156.61 188.19,156.61
  IN2 w0.17: v1(185.57,143.32) 186.09,143.84 186.09,145.61 185.42,146.28 185.42,147.79 185.42,147.8 185.42,147.81 185.25,147.98 185.25,149.63 187.61,151.99 187.61,156.36 187.87,156.61 188.19,156.61
  BOTTOM w0.127: U3002.P30 185.51,143.32 v1(185.57,143.32)
  BOTTOM w0.152: U5.D2 189.36,157.03 v2(189.36,156.99)
FBA_DBI1: length 19.3
  IN2 w0.102: v2(198.97,157.02) 199.38,156.61 200.03,156.61
  IN2 w0.14: 191.42,145.07 v2(191.42,144.17)
  IN2 w0.17: 191.42,145.07 192.69,146.34 192.69,147.47 193.63,148.41 194.75,148.41 200.31,153.97 200.31,156.36 200.06,156.61 200.03,156.61
  BOTTOM w0.127: U3002.F31 191.42,144.14 v2(191.42,144.17)
  BOTTOM w0.152: U5.D13 198.94,157.02 v2(198.97,157.02)
FBA_DBI2: length 26
  BOTTOM w0.102: U5.P13 198.92,165.05 200.18,165.05
  BOTTOM w0.127: U3002.F34 191.93,146.24
  BOTTOM w0.152: 191.93,146.24 191.93,148.36 v1(194.04,150.46) 194.7,151.12 196.89,151.12 200.74,154.97 200.74,164.61 200.31,165.05 200.18,165.05
FBA_DBI3: length 27.4
  BOTTOM w0.102: 189.44,166.62 190,166.62 190.15,166.47 190.15,165.82 U5.P2
  BOTTOM w0.127: 188.14,166.66 189.39,166.66 189.44,166.62 ; U3002.M32 186.39,144.97 186.39,145.63 186.26,145.77 186.26,146.4 186.47,146.61 186.47,148.03
  BOTTOM w0.152: 188.14,166.66 187.84,166.66 185.78,164.6 185.78,154.11 186.67,153.22 v1(186.67,152.09) 186.67,148.23 186.47,148.03
FBA_DBI4: length 16.9
  IN2 w0.102: 176.71,147.21 176.82,147.11 176.82,145.87 176.49,145.54 176.49,144.24 v2(176.41,144.16) ; v2(178.78,156.99) 178.8,156.99 179.2,156.59 179.81,156.59
  IN2 w0.17: 176.71,147.21 176.59,147.34 176.59,149.98 180.45,153.84 180.45,155.95 179.81,156.59 179.81,156.59
  BOTTOM w0.127: U3002.AD31 v2(176.41,144.16)
  BOTTOM w0.152: U7.P2 178.78,156.99 v2(178.78,156.99)
FBA_DBI5: length 19.1
  IN2 w0.102: 167.89,156.39 167.89,156.46 168,156.57 168.54,156.57 168.96,156.99 v2(169.23,156.99)
  IN2 w0.114: 170.67,143.06 170.94,142.79 170.94,141.98 v1(171.32,141.6)
  IN2 w0.17: 167.89,156.39 167.77,156.27 167.77,153.64 169.58,151.84 169.58,145.59 170.67,144.49 170.67,143.06
  BOTTOM w0.127: U3002.AL29 171.32,141.65 v1(171.32,141.6)
  BOTTOM w0.152: v2(169.23,156.99) 169.58,157.34 U7.P13
FBA_DBI6: length 28.4
  IN1 w0.102: 167.7,166.46 167.82,166.59 168.36,166.59 168.39,166.56 168.4,166.56 168.63,166.33 168.63,166.32 168.69,166.26 169.04,166.26 169.18,166.4 v2(169.18,166.59)
  IN1 w0.17: v1(166.81,148.89) 165.89,149.8 165.89,155.02 165.48,155.43 165.48,164.25 167.7,166.46
  BOTTOM w0.152: v1(166.81,148.89) 168.23,147.47 168.23,146.93 168.94,146.22 168.94,145.11 169.12,144.93 169.54,144.93 169.93,144.54 U3002.AM32 ; v2(169.18,166.59) 169.18,165.79 U7.D13
FBA_DBI7: length 25.3
  BOTTOM w0.152: U3002.AF34 174.83,146.43 174.83,147.68 174.53,147.98 v1(174.53,150.29) 174.53,150.49 177.15,153.11 179.27,153.11 180.92,154.75 180.92,164.27 180.19,165.01 178.76,165.01 U7.D2
FBA_DEBUG0: length 2.8
  TOP w0.102: v1(184.69,142.51) 184.71,142.54 R4103.2
  BOTTOM w0.102: U3002.R32 184.33,144.3 184.71,143.91 184.71,142.54 v1(184.69,142.51)
FBA_DEBUG0_K: length 2.2
  TOP w0.14: TP4106.1 185.15,141.22 v1(184.73,141.64)
  BOTTOM w0.305: U3002.R28 v1(184.73,141.64)
FBA_DEBUG1: length 1.7
  TOP w0.127: R4105.2 177.72,145.57 178.06,145.23 v1(178.06,144.95)
  BOTTOM w0.127: U3002.AC32 177.65,144.54 v1(178.06,144.95)
FBA_DEBUG1_K: length 1.6
  TOP w0.127: v1(178.05,141.65) 177.71,141.65 TP4107.1
  BOTTOM w0.127: U3002.AC28 177.68,141.24 178.05,141.61 v1(178.05,141.65)
FBA_EDC0: length 17
  IN2 w0.102: 188.3,155.79 188.95,155.79 188.96,155.81 189.75,155.81 v2(190.15,156.21)
  IN2 w0.14: 188.3,155.79 188.3,155.79 188.23,155.79 ; 186.46,147.18 186.46,143.39 v1(186.39,143.32)
  IN2 w0.17: 186.46,147.18 185.96,147.68 185.96,148.03 185.84,148.14 185.84,149.69 188.12,151.97 188.12,155.68 188.23,155.79
  BOTTOM w0.127: v1(186.39,143.32) 186.41,143.32 U3002.M31
  BOTTOM w0.152: U5.C2 190.15,156.22 v2(190.15,156.21)
FBA_EDC1: length 18.1
  IN2 w0.102: 199.37,155.14 199.37,155.8 v2(198.97,156.21)
  IN2 w0.14: 191.02,145.25 191.02,144.63 v1(190.56,144.17)
  IN2 w0.17: 199.37,155.14 199.37,155.04 199.62,154.79 199.62,153.81 195.09,149.28 193.64,149.28 192.18,147.82 192.18,146.42 191.02,145.25
  BOTTOM w0.127: U3002.G31 190.56,144.16 v1(190.56,144.17)
  BOTTOM w0.152: U5.C13 198.96,156.21 v2(198.97,156.21)
FBA_EDC2: length 29.3
  BOTTOM w0.102: U5.R13 199.01,166.67 199.49,166.67 199.57,166.75 200.18,166.75
  BOTTOM w0.127: U3002.E33 192.63,145.61 193.01,146 193.01,146.29 192.81,146.5
  BOTTOM w0.152: 200.18,166.75 200.43,166.75 201.86,165.32 201.86,154.58 v1(197.29,150.01) 196.7,149.42 194.67,149.42 192.81,147.56 192.81,146.5
FBA_EDC3: length 23.9
  BOTTOM w0.102: 186.68,146.5 186.47,146.29 186.47,145.93 186.83,145.58 U3002.M33
  BOTTOM w0.127: 186.75,147.71 186.75,146.56 186.68,146.5 186.68,146.5 ; 188.14,165.82 189.35,165.82 U5.R2
  BOTTOM w0.152: 186.75,147.71 187.2,148.17 v1(187.2,150.87) 187.2,153.46 186.37,154.3 186.37,164.26 187.92,165.81 188.12,165.81 188.12,165.82 188.14,165.82
FBA_EDC4: length 15.4
  IN2 w0.102: v2(175.55,144.17) 176.13,144.75 176.13,145.71 176.38,145.97 176.38,147.03 176.21,147.21
  IN2 w0.17: v2(178.78,156.19) 179.63,155.33 179.63,153.71 176.18,150.26 176.18,147.24 176.21,147.21
  BOTTOM w0.127: U3002.AE31 v2(175.55,144.17)
  BOTTOM w0.152: v2(178.78,156.19) 178.78,156.19 U7.R2
FBA_EDC5: length 15.2
  IN2 w0.102: 168.81,154.3 168.81,155.57 169.23,155.98 v2(169.23,156.19)
  IN2 w0.114: 171,144.79 171,143.66 v1(171.33,143.34)
  IN2 w0.17: 171,144.79 170.01,145.79 170.01,152.19 168.81,153.38 168.81,154.3
  BOTTOM w0.127: U3002.AK30 v1(171.33,143.34)
  BOTTOM w0.152: U7.R13 169.58,156.54 v2(169.23,156.19)
FBA_EDC6: length 26.6
  IN1 w0.14: v2(169.98,166.59) 169.98,165.99 169.72,165.73 167.93,165.73 167.92,165.73
  IN1 w0.17: 167.92,165.73 167.6,165.73 165.85,163.99 165.85,155.59 166.27,155.18 166.27,150.22 168.99,147.49 v1(169.09,147.49)
  BOTTOM w0.152: v1(169.09,147.49) 169.72,146.86 169.72,145.92 169.33,145.52 U3002.AN33 ; v2(169.98,166.59) U7.C13
FBA_EDC7: length 27.1
  BOTTOM w0.102: 175.16,147.09 175.16,146.61 175.48,146.29 175.48,145.99 175.29,145.8 175.29,145.51 U3002.AF33
  BOTTOM w0.152: 175.16,147.09 175.16,148.13 174.96,148.33 174.96,150.02 v1(176.85,151.91) 177.61,152.67 179.45,152.67 181.32,154.54 181.32,164.77 180.24,165.85 179.38,165.85 179.36,165.82 178.75,165.82 U7.C2
FBB_CMD0: length 28.8
  IN1 w0.102: v1(193.91,129.08) 193.5,128.67 193,128.67 192.72,128.39 192.72,127.98 193.38,127.32 194.47,127.32 194.87,126.92 ; v2(210.98,119.2) 210.58,118.8 210.58,117.3
  IN1 w0.17: 194.87,126.92 194.87,124.76 196.69,122.94 197.96,122.94 203.28,117.62 208.08,117.62 208.62,117.09 210.37,117.09 210.58,117.3
  BOTTOM w0.152: U3.G12 211.38,119.6 v2(210.98,119.2) ; v1(193.91,129.08) 193.53,128.7 U3002.D13
FBB_CMD1: length 33.4
  IN1 w0.089: v2(193.12,129.11) 193.05,129.11 192.64,128.7 192,128.7 191.85,128.54 191.85,128.06 192.16,127.76 192.46,127.76 193.19,127.03 194.28,127.03 194.47,126.84 194.47,126.59
  IN1 w0.102: 211.38,118.92 211.38,120.42 v2(211.77,120.8)
  IN1 w0.17: 194.47,126.59 194.29,126.41 194.29,124.45 196.4,122.35 197.67,122.35 202.88,117.14 207.75,117.14 208.44,116.45 210.85,116.45 211.46,117.06 211.46,118.74 211.38,118.82 211.38,118.92
  BOTTOM w0.152: U3.H10 212.17,121.2 v2(211.77,120.8)
  BOTTOM w0.178: v2(193.12,129.11) 193.12,129.14 U3002.E14
FBB_CMD2: length 33.3
  IN1 w0.079: v1(191.52,129.03) 191.04,128.54 191.04,128.01 191.19,127.86 191.6,127.86 191.83,127.63 191.83,127.22 192,127.05 192.56,127.05 192.74,126.87 192.74,126.33
  IN1 w0.17: 192.74,126.33 192.74,126.13 192.59,125.98 192.59,125.39 196.2,121.79 197.29,121.79 203.13,115.95 211.08,115.95 211.97,116.83 211.97,118.48 211.78,118.66 v2(211.78,120)
  BOTTOM w0.152: v2(211.78,120) 212.18,120.4 U3.H11
  BOTTOM w0.178: U3002.F14 191.52,129.19 v1(191.52,129.03)
FBB_CMD3: length 21
  IN1 w0.17: v1(196.63,127.76) 197.14,127.25 197.57,127.25 202.9,121.91 212.35,121.91 213.25,121.01 213.25,120.93 v2(213.38,120.8)
  BOTTOM w0.152: v2(213.38,120.8) U3.K11
  BOTTOM w0.178: v1(196.63,127.76) 196.55,127.84 U3002.A12
FBB_CMD4: length 24.2
  IN1 w0.17: v2(214.18,120.8) 214.26,120.8 214.64,121.18 214.64,121.89 214.15,122.37 203.21,122.37 197.92,127.65 197.6,127.65 v2(197.3,127.95)
  BOTTOM w0.152: v2(214.18,120.8) U3.K10
  BOTTOM w0.178: v2(197.3,127.95) 197.01,128.24 195.53,128.24 U3002.B12
FBB_CMD5: length 28
  IN1 w0.17: v2(197.91,128.19) 198.15,128.19 203.51,122.83 214.23,122.83 214.94,122.12 214.94,119.95 v2(214.18,119.2)
  BOTTOM w0.152: U3.L12 214.58,119.6 v2(214.18,119.2)
  BOTTOM w0.178: v2(197.91,128.19) 197.91,128.52 197.8,128.63 197.8,128.78 197.43,129.15 196.56,129.15 196.26,128.85 195.64,128.85 195.33,129.16 194.71,129.16 U3002.C14
FBB_CMD6: length 25.2
  IN1 w0.17: v1(198.25,128.81) 203.77,123.29 212.81,123.29 214.69,125.17 214.69,125.72 214.18,126.23 v2(214.18,126.4)
  BOTTOM w0.152: v2(214.18,126.4) U3.K4
  BOTTOM w0.178: U3002.B14 195.39,129.54 195.77,129.16 196.17,129.16 196.44,129.43 197.63,129.43 v1(198.25,128.81)
