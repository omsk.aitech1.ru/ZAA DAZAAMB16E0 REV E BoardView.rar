# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TX5+: length 11
  BOTTOM w0.076: U35.A23 127.41,123.68 127.41,123.57 127.34,123.49 127.19,123.49 127.08,123.59 127.08,123.59
  BOTTOM w0.079: 127.08,123.59 127.08,124.38 126.86,124.61 126.86,125.16 127.23,125.53 127.23,128.05 127.26,128.09
  BOTTOM w0.114: C669.1 128.42,132.95 128.34,132.87 128.34,132.54 127.26,131.46 127.26,128.09 127.26,128.09
PCIE_TX5+_LAN: length 151.5
  TOP w0.114: v1(32.62,69.77) 32.8,69.95 32.8,70.2 33.18,70.58 33.18,71.06 33.78,71.66 U15.21
  IN2 w0.114: v1(129.37,135.1) 129.1,134.83 129.1,134.68 128.82,134.4 127.86,134.4 126.56,133.1 124.35,133.1 122.12,130.87 115.31,130.87 114.66,130.22 112.11,130.22 111.46,130.87 111.09,130.87 110.71,131.25 109.75,131.25 108.51,130.01 104.61,130.01 104.16,130.46 104.16,131.32 103.19,132.3 102.42,132.3 101.99,131.87 99.88,131.87 98.86,130.86 95.62,130.86 95.06,131.42 92.18,131.42 90.67,129.92 86.19,129.92 73.31,117.04 62.95,117.04 61.18,115.27 50.6,115.27 40.8,105.47 40.8,82.85 40.04,82.09 40.04,79.01 38.74,77.72 38.74,73.91 38.08,73.25 37.62,73.25 37.06,72.69 37.06,72.08 36.56,71.57 36.05,71.57 34.96,70.48 34.96,69.89 34.15,69.08 33.13,69.08 32.85,69.36 32.85,69.54 v1(32.62,69.77)
  BOTTOM w0.114: C669.2 128.56,133.96 128.56,134.16 129.11,134.72 129.11,134.84 v1(129.37,135.1)
PCIE_TX5-: length 11
  BOTTOM w0.076: 126.92,123.53 U35.B23
  BOTTOM w0.079: 127.04,128.09 127.04,128.07 127.06,128.05 127.06,125.6 126.69,125.23 126.69,124.54 126.92,124.31 126.92,123.53
  BOTTOM w0.114: 127.04,128.09 127.04,131.55 128.12,132.63 128.12,132.84 128.01,132.95 C668.1
PCIE_TX5-_LAN: length 151.5
  TOP w0.114: v1(33.28,69.77) 33.13,69.77 33.03,69.86 33.03,69.94 33.01,69.96 33.01,70.11 33.39,70.49 33.39,70.97 33.87,71.45 34.09,71.45 34.27,71.26 U15.22
  IN2 w0.114: v1(33.28,69.77) 33.15,69.77 33.06,69.68 33.06,69.45 33.22,69.3 34.06,69.3 34.74,69.97 34.74,70.57 35.96,71.79 36.47,71.79 36.85,72.17 36.85,72.78 37.53,73.46 37.99,73.46 38.53,74 38.53,77.81 39.82,79.1 39.82,82.18 40.58,82.94 40.58,105.56 50.51,115.49 61.09,115.49 62.86,117.26 73.22,117.26 86.1,130.13 90.59,130.13 92.09,131.63 95.15,131.63 95.71,131.07 98.77,131.07 99.79,132.09 101.9,132.09 102.33,132.51 103.28,132.51 104.37,131.41 104.37,130.55 104.7,130.23 108.42,130.23 109.66,131.46 110.8,131.46 111.18,131.08 111.55,131.08 112.2,130.44 114.57,130.44 115.22,131.08 122.03,131.08 124.26,133.32 126.47,133.32 127.77,134.61 128.73,134.61 128.89,134.77 128.89,134.87 v1(128.68,135.07)
  BOTTOM w0.114: v1(128.68,135.07) 128.76,135.07 128.89,134.94 128.89,134.79 128.34,134.25 128.34,133.57 128.24,133.47 127.9,133.47 127.79,133.57 C668.2
PCIE_TX6+: length 8.4
  BOTTOM w0.076: 127.36,124.63 127.36,124.62 127.71,124.28 127.71,124.04 127.81,123.94 127.81,123.56 127.79,123.5 127.77,123.45 127.77,123.36 127.83,123.16 127.83,123 127.75,122.76 127.68,122.58 127.52,122.41 U35.C23
  BOTTOM w0.079: 128.33,128.09 128.33,128.07 128.3,128.04 128.3,125.95 127.36,125.02 127.36,124.63
  BOTTOM w0.114: C649.1 128.83,129.17 128.69,129.32 128.37,129.32 128.33,129.28 128.33,128.09
PCIE_TX6+_WLAN: length 120.9
  IN2 w0.114: v1(196.45,174.87) 196.18,174.61 196.18,174.38 195.94,174.14 195.46,174.14 194.68,174.91 193.34,174.91 192.72,174.29 192.72,172.15 190.76,170.2 167.34,170.2 162.95,165.81 162.44,165.81 161.96,165.32 161.96,164.64 159.65,162.33 159.65,157.71 156.88,154.95 156.88,149.19 158.9,147.18 158.9,142.83 159.92,141.8 159.92,138.2 157.58,135.85 153.59,135.85 153,135.26 151,135.26 150.58,134.84 139.94,134.84 138.7,133.6 130.87,133.6 129.65,132.38 128.86,132.38 128.45,131.97 128.45,131.78 128.66,131.57 v1(128.69,131.57)
  BOTTOM w0.114: v1(196.45,174.87) 196.2,175.13 196.2,175.38 197,176.18 197,177.83 196.49,178.34 195.55,178.34 195.17,178.72 195.17,181.49 193.31,183.34 192.07,183.34 191.91,183.5 CN10.35 ; C649.2 128.61,130.02 128.61,130.34 128.47,130.49 128.47,131.34 v1(128.69,131.57)
PCIE_TX6-: length 8.5
  BOTTOM w0.076: U35.D23 127.38,122 127.09,122.29 127.09,122.53 127.13,122.58 127.13,122.6 127.28,122.74 127.57,122.74 127.59,122.82 127.67,123.03 127.67,123.14 127.6,123.33 127.6,123.49 127.64,123.57 127.65,123.59 127.65,123.87 127.55,123.97 127.55,124.21 127.2,124.56
  BOTTOM w0.079: 128.11,128.09 128.11,128.07 128.13,128.04 128.13,126.02 127.2,125.09 127.2,124.56
  BOTTOM w0.114: 128.11,128.09 128.11,128.78 C648.1
PCIE_TX6-_WLAN: length 120.9
  IN2 w0.114: v1(128.03,131.57) 128.05,131.57 128.24,131.75 128.24,132.06 128.77,132.6 129.56,132.6 130.78,133.81 138.61,133.81 139.85,135.06 150.49,135.06 150.91,135.48 152.91,135.48 153.5,136.06 157.49,136.06 159.71,138.28 159.71,141.71 158.68,142.74 158.68,147.09 156.66,149.1 156.66,155.03 159.43,157.8 159.43,162.42 161.74,164.73 161.74,165.41 162.35,166.02 162.86,166.02 167.25,170.42 190.67,170.42 192.5,172.24 192.5,174.38 193.25,175.13 194.77,175.13 195.55,174.35 195.85,174.35 195.97,174.47 195.97,174.59 v1(195.69,174.87)
  BOTTOM w0.114: C648.2 128.26,129.8 128.39,129.93 128.39,130.25 128.25,130.4 128.25,131.34 v1(128.03,131.57) ; v1(195.69,174.87) 195.98,175.17 195.98,175.47 196.78,176.27 196.78,177.74 196.4,178.12 195.46,178.12 194.95,178.63 194.95,181.4 193.22,183.13 192.08,183.13 191.95,183 CN10.37
PCLK_TPM: length 39.9
  IN2 w0.14: v1(166.86,89.68) 166.86,86.25 166.55,85.95 166.55,84.97 165.77,84.18 165.77,82.2 166.06,81.9 166.06,79.53 166.16,79.44 166.16,78.15 165.69,77.68 165.69,76.12 v1(165.56,75.99)
  BOTTOM w0.102: U44.19 165.12,75.55 v1(165.56,75.99)
  BOTTOM w0.14: R626.1 153.55,93.91 153.55,91.71 153.98,91.28 153.98,90.01 154.46,89.53 156.29,89.53 158.53,91.76 160.99,91.76 161.63,92.4 162.46,92.4 162.67,92.6 162.67,93.25 163.08,93.67 164.27,93.67 164.46,93.48 164.46,91.73 v1(166.18,90.01) 166.5,89.68 v1(166.86,89.68)
PD#: length 15.6
  BOTTOM w0.102: 200.72,34.2 U23.47
  BOTTOM w0.127: 200.72,34.2 200.69,34.2 199.95,34.94 199.95,35.91 199.42,36.44 199.42,39.59 199.17,39.85 198.71,39.85 198.5,40.06 198.5,40.76 R372.2 R369.1 C494.1 197.16,41.95 D15.2 D16.2 v1(194.62,41.57)
PEG_RX0: length 36.5
  IN2 w0.076: 134.79,121.8 134.5,121.51 134.5,121.22 134.42,121.13 134.42,120.2 134.41,120.19 134.41,120.04 134.32,119.96 134.12,119.96 v2(134.04,120.04)
  IN2 w0.114: 134.79,121.8 135.58,121.8 136.54,122.77 139.67,122.77 140.16,122.27 142.25,122.27 142.56,122.59 144.9,122.59 146.3,123.98 157.78,123.98 158.22,123.54 158.58,123.54 158.71,123.67 v1(158.71,123.95)
  BOTTOM w0.114: v1(158.71,123.95) 159.06,123.95 159.82,124.71 159.82,125.75 158.78,126.79 158.78,128.9 159.4,129.52 159.78,129.52 C4015.1 ; v2(134.04,120.04) 133.74,120.04 133.58,119.88 U35.G13
PEG_RX1: length 35
  IN2 w0.114: v1(159.83,123.07) 159.83,122.82 159.53,122.51 158.1,122.51 157.33,123.27 148.2,123.27 147.48,122.55 146.16,122.55 145,121.39 139.92,121.39 139.26,122.05 136.52,122.05 135.78,121.32 135.42,121.32 135.16,121.06 135.16,120.77 v2(134.98,120.59)
  BOTTOM w0.102: v2(134.98,120.59) 134.88,120.7 134.6,120.7 134.5,120.59 U35.F11
  BOTTOM w0.114: v1(159.83,123.07) 160.16,123.07 160.5,123.42 160.68,123.59 160.68,127.55 161.19,128.06 161.88,128.06 161.97,128.15 C4017.1
PEG_RX2: length 40.6
  IN2 w0.079: 132.47,121.81 132.55,121.72 132.55,119.92 132.43,119.8 132.34,119.8 v2(132.16,119.98)
  IN2 w0.114: v1(156.93,125.67) 156.66,125.41 145.62,125.41 144.45,124.24 136.21,124.24 135.02,123.04 132.96,123.04 132.38,122.46 132.38,121.9 132.47,121.81
  BOTTOM w0.114: v1(156.93,125.67) 157.21,125.67 157.36,125.83 157.36,130.09 159.58,132.32 160.14,132.32 161.13,133.31 161.66,133.31 C4020.1 ; U35.G16 131.75,119.96 131.82,120.03 132.11,120.03 v2(132.16,119.98)
PEG_RX3: length 39.4
  IN2 w0.079: 133.51,121.85 133.5,121.85 133.5,121.82 133.47,121.79 133.46,121.63 133.48,121.62 133.48,119.98 133.34,119.84 133.25,119.84 v2(133.12,119.96)
  IN2 w0.114: v1(158.25,125.17) 158.25,124.89 158.06,124.7 145.92,124.7 144.67,123.45 142.28,123.45 141.87,123.03 140.57,123.03 140.13,123.48 136.47,123.48 135.39,122.4 134.05,122.4 133.51,121.85
  BOTTOM w0.114: U35.F15 132.67,120.32 133.02,119.96 v2(133.12,119.96) ; C4022.1 161.59,131.08 159.52,131.08 158.07,129.64 158.07,126.49 158.73,125.83 158.73,125.34 158.55,125.17 v1(158.25,125.17)
PEG_RX#0: length 36.5
  IN2 w0.076: 134.88,121.58 134.67,121.37 134.67,121.15 134.58,121.07 134.58,120.13 134.57,120.12 134.57,119.95 v2(134.03,119.4)
  IN2 w0.114: 134.88,121.58 135.67,121.58 136.63,122.55 139.58,122.55 140.07,122.05 142.33,122.05 142.65,122.37 144.99,122.37 146.39,123.77 157.69,123.77 158.13,123.32 158.67,123.32 158.81,123.46 v1(159.16,123.46)
  BOTTOM w0.114: U35.H13 133.94,119.4 v2(134.03,119.4) ; v1(159.16,123.46) 159.16,123.74 160.04,124.62 160.04,125.84 159,126.88 159,128.81 159.49,129.31 159.69,129.31 C4016.1
PEG_RX#1: length 35
  IN2 w0.102: v2(134.95,119.96) 134.95,120.01 135.38,120.43 135.38,120.99 135.38,120.99
  IN2 w0.114: v1(160.31,122.6) 159.92,122.6 159.62,122.3 158.01,122.3 157.24,123.06 148.29,123.06 147.57,122.33 146.25,122.33 145.09,121.18 139.83,121.18 139.17,121.84 136.61,121.84 135.88,121.11 135.5,121.11 135.38,120.99
  BOTTOM w0.102: U35.G11 134.69,119.69 v2(134.95,119.96)
  BOTTOM w0.114: v1(160.31,122.6) 160.31,122.92 160.65,123.26 160.89,123.5 160.89,127.46 161.28,127.85 161.66,127.85 C4018.1
PEG_RX#2: length 40.6
  IN2 w0.079: v2(132.19,119.33) 132.23,119.33 132.72,119.81 132.72,121.88
  IN2 w0.114: 132.72,121.88 132.59,122 132.59,122.37 133.05,122.83 135.11,122.83 136.3,124.02 144.54,124.02 145.71,125.19 157.38,125.19 v1(157.41,125.22)
  BOTTOM w0.114: v1(157.41,125.22) 157.41,125.57 157.57,125.74 157.57,130 159.67,132.1 160.23,132.1 161.22,133.09 161.67,133.09 C4021.1 ; v2(132.19,119.33) 131.9,119.04 U35.H16
PEG_RX#3: length 39.4
  IN2 w0.079: 133.65,121.71 133.65,121.71 133.65,119.86 v2(133.12,119.34)
  IN2 w0.114: 133.65,121.71 134.12,122.18 135.48,122.18 136.56,123.26 140.04,123.26 140.48,122.82 141.95,122.82 142.37,123.24 144.76,123.24 146.01,124.48 158.15,124.48 158.35,124.68 v1(158.71,124.68)
  BOTTOM w0.114: U35.G15 133.02,119.34 v2(133.12,119.34) ; v1(158.71,124.68) 158.71,125.01 158.95,125.25 158.95,125.91 158.29,126.58 158.29,129.55 159.61,130.87 161.68,130.87 C4023.1
PEG_RXN0_C: length 14.7
  IN2 w0.114: v1(164.52,130.32) 164.55,130.35 164.55,130.58 165.75,131.78 168.75,131.78 169.88,130.65 169.88,130.02 170.34,129.56 171.05,129.56 171.1,129.51 171.56,129.51 171.99,129.94 v1(172.14,129.94)
  BOTTOM w0.114: v1(172.14,129.94) 172.54,129.54 U3002.AJ14 ; v1(164.52,130.32) 164.19,130.32 163.13,129.26 161.18,129.26 C4016.2
PEG_RXN1_C: length 15.2
  IN2 w0.114: v1(165.74,129.03) 165.74,129.47 166.13,129.86 166.13,130.11 167.08,131.05 167.89,131.05 169.13,129.8 169.13,129.5 169.84,128.79 171.62,128.79 172.03,129.19 173.25,129.19 173.61,129.56 173.61,129.75 173.79,129.92 v1(173.82,129.92)
  BOTTOM w0.114: v1(165.74,129.03) 165.74,129.02 165.33,129.02 164.2,127.89 163.12,127.89 162.75,127.53 C4018.2 ; v1(173.82,129.92) 174.2,129.54 U3002.AG14
PEG_RXN2_C: length 15.2
  IN2 w0.114: v1(163.68,132.86) 163.9,133.08 164.13,133.08 164.46,133.41 164.55,133.41 169.41,133.41 170.31,132.51 171.96,132.51 172.98,131.49 173.4,131.07 173.4,130.79 173.2,130.59 172.69,130.59 172.57,130.7 172.57,130.99 v2(172.66,131.08)
  BOTTOM w0.114: U3002.AJ15 172.95,130.34 173.06,130.44 173.06,130.98 172.95,131.08 v2(172.66,131.08) ; C4021.2 163.11,133.09 163.46,133.09 v1(163.68,132.86)
PEG_RXN3_C: length 12.2
  IN2 w0.114: v1(164.01,131.59) 164.01,131.95 164.61,132.54 169.03,132.54 170.73,130.84 171.44,130.84 171.77,131.17 171.77,131.35 172,131.58 v2(172.13,131.58)
  BOTTOM w0.114: C4023.2 162.75,130.84 162.82,130.91 163.11,130.91 163.8,131.59 v1(164.01,131.59) ; v2(172.13,131.58) 171.74,131.19 U3002.AK16
PEG_RXP0_C: length 14.7
  IN2 w0.114: v2(171.31,129.95) 171.14,129.78 170.43,129.78 170.1,130.11 170.1,130.74 168.84,132 165.66,132 164.47,130.8 164.12,130.8 v1(164.09,130.83)
  BOTTOM w0.114: C4015.2 161.18,129.48 163.04,129.48 164.09,130.53 v1(164.09,130.83) ; U3002.AK14 171.73,129.26 171.63,129.15 171.42,129.15 171.31,129.26 v2(171.31,129.95)
PEG_RXP1_C: length 15.2
  IN2 w0.114: v2(173.01,129.92) 173.07,129.98 173.28,129.98 173.4,129.87 173.4,129.65 173.16,129.41 171.94,129.41 171.53,129 169.93,129 169.35,129.59 169.35,129.89 167.98,131.26 166.99,131.26 165.92,130.19 165.92,129.95 165.47,129.51 v1(165.28,129.51)
  BOTTOM w0.114: v1(165.28,129.51) 165.28,129.28 164.11,128.11 163.06,128.11 162.75,128.42 C4017.2 ; v2(173.01,129.92) 173.01,129.64 173.11,129.54 U3002.AH14
PEG_RXP2_C: length 15.1
  IN2 w0.114: v1(163.66,133.52) 163.66,133.52 163.88,133.29 164.04,133.29 164.37,133.62 164.64,133.62 169.5,133.62 170.4,132.72 172.05,132.72 173.2,131.58 173.62,131.16 173.62,130.7 173.29,130.37 172.6,130.37 172.46,130.51 172.23,130.74 v2(172.13,130.74)
  BOTTOM w0.114: C4020.2 163.12,133.31 163.44,133.31 v1(163.66,133.52) ; U3002.AK15 v2(172.13,130.74)
PEG_RXP3_C: length 12.2
  IN2 w0.114: v1(163.58,132.1) 163.86,132.1 164.52,132.76 169.12,132.76 170.82,131.06 171.35,131.06 171.56,131.26 171.56,131.34 v2(171.32,131.58)
  BOTTOM w0.114: v2(171.32,131.58) 171.32,131.11 171.21,131.01 171.03,131.01 170.93,131.11 U3002.AL16 ; v1(163.58,132.1) 163.58,131.68 163.06,131.16 163.06,131.16 162.82,131.16 162.75,131.23 C4022.2
PEG_TX0: length 46.3
  IN2 w0.114: v1(167.3,130.54) 167.32,130.54 167.56,130.3 167.76,130.3 168.26,129.8 168.26,127.83 168.43,127.65 169.04,127.65 169.22,127.83 169.22,127.96 v1(168.92,128.26)
  BOTTOM w0.114: U3002.AN12 169.33,127.85 v1(168.92,128.26) ; v1(167.3,130.54) 167.06,130.3 166.93,130.3 166.8,130.44 166.8,131 166.25,131.54 166.25,134.06 165,135.3 156.44,135.3 152.37,139.38 141.45,139.38 138.89,136.82 138.89,131.75 C652.1
PEG_TX1: length 43.9
  BOTTOM w0.114: U3002.AN14 169.18,129.39 169.03,129.39 168.7,129.06 167,129.06 166.02,130.04 166.02,130.55 165.54,131.03 165.54,133.75 164.7,134.59 160.58,134.59 159.91,133.92 156.81,133.92 152.06,138.67 141.75,138.67 139.86,136.77 v1(139.86,132.86) 140.62,132.86 140.65,132.84 140.73,132.75 141.3,132.18 141.3,131.36 141.22,131.27 140.85,131.27 C655.1
PEG_TX2: length 44.8
  BOTTOM w0.114: U3002.AP14 168.54,129.54 168.64,129.64 168.64,129.83 168.54,129.93 168.12,129.93 167.89,130.16 167.89,130.66 166.74,131.81 166.74,134.52 165.46,135.81 156.67,135.81 152.61,139.87 141.2,139.87 136.82,135.48 136.82,134.05 v1(137.34,133.52) 136.82,133 136.82,131.75 137.22,131.35 C662.1
PEG_TX3: length 48.2
  BOTTOM w0.114: U3002.AN15 169.33,130.02 169.23,129.92 168.99,129.92 168.89,130.02 168.89,130.73 167.57,132.05 167.57,135.15 166.14,136.58 161.87,136.58 161.87,136.58 156.91,136.58 152.91,140.58 140.9,140.58 136.01,135.69 v1(136.01,134.96) 136.01,134.96 135.28,134.96 134.32,134 132.64,134 132.3,133.66 132.3,133.28 132.38,133.2 C660.1
PEG_TX#0: length 46.3
  IN2 w0.114: v1(167.32,129.84) 167.56,130.08 167.67,130.08 168.04,129.71 168.04,127.74 168.34,127.44 169.13,127.44 169.44,127.74 169.44,127.95 v2(169.75,128.26)
  BOTTOM w0.114: v1(167.32,129.84) 167.07,130.08 166.85,130.08 166.58,130.35 166.58,130.91 166.03,131.45 166.03,133.97 164.91,135.08 156.36,135.08 152.28,139.16 141.53,139.16 139.1,136.73 139.1,131.75 C653.2 ; v2(169.75,128.26) 169.75,128.24 170.13,127.87 U3002.AM12
PEG_TX#1: length 43.9
  BOTTOM w0.114: U3002.AM14 169.77,129.18 169.12,129.18 168.79,128.85 166.91,128.85 165.8,129.95 165.8,130.46 165.32,130.94 165.32,133.66 164.61,134.37 160.67,134.37 160,133.7 156.72,133.7 151.97,138.45 141.84,138.45 140.07,136.68 140.07,133.83 140.14,133.76 v1(140.76,133.76) 140.76,133.03 140.8,132.99 140.86,132.93 140.89,132.9 141.52,132.27 141.52,131.62 C656.1
PEG_TX#2: length 44.8
  BOTTOM w0.114: U3002.AP15 168.53,130.25 168.43,130.14 168.2,130.14 168.1,130.25 168.1,130.75 166.96,131.9 166.96,134.61 165.55,136.02 156.76,136.02 152.7,140.09 141.12,140.09 136.6,135.57 136.6,134.05 v1(136.07,133.52) 136.6,133 136.6,131.75 136.2,131.35 C661.1
PEG_TX#3: length 48.2
  BOTTOM w0.114: U3002.AM15 169.65,130.82 169.11,130.82 167.79,132.14 167.79,135.24 166.22,136.8 161.96,136.8 161.96,136.8 157,136.8 153,140.8 140.81,140.8 135.87,135.86 v1(135.11,135.86) 135.11,135.1 134.23,134.22 132.56,134.22 132.09,133.75 132.09,133.43 C654.1
PEGX_RST#: length 85.7
  TOP w0.127: Q4301.2 v1(172.12,113.64) 173.04,113.64 173.28,113.89 173.28,114.68 173.16,114.8 173.16,116.76 v1(172.73,117.19)
  IN2 w0.14: v1(172.73,117.19) 176.76,113.15 176.76,111.07 178.11,109.72 178.77,109.07 178.77,107.28 179.3,106.75 179.97,106.75 180.55,106.17 180.55,104.82 181.57,103.8 192.97,103.8 193.63,103.14 211.31,103.14 211.93,103.77 211.93,106.71 214.71,109.49 215.12,109.49 v1(215.53,109.09)
  BOTTOM w0.102: U3002.AJ12 172.96,127.46
  BOTTOM w0.127: v1(172.73,117.19) 173.01,117.47 173.01,126.9 172.96,126.95 172.96,127.46 ; R4007.1 217.49,107.81 U4002.4 219.3,107.34 R4005.2 R4004.1 221.12,107.57 221.34,107.79 221.34,109.11 220.77,109.68 216.12,109.68 v1(215.53,109.09)
PEX_CLKREQ#: length 18.1
  TOP w0.114: v1(171.33,127.44) 171.17,127.44 R4008.1
  IN2 w0.114: v1(172.45,118.03) 172.45,119.27 170.95,120.77 170.34,120.77 169.28,121.83 169.28,122.78 169.55,123.06 169.55,125.66 v1(171.33,127.44)
  BOTTOM w0.114: U3002.AK12 v1(171.33,127.44) ; Q4002.1 171.18,115.29 171.18,116.76 v1(172.45,118.03)
PEX_PLLVDD: length 0.6
  BOTTOM w0.381: U3002.AG26 174.23,139.54 v1(173.83,139.94)
  vias: v1(173.16,140.86)
PEX_TERMP: length 4.5
  BOTTOM w0.127: R4009.2 165.32,144.29 167.57,142.04 U3002.AP29
PEX_TSTCLK: length 14.6
  BOTTOM w0.127: U3002.AJ26 172.58,139.42 172.29,139.14 171.56,139.14 171.33,138.91 171.33,138.42 171.2,138.3 167.32,138.3 166.81,138.81 166.81,141.5 165.54,142.77 164.7,142.77 164.19,143.28 R4006.2 163.73,143.28 v1(162.85,144.16)
PEX_TSTCLK#: length 9.6
  BOTTOM w0.127: U3002.AK26 171.5,139.54 171.1,139.14 168.2,139.14 167.98,139.36 167.98,140.84 165.54,143.28 R4006.1
PIRQA#: length 24.8
  BOTTOM w0.127: R631.1 152.19,90.71 v1(151.41,91.49) 151.09,91.82 151.09,96.26 148.39,98.95 144.96,98.95 144.71,98.7 139.5,98.7 138.99,99.21 136.23,99.21 134.69,100.74 U35.BB11
PLLVDD: length 1.2
  BOTTOM w0.381: v1(176.39,124.02) 176.42,124 176.47,124 U3002.AD7 ; v1(175.56,124.07) 175.92,124.44 U3002.AE8
  vias: v1(174.76,124.43)
PLTRST#: length 497.8
  TOP w0.127: v1(188.4,34.39) 187.1,34.39 186.16,33.45 183.11,33.45 182.84,33.17 180.7,33.17 178.9,34.97 178.24,34.97 178.11,34.84 176.64,34.84 176.31,35.17 175.6,35.17 v1(175.34,34.92) 175.16,34.92 v1(173.21,32.96) ; v1(33.84,58.06) 34.98,58.06 36.83,59.91 36.83,60.99 36.82,61 36.82,61.2 34.25,63.76 R11261.1
  IN1 w0.14: v1(162.11,91.94) 162.21,91.94 163.66,90.49 v1(163.66,87.95) ; v1(176.31,105.68) 175.8,106.19 174.25,106.19 173.06,105 173.06,100.02 172.85,99.82 172.85,91.56 173.74,90.67 v1(173.74,89.55)
  IN2 w0.14: v1(224.44,109.09) 224.57,109.09 225.08,109.6 225.08,110.51 224.4,111.18 224.4,142.01 224.83,142.44 224.83,155.2 220.26,159.77 215.77,159.77 214.81,160.73 208.77,160.73 206.92,162.57 206.92,163.66 206.48,164.1 206.48,165.51 205.46,166.53 205.46,169.57 205.06,169.98 205.06,174.06 204.46,174.65 204.46,178.55 v1(202.22,180.79) ; v1(147.61,23.06) 151.82,23.06 152.1,23.34 154.72,23.34 158.91,27.53 168.37,27.53 173.21,32.36 v1(173.21,32.96) ; v1(130.56,39.16) 128.35,39.16 124.89,42.63 120.55,42.63 120.08,43.1 94.14,43.1 92.44,44.8 92.44,54.38 91.52,55.29 81.11,55.29 78.97,57.42 78.97,67.51 75.28,71.21 67.29,71.21 66.9,70.82 56.36,70.82 55.48,69.95 53.93,69.95 51.39,67.41 51.39,66.87 48.8,64.28 48.8,63.09 47.1,61.4 45.17,61.4 44.69,60.92 43.27,60.92 42.12,59.76 39.27,59.76 37.72,58.21 34.58,58.21 34.42,58.06 v1(33.84,58.06) ; v1(168.43,89) 168.17,88.73 168.17,87.13 167.9,86.86 167.9,85.9 167.49,85.49 167.49,84.53 166.81,83.84 166.81,82.75 167.06,82.49 167.06,81.48 167.8,80.74 167.8,80.21 167.34,79.75 167.34,77.59 167.19,77.44 v1(167.19,77.39) 167.19,77.21 167.23,77.17 167.23,73.46 167.41,73.28 167.41,67.75 173.28,61.88 173.28,60.89 173.77,60.41 173.77,50.57 172.62,49.42 172.62,45.7 172,45.07 172,44.48 171.09,43.57 168.99,43.57 168.81,43.76 163.84,43.76 161.04,40.96 161.04,39.9 156.8,35.66 155.78,35.66 149.84,29.71 145.22,29.71 145.15,29.78 v1(144.3,29.78)
  BOTTOM w0.102: 164.32,77.09 165.16,77.09 165.63,77.57
  BOTTOM w0.127: R742.1 164.32,77.09 ; 165.63,77.57 166.96,77.57 167.14,77.39 v1(167.19,77.39) ; R671.1 201.89,181.12 v1(202.22,180.79) ; R214.1 163.58,88.03 v1(163.66,87.95) 163.83,87.95 164.29,87.49 164.29,86.94 164.13,86.78 U14.4 ; v1(224.44,109.09) 224.57,109.09 225.1,109.62 225.1,112.52 224.92,112.69 223.15,112.69 220.64,110.19 215.91,110.19 215.24,109.52 212.73,109.52 211.61,108.4 208.9,108.4 208.61,108.12 C4030.2 U4001.2 211.04,107.2 211.21,107.03 211.21,106.04 209.53,104.36 208.21,104.36 207.21,103.36 193.04,103.36 192.61,103.79 187.23,103.79 186.85,104.17 180.85,104.17 180.47,104.55 180.47,105.71 180.14,106.04 179.03,106.04 178.03,105.05 177.48,105.05 176.84,105.68 v1(176.31,105.68) ; R749.1 188.86,33.93 v1(188.4,34.39) ; v1(147.61,23.06) 147.61,24.35 144.3,27.65 v1(144.3,29.78) 144.3,30.17 143.56,30.91 143.56,32.91 142.52,33.95 140.77,33.95 138.94,35.78 138.61,36.11 138.61,38.22 137.67,39.16 v1(130.56,39.16) ; v1(173.74,89.55) 174,89.3 174,88.82 173.62,88.44 173.13,88.44 172.85,88.72 172.85,88.79 172.47,89.17 171.47,89.17 171.22,89.43 170.72,89.43 170.29,89 v1(168.43,89) 166.08,89 164.76,90.32 163.66,90.32 163.12,90.86 R960.2 163.12,91.44 162.62,91.94 v1(162.11,91.94)
PLTRST#_EC: length 4.3
  BOTTOM w0.127: U45.22 188.06,33 v1(188.55,32.51) 189.65,32.51 C822.1 R749.2
PM_THRMTRIP#: length 1.8
  TOP w0.127: R10890.2 v1(115.53,43.96) 115.19,43.96 R10921.2
PMON: length 33.6
  TOP w0.127: v1(150.17,187.07) v1(150.65,186.58) 150.65,185.58 150.83,185.41 150.86,185.41 PR172.1
  TOP w0.203: v1(135.79,173.3) 136.11,172.98 PR25.2
  TOP w0.305: PR25.2 136.51,172.59 135.79,171.88 PR342.2 PC7.2
  IN2 w0.14: v1(135.79,173.3) 135.82,173.32 134.49,174.66 134.49,179.03 135.69,180.23 135.69,182.01 139.38,185.69 139.38,186.89 140.14,187.65 144.43,187.65 145.07,187.01 150.12,187.01 v1(150.17,187.07)
POA_AUTH_ERR: length 86.5
  IN2 w0.14: v1(181.08,30.47) 180.83,30.73 176.8,30.73 175.96,29.88 175.26,29.88 172.25,26.88 172.04,26.88 171.41,26.25 171.4,26.25 170.72,25.57 170.71,25.57 170.44,25.29 170.44,25.07 169.86,24.48 163.69,24.48 158.26,19.04 140.95,19.04 138.89,21.1 135.85,21.1 135.36,20.62 127.38,20.62 124.44,17.67 113.57,17.67 112.73,16.83 110.94,16.83 108.72,19.06 v1(108.72,19.98)
  BOTTOM w0.127: U45.48 179.58,28.64 181.13,30.2 181.13,30.42 v1(181.08,30.47) ; R11295.2 108.39,19.7 108.67,19.98 v1(108.72,19.98)
POA_EN#: length 82.9
  IN2 w0.14: v1(109.4,27.53) 109.74,27.53 110.34,26.93 113.51,26.93 114.69,25.75 117.35,25.75 118.89,24.21 118.89,23.94 119.45,23.39 122.65,23.39 124.25,24.99 151.02,24.99 151.44,25.41 153.69,25.41 158.94,30.66 165.95,30.66 167.87,32.58 168.38,32.58 169.91,34.11 170.54,34.11 172.95,36.52 v1(173.31,36.52)
  BOTTOM w0.127: v1(173.31,36.52) 172.99,36.2 U45.83 ; v1(109.4,27.53) 109.41,27.53 109.53,27.53 110.17,26.89 v1(110.17,26.18) 110.36,25.99 110.36,24.69 109.61,23.94 109.61,22.53 111.05,21.08 v1(111.05,20.21) 110.67,19.83 R11293.2
POA_FP_PWREN#: length 70.9
  TOP w0.127: v1(138.61,32.79) v1(137.98,32.15) 137.6,31.77 119.51,31.77 117.94,30.2 R11297.1
  IN2 w0.14: v1(141.1,23.67) 141.2,23.67 141.86,23 142.48,23 143.07,23.59 151.6,23.59 152.02,24.01 154.26,24.01 159.52,29.26 166.83,29.26 167.74,30.17 168.35,30.17 169.37,31.19 170.12,31.19 171.67,32.73 171.67,33.25 172.47,34.06 v1(172.85,34.06)
  BOTTOM w0.127: U45.76 172.32,33.4 172.85,33.93 v1(172.85,34.06) ; v1(141.1,23.67) 140.9,23.87 140.9,30.68 138.79,32.79 v1(138.61,32.79)
POA_POWERREQ: length 94.8
  IN2 w0.14: v1(184.11,32.4) 183.8,32.1 182.77,32.1 182.19,32.68 175.06,32.68 168.81,26.44 162.88,26.44 158.52,22.07 154.59,22.07 154.59,22.07 153.43,22.07 153.43,22.07 152.49,22.07 151.63,21.2 141.99,21.2 139.93,23.26 125.74,23.26 123.3,20.82 112.21,20.82 109.18,23.86 v1(109.18,24.81)
  BOTTOM w0.127: R11296.2 107.24,19.7 108.01,20.47 v1(108.26,20.47) 109.07,21.28 109.07,24.71 v1(109.18,24.81) ; U45.20 184.53,33.8 184.11,33.37 v1(184.11,32.4)
POA_PWR: length 9.3
  TOP w0.508: R2854.1 114.94,33.27 114.28,33.93 Q75.1 113.63,33.96 C3001.2 113.09,35.45 112.96,35.58 111.32,35.58 R866.1 111.3,35.58 R11289.1 R11288.1 R11290.1
POA_PWR_INT#: length 93.4
  IN2 w0.14: v1(183.47,32.58) 182.84,32.58 182.43,32.99 174.97,32.99 168.69,26.72 162.77,26.72 158.4,22.35 154.47,22.35 152.37,22.35 151.61,21.58 142.07,21.58 140.11,23.54 125.61,23.54 123.37,21.31 113.16,21.31 109.84,24.63 v1(109.84,24.81)
  BOTTOM w0.127: v1(183.47,32.58) 183.47,33.12 184.55,34.2 U45.19 ; v1(109.84,24.81) 109.35,24.33 109.35,22.42 110.53,21.25 110.53,20.83 110.1,20.4 109.72,20.4 v1(109.53,20.21) R11294.2
PROC_PWRGD: length 8.5
  BOTTOM w0.079: R544.2 95.55,124.46 95.55,124.37
  BOTTOM w0.114: 101.27,124.39 U35.A68
  BOTTOM w0.127: R544.2 95.71,124.62 R554.1 97.11,124.62 97.34,124.39 101.27,124.39 ; 95.55,124.37 95.34,124.16 94.38,124.16 v1(94.14,123.92)
PROCHOT_EC: length 5.9
  BOTTOM w0.127: Q30.2 191.57,33.61 v1(190.97,34.21) R380.2 189.73,34.54 188.93,34.54 188.47,35 U45.17
PS_FB_CLAMP: length 12.4
  BOTTOM w0.127: R856.1 198.04,110.23 198.3,110.49 198.3,111.43 198.81,111.94
  BOTTOM w0.14: U3002.E1 192.63,118.34 194.75,116.22 195.84,116.22 198.32,113.75 v1(198.32,113.62) 198.81,113.13 198.81,111.94
PTP_PWR_EN#: length 68.1
  IN2 w0.14: v1(177.73,37.74) 175.44,35.45 173.08,35.45 171.11,33.48 171.11,32.96 169.89,31.74 168.22,31.74 166.3,29.82 159.29,29.82 154.03,24.57 151.79,24.57 151.37,24.15 142.58,24.15 v1(142.17,23.74)
  BOTTOM w0.127: U45.125 184.38,42.08 180.88,38.58 179.94,38.58 179.36,37.99 177.98,37.99 v1(177.73,37.74) ; v1(142.17,23.74) 142.17,23.69 137.67,19.2 137.67,18 137.55,17.88 135.92,17.88 135.77,18.03 135.77,19.32 135.54,19.55 132.75,19.55 130.99,17.8 R754.1
PWM1_B: length 32.6
  TOP w0.203: PR27.1 145.1,172.44 v1(144.68,172.03)
  BOTTOM w0.203: v1(144.68,172.03) 144.3,171.65 144.3,167.51 142.6,165.81 v1(135.34,165.81) 129.47,165.81 129.04,166.24 125.96,166.24 125.33,165.6 120.88,165.6 119.72,164.43 119.72,164.16 PR228.1
PWM2_B: length 26.6
  TOP w0.203: PR29.1 145.37,173.96 146.16,173.17 146.16,169.56 142.35,165.75 139.59,165.75 139.26,165.42 135.97,165.42 135.62,165.07 v1(128.35,165.07) 128.12,165.07 v1(127.72,164.66)
  BOTTOM w0.254: v1(127.72,164.66) 127.43,164.37 PR233.1
PWM-VID: length 109.3
  TOP w0.127: v1(186.55,63.99) 186.98,64.42 186.98,64.61 186.37,65.22 186.37,65.23 183.21,68.38 174.64,68.38 173.79,69.23 v1(173.79,76.78) 173.79,77.06 171.51,79.34 169.53,79.34 168.59,80.28 168.59,80.31 167.72,81.17 167.72,82.43 165.39,84.77 165.39,86.86 166.99,88.46 169.74,88.46 171.34,90.06 171.74,90.06 172.47,90.79 172.83,90.79 177.91,95.86 177.91,100.57 180.94,103.6 181.75,103.6 182.29,104.13 182.58,104.13 183.41,104.96 183.41,109.06 184.27,109.92 184.27,111.84 184.8,112.37 184.8,112.49 184.88,112.57 184.88,113.52 184.8,113.6 184.8,115.22 186.75,117.16 186.75,121.13 186.99,121.37 186.99,121.8 v1(186.44,122.35)
  IN1 w0.14: v1(205.09,59.07) 205.09,58.67 203.66,57.24 197.73,57.24 195.7,59.28 195.05,59.28 193.58,60.74 193,60.74 192.31,61.43 190.79,61.43 189.48,62.74 188.03,62.74 186.78,63.99 v1(186.55,63.99)
  BOTTOM w0.102: U3002.M5 186.77,121.94 186.44,122.27 v1(186.44,122.35)
  BOTTOM w0.127: PR256.1 v1(205.09,59.07)
PWM_A: length 25
  IN2 w0.203: v1(144.1,181.2) 144.03,181.2 143.52,180.68 143.52,177.92 144.63,176.8 144.63,174.09 145.4,173.32 145.4,169.87 142.5,166.97 140.43,166.97 138.45,164.99 138.45,164.98 v1(138.28,164.82)
  BOTTOM w0.203: PR43.2 142.74,181.07 143.97,181.07 v1(144.1,181.2)
  BOTTOM w0.254: PR237.1 138.28,163.91 v1(138.28,164.82)
PWM_C: length 42.7
  TOP w0.203: PR47.2 136.51,182.04 v1(136.7,182.23) v1(137.17,182.7)
  IN1 w0.203: v1(137.17,182.7) 137.71,182.7 138.32,182.09 138.32,181.54 140.71,179.15 142.04,179.15 142.6,179.7 142.6,183.07 143.14,183.61 145.14,183.61 146.28,182.47 150.73,182.47 152.05,181.15 152.05,167.2 149.69,164.84 v1(148.9,164.84)
  BOTTOM w0.254: PR239.1 149.69,164.05 v1(148.9,164.84)
PWRLED#: length 165.7
  TOP w0.127: R436.1 54.32,20.36 54.67,20.01 v1(54.67,15.56) 54.67,11.96 v1(53.9,11.2) ; R436.1 R432.1 ; R436.1 R426.1
  IN2 w0.14: v1(185.32,32.91) 184.23,31.82 182.66,31.82 182.07,32.4 175.17,32.4 168.92,26.16 163,26.16 158.63,21.79 154.7,21.79 152.61,21.79 151.69,20.87 141.87,20.87 139.76,22.98 125.89,22.98 123.45,20.54 112.1,20.54 103,29.64 89.27,29.64 81.76,22.13 78.5,22.13 77.06,20.69 73.36,20.69 70.75,18.08 70.75,16.49 67.08,12.82 61.65,12.82 59.59,10.76 54.34,10.76 v1(53.9,11.2)
  BOTTOM w0.127: v1(185.32,32.91) 185.35,32.91 185.79,32.47 186.06,32.47 186.33,32.2 U45.24
R_SPK+: length 145.5
  IN2 w1.016: 78.21,18.54 78.62,18.13 81.65,18.13 90.44,26.92 102.34,26.92 107.46,21.79 107.46,20.53 107.46,20.53 107.46,16.14 109.16,14.43 117.6,14.43 119.41,16.25 132.68,16.25 134.15,17.72 145.04,17.72 145.05,17.71 145.44,17.71 147.1,16.04 164.14,16.04 164.66,15.52 166.9,15.52 167.46,16.09 167.96,16.09 172.98,21.1 172.98,22.75 174.96,24.73 176.05,24.73 179.18,27.86 185.71,27.86 186.34,27.22 189.01,27.22 189.82,28.04 191.42,28.04 192.77,29.38 192.77,32.2 195.31,34.74 198.08,34.74
  vias: v1(76.64,18.05) v1(76.89,17.27) v1(77.3,18.03) v1(198.95,34.02) v1(199.64,34.02)
R_SPK+_1:
  vias: v1(76.46,13.48) v1(76.82,14.47) v1(77.07,13.74)
R_SPK-: length 145.2
  IN2 w1.016: 196.7,33.57 195.79,33.57 193.94,31.72 193.94,28.85 191.14,26.05 185.83,26.05 185.18,26.7 179.67,26.7 176.54,23.57 175.44,23.57 174.15,22.27 174.15,20.62 174.14,20.61 174.14,20.58 168.48,14.93 167.94,14.93 167.26,14.25 164.21,14.25 163.62,14.84 146.67,14.84 144.96,16.56 135.87,16.56 134.4,15.08 133.15,15.08 133.13,15.06 125.79,15.06 124.01,13.28 108.69,13.28 106.31,15.66 106.31,21.31 101.86,25.76 90.91,25.76 82.1,16.95 77.11,16.95
  vias: v1(75.55,18.05) v1(75.57,17.39) v1(75.72,16.66) v1(199,33.23) v1(199.69,33.23)
R_SPK-_1:
  vias: v1(75.27,13.74) v1(75.8,13.33) v1(76.82,12.62)
RAM_ID1: length 10
  BOTTOM w0.076: 143,104.99 142.93,105.05 141.46,105.05 141.42,105.09 141.17,105.34 140.75,105.34 140.53,105.4 140.38,105.4 U35.AP2
  BOTTOM w0.079: 143.31,104.67 143,104.99
  BOTTOM w0.127: R611.1 R610.2 147.39,102.77 147,102.38 146.11,102.38 145.55,102.94 145.04,102.94 143.31,104.67
RAM_ID2: length 8.7
  BOTTOM w0.076: 140.86,105.62 141.14,105.62 141.45,105.3 143.06,105.3 143.19,105.18
  BOTTOM w0.079: 140.86,105.62 U35.AP1 ; 143.47,104.9 143.19,105.18
  BOTTOM w0.127: R613.1 147.44,103.91 R612.2 147.25,103.99 147.25,104.16 147.07,104.34 146.16,104.34 146.02,104.2 144.16,104.2 143.47,104.9
RAM_ID3: length 13.9
  BOTTOM w0.076: 141.35,104.9 141.08,105.16 140.93,105.16 140.92,105.18 140.73,105.18 140.51,105.24 140.09,105.24 139.71,105.62 U35.AP3
  BOTTOM w0.127: 141.35,104.9 141.45,104.79 142.8,104.79 144.93,102.67 145.44,102.67 145.98,102.13 147.88,102.13 148.14,102.38 149.92,102.38 150.31,102.77 R614.2 150.56,102.76 R615.1
REGN6V: length 5.5
  TOP w0.178: PC122.1 160.61,179.46 160.61,181.02 160.32,181.31 PU5.24
  TOP w0.305: PR1.1 161.16,180.22 v1(161.5,179.87) 161.07,179.44 PC122.1
REGOUT:
  vias: v1(40.77,69.06)
RF_EN: length 237.9
  IN2 w0.14: v1(178.06,35.83) 178.06,36.09 179.08,37.1 181.11,37.1 181.79,36.42 181.93,36.42 181.94,36.41 185.03,36.41 187.61,39 187.61,46.14 188.36,46.88 189.02,46.88 189.35,47.21 189.91,47.21 194.08,43.05 199.42,43.05 201.57,40.9 206.15,40.9 208.02,42.77 208.51,42.77 213.08,47.33 213.08,54.48 212.22,55.34 212.22,59.02 212.84,59.65 212.84,60.64 214.59,62.4 214.59,64.97 216.01,66.39 216.01,67.93 216.67,68.59 216.67,69.97 218.19,71.5 218.19,75.41 218.57,75.79 218.57,85.36 213.98,89.96 213.98,89.99 213.8,90.16 213.8,99 215.12,100.32 215.25,100.32 215.25,100.35 218.27,103.37 218.27,103.7 222.84,108.27 225.01,108.27 225.94,109.2 225.94,112.26 225.63,112.57 225.63,119.04 225.23,119.45 225.23,141.51 225.63,141.92 225.63,155.59 220.63,160.59 216.09,160.59 215.14,161.54 209.09,161.54 207.72,162.91 207.72,164.01 207.32,164.41 207.32,165.83 206.31,166.84 206.31,169.92 205.86,170.37 205.86,174.39 205.27,174.98 205.27,180.98 204.54,181.71 203.89,181.71 203.23,182.37 201.68,182.37 201.05,181.73 201.05,178.76 v1(201.67,178.14)
  BOTTOM w0.127: v1(178.06,35.83) 178.06,30.14 177.11,29.19 173.42,29.19 172.52,28.29 v1(172.52,27.22) 172.52,26.75 172.68,26.6 172.68,26.22 172.43,25.97 172.04,25.97 171.63,26.38 R774.2 ; CN10.56 201.56,178.25 v1(201.67,178.14)
RING2: length 23.7
  IN2 w1.016: 207.73,13.41 208.13,13.81 208.13,20.16 206.6,21.7 206.6,26.14 207.97,27.51 207.97,27.58 208.03,27.65 208.03,29.08 207.65,29.46 207.65,33.01 208.13,33.5 v1(208.62,33.5)
  BOTTOM w0.203: U23.17 208.12,33 v1(208.62,33.5)
  vias: v1(206.1,12.97) v1(206.79,12.75)
RING2_R:
  vias: v1(208.69,12.82)
ROM_SCLK: length 11.8
  TOP w0.127: R4307.1 R4315.2
  TOP w0.14: R4315.2 190.58,112.05 190.58,114.55 v1(190.33,114.8) 190.05,115.08 190.05,119.01 189.72,119.34 v1(189.72,119.95)
  BOTTOM w0.14: U3002.H4 189.72,120.74 v1(189.72,119.95)
ROM_SI: length 17
  TOP w0.127: v1(189.73,121.54) 189.73,120.94 v1(189.9,120.77) 190.18,120.49 190.18,119.27 191.37,118.08 192.56,118.08 195.51,115.14 v1(195.51,109.98)
  BOTTOM w0.102: U3002.H5 v1(189.73,121.54)
  BOTTOM w0.127: R4305.1 R4313.2 194.98,109.65 195.31,109.98 v1(195.51,109.98)
ROM_SO: length 18.5
  TOP w0.127: v1(190.56,123.23) 190.94,122.85 190.94,119.71 191.17,119.48 191.6,119.48 191.93,119.81 193.1,119.81 v1(193.99,118.92) 197.8,115.11 197.8,111.9 R4314.2 R4306.1
  BOTTOM w0.14: U3002.H7 190.53,123.23 v1(190.56,123.23)
RSET: length 4.1
  TOP w0.127: R11264.2 41.84,77.35 v1(41.84,77.03) 41.84,74.77 41.53,74.46 U15.47
RSMRST#: length 84.6
  IN1 w0.14: v1(160.2,82.21) 160.74,82.21 163.76,79.19 163.76,70.2 164.95,69.01 164.95,67.72 170.21,62.46 170.21,59.42 170.58,59.04 170.58,54.2 171.82,52.96 171.82,52.08 171.58,51.83 171.58,46.56 172.19,45.95 172.19,44.11 173.61,42.7 173.83,42.7 174.79,41.74 174.79,41.11 v1(174.81,41.09)
  BOTTOM w0.127: R655.1 v1(135.82,92.08) 135.82,91.08 145.94,80.95 158.36,80.95 159.62,82.21 v1(160.2,82.21) ; v1(174.81,41.09) 175.11,40.79 177.71,40.79 179.18,42.26 U45.112
RST_MON#: length 5.7
  BOTTOM w0.127: R4007.2 215.18,108.58 214.75,109.01 214.23,109.01 v1(213.8,108.58) 213.8,107.84 R11108.1 212.14,107.83 U4001.4
RTC_RST#: length 246
  TOP w0.076: 134.84,103.1 135.37,103.63 135.37,103.97 135.09,104.25 134.8,104.25 134.56,104.48 134.56,106.54 134,107.1 132.29,107.1 v2(132.23,107.17)
  TOP w0.127: R299.2 C380.1 78.92,46.1 82.95,42.07 82.95,41.92 v1(82.99,41.88) ; 134.84,103.1 134.84,102.22 134.73,102.1 134.73,100.4 136.65,98.48 136.65,93.22 139.33,90.54 140.97,90.54 143.34,88.17 143.71,88.17 146.69,85.19 146.69,75.43 Q6060.3 145.62,74.37 144.74,74.37 144.2,73.83 144.2,71.77 145.01,70.96 153.64,70.96 153.79,70.81 155.72,70.81 v1(155.89,70.64) 156.13,70.89 159.32,70.89 162.31,67.9 163.31,67.9 163.71,67.51 164.32,67.51 164.71,67.9 168.26,67.9 171.18,70.82 v1(171.18,73.55) 171.18,74.62 168.94,76.85 168.94,77.08 166.45,79.57 166.45,81.9 164.12,84.24 164.12,87.75 165.16,88.79 165.16,90.19 166.25,91.28 168.94,91.28 169.6,90.62 v1(170.34,90.62)
  IN2 w0.14: v1(155.89,70.64) 155.89,70.38 155.94,70.32 155.94,59.26 155.53,58.85 155.53,57.01 156.03,56.52 156.03,55.05 155.53,54.56 155.53,52.86 155.94,52.45 155.94,49.34 149.02,42.41 144.65,42.41 138.34,36.1 123.21,36.1 121.95,37.36 114.42,37.36 112.84,38.93 85.93,38.93 v1(82.99,41.88) 82.94,41.93 81.95,41.93 78.34,38.32 78.34,38.04 v1(78.47,37.92)
  BOTTOM w0.114: v2(132.23,107.17) 131.96,107.44 131.77,107.44 U35.AM16
  BOTTOM w0.127: J1.1 81.83,27.34 79,30.17 79,37.38 v1(78.47,37.92) ; v1(170.34,90.62) 170.78,90.18 R268.2
RTC_X1: length 28
  IN1 w0.076: v2(131.3,107.71) 131.3,108 131.58,108.29 132.42,108.29 132.66,108.05 132.66,107.72 132.97,107.41 134.63,107.41 134.65,107.43 134.74,107.43 134.91,107.6 135.1,107.6 135.18,107.51
  IN1 w0.14: 135.18,107.51 135.54,107.16 137.01,107.16 137.39,107.54 137.8,107.54 138.26,107.08 139.6,107.08 140.32,106.37 142.27,106.37 v1(142.73,106.83)
  BOTTOM w0.114: v2(131.3,107.71) 131.3,107.71 131.04,107.45 U35.AM18
  BOTTOM w0.14: v1(142.73,106.83) 147.38,106.83 147.63,107.08 153.46,107.08 R255.1 153.84,107.09 154.11,106.82 C351.2 155.49,107.82 Y2.1
RTC_X2: length 28.6
  IN1 w0.076: v2(130.41,107.77) 130.9,108.26 131.28,108.26 131.48,108.45 132.49,108.45 132.82,108.12 132.82,107.79 133.04,107.57 134.56,107.57 134.58,107.6 134.67,107.6 134.86,107.79 135.29,107.79 135.3,107.78
  IN1 w0.14: v1(141.99,106.8) 140.26,106.8 139.71,107.35 138.37,107.35 137.91,107.8 137.28,107.8 136.9,107.42 135.65,107.42 135.3,107.78
  BOTTOM w0.14: v1(141.99,106.8) 142.23,106.56 142.39,106.56 142.55,106.4 142.9,106.4 143.06,106.56 153.1,106.56 153.35,106.31 R255.2 153.86,106.31 154.35,105.82 C362.2 154.99,105.32 Y2.2 ; U35.AM20 130.1,107.45 v2(130.41,107.77)
S5_ON: length 310.6
  TOP w0.127: v1(173.2,44.56) 172.42,43.78 v1(171.48,43.78) 168.81,43.78 168.18,44.42 162.36,44.42 161.6,43.66 159.31,43.66 v1(158.5,42.84) ; v1(37.22,90.65) 37.64,91.07 PR6299.1 ; v1(42.6,113.3) PQ13.2 ; v1(56.04,101.44) 64.8,101.44 65.46,100.78 65.46,97.19 66.85,95.81 66.85,92.27 66.92,92.19 66.92,80.37 71.2,76.09 71.2,68.85 72.88,67.18 72.88,56.49 71.66,55.28 68.53,55.28 66.92,56.89 62.87,56.89 62.19,56.21 PR6293.1 63.2,55.57 63.28,55.65 65.72,55.65 68,53.36 72.83,53.36 74.73,51.45 74.73,50.44 74.1,49.8 74.1,45.31 79.15,40.25 79.15,35 77.98,33.83 v1(77.98,30.37) 77.98,27.12 75.6,24.73 75.6,24.61 74.12,23.13 68.1,23.13 v1(67.87,22.91)
  TOP w0.254: PQ9.2 40.95,114.57 41.74,113.79 PQ13.2
  IN1 w0.14: v1(42.6,113.3) 42.6,112.16 40.11,109.67 40.11,92.63 38.13,90.65 v1(37.22,90.65) ; v1(77.98,30.37) 80.72,30.37 85.3,34.95 111.81,34.95 112.21,34.55 125.53,34.55 128.7,31.38 141.85,31.38 144.18,33.7 148.93,33.7 156.34,41.12 157.13,41.12 158.5,42.49 v1(158.5,42.84) 158.5,43.44 161.88,46.82 161.88,52.29 160.91,53.26 160.91,60.03 161.7,60.83 v1(161.7,62.1)
  BOTTOM w0.127: v1(161.7,62.1) 162.09,61.71 PR69.1 ; v1(67.87,22.91) 67.52,22.55 PR6285.1 ; v1(56.04,101.44) 55.76,101.16 49.16,101.16 42.86,94.86 42.86,92.96 41.54,91.64 38.21,91.64 v1(37.22,90.65) ; R741.1 172.68,47.15 172.68,45.08 173.18,44.57 173.19,44.57 v1(173.2,44.56) 173.22,44.56 173.44,44.34 173.84,44.34 174.38,43.81 U45.100
SATA_DEVSLP1: length 4.5
  BOTTOM w0.076: U35.J2 140.43,118.73 140.71,118.61 140.97,118.61 141.38,119.02 141.38,119.04 141.41,119.02
  BOTTOM w0.127: 141.41,119.02 143.31,119.02 143.44,119.15 R574.1
SATA_RXN0: length 167.9
  IN2 w0.114: v1(206.46,50.52) 206.3,50.67 205.54,50.67 205.11,51.1 197.57,51.1 192.77,55.9 187.81,55.9 187.1,56.61 187.1,56.64 186.8,56.94 185.41,58.33 183.6,60.14 183.6,61.56 180.21,64.94 179.21,64.94 174.39,69.77 174.39,80.71 175.37,81.7 175.37,91.54 176,92.17 176,96.25 176.64,96.9 176.64,98.93 175.05,100.52 175.05,102.04 174.42,102.67 174.42,106.15 174.01,106.56 174.01,108.21 172.68,109.54 172.68,109.54 172.29,109.93 172.29,109.93 172.21,110.01 172.21,110.89 165.4,117.69 165.01,118.08 164.96,118.13 164.38,118.13 161.19,121.31 161.19,122.6 160.46,123.34 160.46,124.56 158.53,126.49 147.78,126.49 147.38,126.08 144.94,126.08 143.82,124.96 138.03,124.96 137.69,125.31 136.32,125.31 134.51,123.5 130.6,123.5 129.82,122.72 129.82,122.22 130.23,121.81 130.23,120.46 130.02,120.25 129.68,120.25 v2(129.47,120.04)
  BOTTOM w0.114: U35.F20 129.77,120.34 v2(129.47,120.04) ; C507.2 223.92,38.13 223.97,38.18 223.97,38.53 222.97,39.53 221.89,39.53 218.76,42.65 218.76,47.19 214.26,51.7 208.15,51.7 207.2,50.74 206.67,50.74 206.46,50.53 v1(206.46,50.52)
SATA_RXN0_C: length 8.6
  BOTTOM w0.114: C507.1 223.85,36.95 223.85,36.35 225.85,34.35 229.81,34.35 CN14.5
SATA_RXN1: length 215.1
  IN2 w0.089: v2(128.55,120.02) 128.55,120.11 129.08,120.64 129.08,121.03 129.1,121.05 129.1,121.79
  IN2 w0.114: 129.1,121.79 129.11,121.81 129.11,122.73 128.54,123.3 127.71,123.3 127.22,123.78 127.22,124.95 128.11,125.84 134.28,125.84 135.68,127.24 137.89,127.24 138.49,126.64 143.08,126.64 144.65,128.2 159.28,128.2 162.19,125.29 162.19,124.05 162.87,123.36 162.87,122.06 164.44,120.49 165.08,119.84 165.64,119.84 171.88,113.6 173.09,113.6 173.67,113.02 173.67,112.69 174.5,111.85 174.91,111.44 174.91,110.05 176.17,108.8 176.17,108.24 176.96,107.44 176.96,105.21 176.62,104.87 176.62,102.88 178.32,101.18 178.32,96.2 177.68,95.56 177.68,91.48 177.37,91.17 177.37,89 177.05,88.68 177.05,81 176.12,80.07 176.12,75.07 176.64,74.55 176.64,69.53 177.52,68.65 179.63,66.54 181.11,66.54 181.47,66.18 181.83,66.18 182.9,65.11 182.9,64.7 185.27,62.33 185.27,61.01 186.7,59.58 187.29,58.99 188.61,58.99 190.01,57.59 193.54,57.59 198.34,52.79 205.97,52.79 208.2,55.02 208.2,59.81 208.84,60.45 208.84,61.42 209.61,62.19 209.61,64.2 209.81,64.41 210.19,64.41 v1(210.39,64.21)
  BOTTOM w0.114: v1(210.39,64.21) 210.65,64.46 213.87,64.46 215.07,65.65 219.79,65.65 220.95,66.81 220.95,82.76 223.64,85.45 227.43,85.45 227.87,85.9 228.15,85.9 232.35,90.1 232.35,96.08 230.26,98.18 229.13,98.18 228.77,98.53 228.77,98.99 228.93,99.15 229.09,99.15 C744.2 ; U35.G21 128.88,119.69 v2(128.55,120.02)
SATA_RXN1_C: length 4.9
  BOTTOM w0.114: CN9.5 233.47,97.56 233.1,97.56 231.43,99.23 230.74,99.23 C744.1
SATA_RXN3/PEG_RXN9_L0: length 76.3
  IN2 w0.114: v1(167.71,121.42) 167.49,121.2 167.34,121.2 167.25,121.29 167.25,121.9 166.68,122.47 166.68,123.13 167.13,123.58 167.13,125.53 166.19,126.47 160.51,132.15 152.25,132.15 151.96,131.86 141.11,131.86 139.92,130.66 132.2,130.66 130.22,128.68 125.93,128.68 123.92,126.68 123.92,123.37 124.59,122.7 124.59,121.81 124.31,121.53 v2(124.31,121.51)
  BOTTOM w0.114: v2(124.31,121.51) 124.44,121.38 U35.E28 ; R959.2 167.16,106.42 167.16,117.88 166.17,118.87 166.17,120.57 166.78,121.18 167.47,121.18 v1(167.71,121.42)
SATA_RXN3/PEG_RXN9_L0_N: length 2.2
  BOTTOM w0.114: CN23.31 167.25,103.44 167.25,104.35 167.37,104.47 167.37,104.99 R959.1
SATA_RXN3/PEG_RXN10_L1: length 81.7
  IN2 w0.114: v1(167.47,123.18) 167.47,123.13 167.67,122.93 167.98,122.93 168.13,123.08 168.13,125.44 160.79,132.79 152,132.79 151.71,132.49 140.86,132.49 139.66,131.29 131.94,131.29 129.89,129.23 125.74,129.23 123.52,127.01 123.52,122.81 123.78,122.54 123.78,120.8 v2(123.91,120.67)
  BOTTOM w0.102: v2(123.91,120.67) 124.03,120.8 124.03,121.2 123.91,121.33 123.65,121.33 123.52,121.2 U35.E30
  BOTTOM w0.114: v1(167.47,123.18) 167.47,123.16 167.27,122.96 166.53,122.96 166.38,123.11 165.44,123.11 164.41,122.09 164.41,118.16 164.97,117.61 164.97,110.14 v1(164.42,109.6) 164.89,109.13 164.89,109.05 164.41,108.57 164.41,106.6 R11062.2
SATA_RXN3/PEG_RXN10_L1_N: length 2.2
  BOTTOM w0.114: R11062.1 164.38,105.05 164.38,104.43 164.25,104.29 CN23.43
SATA_RXP0: length 167.9
  IN2 w0.114: v2(129.47,120.69) 129.69,120.47 129.93,120.47 130.01,120.55 130.01,121.7 129.6,122.12 129.6,122.8 130.51,123.72 134.42,123.72 136.23,125.52 137.78,125.52 138.12,125.18 143.73,125.18 144.85,126.3 147.29,126.3 147.69,126.7 158.62,126.7 160.67,124.64 160.67,123.43 161.41,122.69 161.41,121.4 164.47,118.35 165.05,118.35 165.55,117.84 172.42,110.98 172.42,110.1 172.5,110.02 172.5,110.02 172.77,109.75 172.77,109.75 174.22,108.3 174.22,106.65 174.63,106.24 174.63,102.76 175.27,102.13 175.27,100.61 176.86,99.02 176.86,96.81 176.22,96.16 176.22,92.08 175.59,91.45 175.59,81.61 174.6,80.62 174.6,69.86 179.3,65.16 180.3,65.16 183.81,61.65 183.81,60.23 185.57,58.48 187.32,56.72 187.32,56.72 187.32,56.7 187.9,56.12 192.86,56.12 197.66,51.32 205.2,51.32 205.63,50.88 206.17,50.88 v1(206.46,51.18)
  BOTTOM w0.114: C504.2 224.19,38.41 224.19,38.62 223.06,39.75 221.98,39.75 218.98,42.74 218.98,47.28 214.34,51.91 208.06,51.91 207.11,50.96 206.67,50.96 v1(206.46,51.18) ; U35.E20 129.62,120.69 v2(129.47,120.69)
SATA_RXP0_C: length 8.7
  BOTTOM w0.114: CN14.6 230.3,34.81 230.05,34.56 225.94,34.56 224.07,36.44 224.07,37.21 224.2,37.35 C504.1
SATA_RXP1: length 215.1
  IN2 w0.089: 128.9,121.84 128.9,121.72 128.92,121.7 128.92,121.12 128.9,121.11 128.9,120.69 128.86,120.65 128.57,120.65 v2(128.55,120.67)
  IN2 w0.114: v1(210.42,64.89) 210.15,64.62 209.72,64.62 209.39,64.29 209.39,62.28 208.62,61.51 208.62,60.54 207.98,59.9 207.98,55.11 205.88,53.01 198.42,53.01 193.63,57.8 190.1,57.8 188.7,59.2 187.38,59.2 186.85,59.74 185.49,61.09 185.49,62.42 183.12,64.79 183.12,65.2 181.92,66.4 181.56,66.4 181.2,66.76 179.72,66.76 177.68,68.8 176.85,69.62 176.85,74.64 176.33,75.16 176.33,79.98 177.27,80.91 177.27,88.59 177.59,88.91 177.59,91.08 177.89,91.39 177.89,95.47 178.54,96.11 178.54,101.27 176.84,102.97 176.84,104.78 177.18,105.12 177.18,107.53 176.38,108.33 176.38,108.88 175.13,110.14 175.13,111.53 174.65,112 173.88,112.78 173.88,113.11 173.18,113.81 171.97,113.81 165.73,120.06 165.17,120.06 164.59,120.64 163.09,122.15 163.09,123.45 162.4,124.14 162.4,125.38 159.37,128.42 144.56,128.42 142.99,126.85 138.58,126.85 137.98,127.45 135.59,127.45 134.19,126.05 128.02,126.05 127.01,125.04 127.01,123.69 127.62,123.08 128.45,123.08 128.9,122.64 128.9,121.84
  BOTTOM w0.114: v1(210.42,64.89) 210.64,64.68 213.78,64.68 214.98,65.87 219.7,65.87 220.73,66.9 220.73,82.85 223.55,85.67 227.34,85.67 227.78,86.11 228.06,86.11 232.14,90.19 232.14,95.99 230.17,97.96 229.04,97.96 228.56,98.44 228.56,99.08 228.84,99.37 229.09,99.37 C743.2 ; v2(128.55,120.67) 128.92,120.67 129.01,120.58 U35.F21
SATA_RXP1_C: length 4.8
  BOTTOM w0.114: C743.1 230.59,99.44 231.52,99.44 233.19,97.77 233.51,97.77 CN9.6
SATA_RXP3/PEG_RXP9_L0: length 76.3
  IN2 w0.114: v2(124.9,121.25) 124.9,121.23 124.8,121.33 124.8,122.8 124.14,123.46 124.14,126.59 126.02,128.47 130.31,128.47 132.29,130.45 140.01,130.45 141.2,131.64 152.05,131.64 152.34,131.93 160.42,131.93 166.1,126.26 166.1,126.26 166.91,125.45 166.91,123.67 166.46,123.22 166.46,122.38 167.04,121.81 167.04,121.2 167.25,120.99 167.44,120.99 v1(167.71,120.72)
  BOTTOM w0.114: R958.2 167.37,106.78 167.37,117.97 166.39,118.96 166.39,120.48 166.87,120.96 167.47,120.96 v1(167.71,120.72) ; v2(124.9,121.25) 124.9,120.95 125.02,120.82 125.18,120.82 U35.E27
SATA_RXP3/PEG_RXP9_L0_N: length 2.2
  BOTTOM w0.114: R958.1 167.58,105.05 167.58,104.52 167.75,104.35 CN23.29
SATA_RXP3/PEG_RXP10_L1: length 81.8
  IN2 w0.114: v1(167.44,122.52) 167.63,122.71 168.07,122.71 168.34,122.99 168.34,125.53 160.88,133 151.91,133 151.62,132.71 140.77,132.71 139.57,131.5 131.85,131.5 129.8,129.45 125.65,129.45 123.32,127.12 123.32,122.73 123.56,122.49 123.56,121.09 123.07,120.59 v1(123.07,120.59)
  BOTTOM w0.102: U35.F30 123.32,120.34 v1(123.07,120.59)
  BOTTOM w0.114: v1(167.44,122.52) 167.44,122.55 167.28,122.71 166.46,122.71 166.29,122.89 165.53,122.89 164.63,122 164.63,118.25 165.18,117.7 165.18,110.1 v1(165.69,109.6) 165.13,109.04 165.13,108.99 164.63,108.48 164.63,106.6 R11061.2
SATA_RXP3/PEG_RXP10_L1_N: length 2.2
  BOTTOM w0.114: CN23.41 164.75,103.44 164.75,104.26 164.6,104.41 164.6,104.99 R11061.1
SATA_TXN0: length 171.5
  IN2 w0.114: v1(128.42,124.79) 128.51,124.89 134.68,124.89 136.11,126.32 137.76,126.32 138.28,125.8 143.44,125.8 145,127.36 158.92,127.36 161.35,124.94 161.35,123.66 162.03,122.97 162.03,121.66 164.72,118.97 165.31,118.97 172.05,112.22 172.94,112.22 174.07,111.09 174.07,109.71 174.86,108.92 174.86,108.07 175.33,107.6 175.33,105.11 175.79,104.66 175.79,102.47 177.48,100.78 177.48,96.55 176.84,95.91 176.84,91.82 176.54,91.52 176.54,89.35 176.21,89.03 176.21,81.35 175.28,80.42 175.28,74.73 175.78,74.22 175.78,69.38 179.38,65.78 180.69,65.78 181.12,65.34 181.48,65.34 182.05,64.77 182.05,64.36 184.44,61.98 184.44,60.6 188.41,56.62 193.26,56.62 197.93,51.96 207.72,51.96 208.3,51.38 208.3,50.6 v1(208.03,50.34)
  BOTTOM w0.114: v1(128.42,124.79) 128.61,124.6 128.61,124.08 128.43,123.9 128.43,123.49 128.73,123.19 U35.B21 ; C513.2 224.24,34.34 224.24,35.02 222.54,36.72 222.54,38 218.14,42.4 218.14,46.92 214.01,51.05 208.46,51.05 208.26,50.85 208.26,50.57 v1(208.03,50.34)
SATA_TXN0_C: length 8.5
  BOTTOM w0.114: CN14.3 230.3,30.97 230.08,30.75 228.28,30.75 227.42,31.6 225.06,31.6 224.05,32.62 224.05,33.1 224.28,33.34 C513.1
SATA_TXN1: length 197.5
  IN2 w0.114: v1(208.74,63.7) 208.5,63.46 208.25,63.46 207.79,63 207.79,61.65 206.42,60.28 206.42,60.13 206.42,58.78 206.67,58.53 206.67,55.79 204.84,53.95 199.5,53.95 194.87,58.57 190.53,58.57 188.74,60.36 187.42,60.36 186.4,61.37 186.4,63.15 182.32,67.23 181.91,67.23 181.65,67.5 179.99,67.5 177.67,69.81 177.67,75.01 177.17,75.51 177.17,79.63 178.1,80.56 178.1,88.15 178.85,88.9 178.85,95.24 179.37,95.76 179.37,101.78 177.68,103.47 177.68,104.43 178.33,105.09 178.33,106.82 178.14,107.02 178.14,108.32 175.96,110.49 175.96,111.88 175.25,112.6 174.85,112.99 174.85,114.09 171.17,117.77 169.23,117.77 166.06,120.94 165.48,120.94 163.92,122.49 163.92,123.83 163.26,124.49 163.26,125.74 159.75,129.26 143.72,129.26 142.2,127.73 138.73,127.73 138.29,128.16 135.26,128.16 135.02,127.92 132.61,127.92 131.29,126.6 127.81,126.6 126.41,125.2 126.41,123.02 127.54,121.89 127.69,121.74 128.06,121.74 v1(128.52,121.29)
  BOTTOM w0.114: v1(128.52,121.29) 128.73,121.5 U35.D21 ; v1(208.74,63.7) 208.93,63.51 210.66,63.51 211.55,62.62 213.15,62.62 215.69,65.16 221.2,65.16 221.62,65.58 221.62,82.44 223.81,84.63 228.3,84.63 C749.2
SATA_TXN1_C: length 12.6
  BOTTOM w0.114: C749.1 229.3,84.85 229.67,84.47 229.93,84.47 230.22,84.77 231.3,85.85 231.3,88.41 232.95,90.06 232.95,93.65 233.21,93.9 233.45,93.9 CN9.3
SATA_TXN3/PEG_TXN9_L0: length 66.6
  IN2 w0.114: v1(165.92,121.56) 165.69,121.79 165.51,121.79 164.55,122.75 164.55,124.1 164.27,124.38 164.27,125.67 160.05,129.89 143.47,129.89 141.97,128.39 138.77,128.39 138.5,128.66 134.93,128.66 134.66,128.39 132.42,128.39 130.99,126.97 127.49,126.97 126.52,126 126.21,126 v1(126.02,125.8)
  BOTTOM w0.079: v1(126.02,125.8) 126.02,125.85 126.24,126.08 126.36,126.08 126.53,125.91 126.53,125.72 126.27,125.45 126.27,124.42 126.53,124.16 126.53,122.87 126.5,122.83 126.5,122.6 126.82,122.28 U35.D24
  BOTTOM w0.114: v1(165.92,121.56) 165.7,121.77 165.6,121.77 165.47,121.65 165.47,118.65 166.53,117.59 166.53,109.09 166.15,108.71 166.15,108.51 C1176.1
SATA_TXN3/PEG_TXN9_L0_N: length 4.1
  BOTTOM w0.114: C1176.2 166.11,106.88 166.11,104.49 166.25,104.35 CN23.35
SATA_TXN3/PEG_TXN10_L1: length 70.7
  IN2 w0.114: v1(125.71,124.81) 125.71,124.7 125.56,124.55 125.28,124.55 124.97,124.85 124.97,126.41 126.24,127.68 130.66,127.68 131.93,128.95 134.26,128.95 134.83,129.52 138.93,129.52 139.22,129.23 141.62,129.23 143.18,130.79 152.44,130.79 152.74,131.08 160.08,131.08 165.4,125.76 165.4,124.34 165.63,124.11 166.13,124.11 166.25,124 166.25,123.76 v1(166.22,123.73)
  BOTTOM w0.114: v1(125.71,124.81) 126.08,124.44 126.08,124.35 126.17,124.26 126.17,123.8 U35.A25 ; C4664.1 163.22,107.82 163.05,107.82 162.94,107.93 162.94,108.95 164.33,110.34 164.33,117.2 163.79,117.75 163.79,122.35 165.59,124.15 166.07,124.15 166.22,124 v1(166.22,123.73)
