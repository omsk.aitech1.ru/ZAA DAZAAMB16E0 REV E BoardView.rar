# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MX2: length 49.1
  IN1 w0.14: v1(174.78,26.11) 174.78,25.55 174.99,25.34 174.99,24.66 173.61,23.28 173.61,20.77 175.08,19.3 176.03,19.3 v1(177.45,17.85) 177.25,17.68 177.25,17.66 176.42,16.83 v1(176.42,15.87)
  IN2 w0.14: v1(197.28,22.32) 197.28,25.11 197.81,25.64 v1(197.81,26.2)
  BOTTOM w0.127: U45.60 v1(174.78,26.11) ; CN20.3 v1(176.42,15.87) ; C4811.1 195.92,23.25 196.35,23.25 v1(197.28,22.32) 197.8,22.32 197.96,22.16 CN2019.3 197.96,19.89 196.87,18.81 178.41,18.81 v1(177.45,17.85) ; v1(197.81,26.2) 197.81,26.39 196.81,27.39 RP1.3
MX3: length 50.6
  IN1 w0.14: v1(175.42,15.84) 175.42,16.49 v1(176.79,17.85) 175.62,19.02 174.97,19.02 173.33,20.66 173.33,23.43 174.68,24.78 174.68,25.24 174.17,25.75 v1(174.17,25.8)
  IN2 w0.14: v1(196.55,22.32) 195.92,22.96 195.92,25.8 v1(197.78,27.67)
  BOTTOM w0.127: U45.61 174.38,26.34 174.17,26.13 v1(174.17,25.8) ; C4812.1 194.52,23.46 195.18,22.8 196.07,22.8 v1(196.55,22.32) 196.96,21.91 CN2019.4 196.96,20.09 195.93,19.06 178,19.06 v1(176.79,17.85) ; v1(197.78,27.67) 197.57,27.88 197.44,27.88 196.66,28.66 RP1.1 ; CN20.4 v1(175.42,15.84)
MX4: length 47.4
  IN1 w0.14: v1(174.07,25.14) 173.67,24.73 173.67,24.49 173.05,23.87 173.05,20.54 175.43,18.16 175.73,18.16 v1(176.05,17.85) 174.76,16.54 v1(174.76,15.84)
  BOTTOM w0.127: RP1.9 194.98,28.03 195.12,27.89 195.12,25.88 194.91,25.67 194.39,25.67 v1(193.85,25.13) 194.03,24.95 194.03,23.99 193.86,23.82 193.77,23.82 193.55,23.61 C4793.1 193.55,23.44 v1(194.28,22.71) 194.44,22.55 195.13,22.55 195.96,21.72 CN2019.5 195.96,20.18 195.09,19.31 177.52,19.31 v1(176.05,17.85) ; v1(174.07,25.14) 173.81,25.41 173.81,25.45 173.72,25.54 173.72,26.13 173.98,26.39 U45.62 ; CN20.5 174.42,15.51 v1(174.76,15.84)
MX5: length 51.1
  IN1 w0.14: v1(189.97,25.14) 190.1,25.14 191.67,23.57 v1(191.67,23.1) 191.67,22.7 187.53,18.56 184.87,18.56 179.23,12.92 v1(175.24,12.92) ; v1(174.05,15.87) 172.77,17.15 172.77,23.99 173.39,24.61 173.39,25.19 173.36,25.22 v1(173.36,25.27)
  BOTTOM w0.127: U45.63 173.58,26.38 173.26,26.05 173.26,25.37 v1(173.36,25.27) ; C4794.1 192.51,23.68 v1(191.67,23.1) 193.2,23.1 194.03,22.27 194.62,22.27 194.96,21.93 CN2019.6 ; v1(189.97,25.14) 190.29,25.45 190.29,25.63 190.48,25.83 192.36,25.83 193.29,26.76 RP1.7 ; v1(175.24,12.92) 175.24,13 174.38,13.86 173.82,13.86 173.42,14.26 CN20.6 173.42,15.25 v1(174.05,15.87)
MX6: length 58.3
  TOP w0.127: v1(190,23.81) 189.22,23.81 189.19,23.85 173.62,23.85 172.88,24.58 v1(172.88,24.76)
  IN1 w0.14: v1(174.58,12.9) 174.58,13 174.97,13.39 179.3,13.39 184.75,18.84 187.09,18.84 v1(191.01,22.85)
  IN2 w0.14: v1(191.01,22.85) 190.62,23.17 190.62,23.19 v1(190,23.81)
  BOTTOM w0.127: U45.64 173.18,26.36 172.65,25.83 172.65,24.99 v1(172.88,24.76) ; v1(174.58,12.9) 174.58,13.23 174.2,13.61 172.68,13.61 172.42,13.86 CN20.7 ; CN2019.7 193.96,21.98 193.28,22.65 191.2,22.65 v1(191.01,22.85) ; C4795.1 190.07,23.73 v1(190,23.81) 189.52,24.29 189.52,25.42 190.2,26.11 192.16,26.11 193.45,27.39 RP1.8
MX7: length 61
  TOP w0.127: v1(190.23,22.85) 189.71,23.36 187.97,23.36 187.76,23.57 173.41,23.57 172.26,24.72 172.26,25.45 172.47,25.66 172.47,26.17 v1(172.23,26.41)
  IN1 w0.14: v1(190,24.48) 189.52,24 189.52,23.56 v1(190.23,22.85) 186.5,19.12 184.64,19.12 179.18,13.67 174.54,13.67 173.92,13.05 v1(173.92,12.87)
  BOTTOM w0.127: v1(172.23,26.41) 172.08,26.57 172.08,28.4 172.37,28.7 172.37,28.85 172.22,29 U45.65 ; C4796.1 191.61,23.73 191.18,23.3 190.69,23.3 v1(190.23,22.85) 190.54,22.53 190.7,22.53 190.86,22.37 192.45,22.37 192.96,21.86 CN2019.8 ; RP1.6 193.15,26.12 192.57,25.55 190.76,25.55 190.46,25.24 190.46,24.99 190,24.53 v1(190,24.48) ; v1(173.92,12.87) 173.67,13.13 172.55,13.13 171.42,14.25 CN20.8
MY0: length 50.5
  TOP w0.127: v1(175.67,22.49) 174.07,22.49 172.49,24.07 171.66,24.07 171.08,24.66 170.59,24.66 168.59,26.66 162.64,26.66 153.93,17.95 v1(153.93,17.7) v1(153.4,17.16)
  IN1 w0.14: v1(175.67,22.49) 175.67,22.95 176.21,23.49 176.21,26.55 178.38,28.72 182.17,28.72 184.69,26.21 v1(184.69,25.75)
  BOTTOM w0.127: C4800.1 174.59,23.51 175.29,22.8 175.36,22.8 v1(175.67,22.49) 174.96,21.78 CN2019.26 ; CN20.26 153.42,17.14 v1(153.4,17.16) ; U45.36 184.38,26.29 184.69,25.98 v1(184.69,25.75)
MY1: length 50.2
  TOP w0.127: v1(154.42,17.22) 154.42,18.07 162.77,26.41 168.43,26.41 170.44,24.4 170.95,24.4 171.53,23.82 172.22,23.82 174.17,21.86 176.05,21.86 176.33,22.14 v1(176.33,22.6)
  IN1 w0.14: v1(176.33,22.6) 176.33,23.06 176.54,23.27 176.54,26.49 178.49,28.44 181.95,28.44 184.18,26.21 v1(184.18,25.34)
  BOTTOM w0.127: CN2019.25 175.96,22.08 176.33,22.45 v1(176.33,22.6) 176.33,22.73 175.56,23.51 C4799.1 ; CN20.25 v1(154.42,17.22) ; U45.37 183.98,26.26 184.18,26.05 v1(184.18,25.34)
MY2: length 48.2
  TOP w0.127: v1(155.38,17.24) v1(155.38,17.88) 155.38,18.64 162.9,26.16 168.28,26.16 170.29,24.15 170.82,24.15 171.41,23.57 172.07,23.57 174.02,21.61 176.34,21.61 v1(177.2,22.46)
  IN1 w0.14: v1(177.2,22.46) 176.82,22.84 176.82,26.35 178.63,28.16 181.72,28.16 183.7,26.18 v1(183.7,25.8)
  BOTTOM w0.127: v1(183.7,25.8) 183.58,25.92 U45.38 ; CN20.24 155.42,17.19 v1(155.38,17.24) ; C4798.1 176.51,23.15 v1(177.2,22.46) 176.96,22.23 CN2019.24
MY3: length 48.4
  TOP w0.127: v1(156.04,17.22) 156.04,18.92 163.03,25.9 168.15,25.9 170.16,23.9 170.69,23.9 171.28,23.31 171.96,23.31 173.94,21.33 176.8,21.33 v1(177.93,22.46)
  IN1 w0.14: v1(183.19,25.34) 183.22,25.37 183.22,26.16 181.49,27.88 178.74,27.88 177.09,26.24 177.09,23.57 177.11,23.29 v1(177.93,22.46)
  BOTTOM w0.127: CN2019.23 177.96,22.01 177.96,22.01 177.96,22.44 v1(177.93,22.46) 177.48,22.92 C4797.1 ; v1(156.04,17.22) 156.42,16.83 CN20.23 ; v1(183.19,25.34) 183.18,25.35 U45.39
MY4: length 47.4
  TOP w0.127: v1(178.69,22.85) 178.69,22.4 177.35,21.05 173.86,21.05 171.85,23.06 171.15,23.06 170.57,23.64 170.03,23.64 168.03,25.65 163.13,25.65 156.7,19.21 v1(156.7,17.85) v1(156.7,17.22)
  IN1 w0.14: v1(178.69,22.85) 178.23,22.85 177.37,23.7 177.37,26.12 178.86,27.6 181.29,27.6 182.71,26.18 v1(182.71,25.8)
  BOTTOM w0.127: U45.40 182.78,26.51 182.71,26.44 v1(182.71,25.8) ; v1(156.7,17.22) 157.42,16.49 CN20.22 ; CN2019.22 178.96,22.09 178.69,22.35 v1(178.69,22.85) 178.44,23.1 C4804.1
MY5: length 47.9
  TOP w0.127: v1(179.48,22.85) 179.17,22.53 179.17,22.13 177.83,20.8 173.76,20.8 171.75,22.8 171.02,22.8 170.44,23.39 169.91,23.39 167.9,25.39 163.28,25.39 157.38,19.5 v1(157.38,18.97) v1(157.38,17.19)
  IN1 w0.14: v1(182.23,25.34) 182.23,26.18 181.08,27.32 179,27.32 177.65,25.98 177.65,24.23 178.57,23.31 179.02,23.31 v1(179.48,22.85)
  BOTTOM w0.127: v1(182.23,25.34) 182.23,26.43 182.38,26.59 U45.41 ; CN2019.21 179.96,22.37 v1(179.48,22.85) 179.41,22.92 C4803.1 ; v1(157.38,17.19) 158.42,16.15 CN20.21
MY6: length 46.8
  TOP w0.127: v1(180.26,22.85) 179.91,22.5 179.79,22.5 179.69,22.4 179.43,22.4 179.43,22.02 177.96,20.54 173.64,20.54 171.63,22.55 170.9,22.55 170.31,23.13 169.78,23.13 167.77,25.14 163.38,25.14 158.07,19.82 v1(158.07,17.85) v1(158.07,17.19)
  IN1 w0.14: v1(180.26,22.85) 179.49,23.62 178.67,23.62 177.93,24.35 177.93,25.75 179.23,27.05 180.9,27.05 181.73,26.22 181.73,25.81 v1(181.72,25.8)
  BOTTOM w0.127: CN20.20 159.42,15.65 158.1,16.98 158.1,17.15 v1(158.07,17.19) ; CN2019.20 180.96,22.14 v1(180.26,22.85) 180.37,22.96 C4802.1 ; v1(181.72,25.8) 181.72,26.34 181.98,26.6 U45.42
MY7: length 47.3
  TOP w0.127: v1(158.8,17.21) v1(158.8,18.97) 158.8,20.2 163.49,24.89 167.62,24.89 169.63,22.88 170.01,22.88 172.6,20.29 178.09,20.29 179.38,21.58 179.67,21.58 v1(180.93,22.85)
  IN1 w0.14: v1(181.24,25.32) 181.24,26.23 180.7,26.77 179.41,26.77 178.21,25.57 178.21,24.48 178.8,23.9 179.77,23.9 180.13,23.54 180.23,23.54 v1(180.93,22.85)
  BOTTOM w0.127: v1(158.8,17.21) 160.42,15.59 CN20.19 ; U45.43 181.57,27.33 181.57,26.59 181.24,26.26 v1(181.24,25.32) ; CN2019.19 181.96,21.82 v1(180.93,22.85) 180.93,23.1 C4801.1
MY8: length 47.9
  TOP w0.127: v1(182.76,22.85) 181.25,21.34 179.85,21.34 179.79,21.28 179.46,21.28 178.21,20.04 172.47,20.04 169.88,22.63 169.5,22.63 167.49,24.63 163.59,24.63 159.46,20.5 v1(159.47,17.88) v1(159.46,17.24)
  IN1 w0.14: v1(182.76,22.85) 181.77,23.82 180.24,23.82 179.89,24.18 178.92,24.18 178.49,24.61 178.49,25.42 179.56,26.49 180.45,26.49 180.75,26.18 v1(180.75,25.8)
  BOTTOM w0.127: CN2019.18 182.96,22.09 182.76,22.3 v1(182.76,22.85) 182.3,23.3 C4808.1 ; v1(159.46,17.24) 161.42,15.28 CN20.18 ; v1(180.75,25.8) 180.75,26.16 181.18,26.58 U45.44
MY9: length 48.7
  TOP w0.127: v1(160.12,17.21) v1(160.12,18.99) 160.12,20.8 163.7,24.38 167.29,24.38 169.32,22.35 169.78,22.35 172.37,19.76 178.62,19.76 179.95,21.09 181.79,21.09 v1(183.55,22.85)
  IN1 w0.14: v1(180.45,25.22) 180.3,25.37 180.3,25.57 180.02,25.85 179.48,25.85 178.77,25.14 178.77,24.73 179.05,24.45 180,24.45 180.36,24.1 182.28,24.1 v1(183.55,22.85)
  BOTTOM w0.127: CN2019.17 183.96,22.43 v1(183.55,22.85) 183.27,23.12 C4807.1 ; CN20.17 162.42,15.43 161.37,16.48 160.86,16.48 v1(160.12,17.21) ; v1(180.45,25.22) 180.31,25.36 180.31,26.09 180.78,26.57 U45.45
MY10: length 46.3
  TOP w0.127: v1(160.84,17.29) v1(160.84,17.93) 160.84,21.16 163.8,24.12 167.09,24.12 169.17,22.04 169.7,22.04 172.24,19.5 178.73,19.5 180.06,20.83 182.34,20.83 v1(184.36,22.85)
  IN1 w0.14: v1(184.36,22.85) 182.84,24.38 180.47,24.38 179.81,25.04 v1(179.81,25.37)
  BOTTOM w0.127: CN20.16 163.42,15.06 161.7,16.78 161.34,16.78 v1(160.84,17.29) ; CN2019.16 184.96,22.24 v1(184.36,22.85) 184.23,22.97 C4806.1 ; U45.46 180.38,26.57 179.81,26 v1(179.81,25.37)
MY11: length 54.6
  TOP w0.127: v1(161.5,17.29) 161.5,18.12 161.09,18.52 161.09,21.05 161.43,21.39 161.43,21.39 161.49,21.45 161.49,21.45 163.91,23.87 166.96,23.87 169.12,21.71 169.61,21.71 172.1,19.22 178.82,19.22 180.13,20.53 182.83,20.53 v1(184.15,21.85) v1(185.15,22.85)
  IN1 w0.14: v1(178.75,29.69) 179.43,29 182.29,29 185.09,26.2 185.53,26.2 186.59,25.14 186.59,24.76 185.15,23.31 v1(185.15,22.85)
  BOTTOM w0.127: U45.51 178.38,28.28 178.75,28.65 v1(178.75,29.69) ; C4805.1 185.2,22.9 v1(185.15,22.85) 185.96,22.03 CN2019.15 ; v1(161.5,17.29) 161.63,17.29 163.48,15.44 164.19,15.44 164.42,15.2 CN20.15
MY12: length 45
  IN1 w0.14: v1(178.18,29.36) 178.18,29.78 178.55,30.15 179.77,30.15 180.64,29.28 182.41,29.28 185.2,26.48 185.66,26.48 186.87,25.27 186.87,24.63 186.04,23.79 v1(186.04,22.85) 183.99,20.8 183.94,20.8 178.49,15.34 171.53,15.34 169.52,13.34 169.26,13.34 168.79,12.87 v1(168.79,12.87)
  BOTTOM w0.127: U45.52 177.98,28.54 178.18,28.75 v1(178.18,29.36) ; C4815.1 186.16,22.97 v1(186.04,22.85) 186.48,22.4 186.48,22.39 186.96,21.91 CN2019.14 ; CN20.14 165.42,13.58 166.13,12.87 v1(168.79,12.87)
MY13: length 45.8
  IN1 w0.14: v1(177.68,28.93) 177.68,29.68 178.43,30.43 179.88,30.43 180.75,29.56 182.52,29.56 185.32,26.76 185.81,26.76 187.23,25.34 187.23,24.31 186.75,23.83 v1(186.75,22.85) 184.42,20.52 184.06,20.52 178.6,15.06 171.64,15.06 169.45,12.87 v1(169.45,12.87)
  BOTTOM w0.127: v1(177.68,28.93) 177.68,28.9 177.58,28.8 U45.53 ; v1(169.45,12.87) 168.89,13.43 166.57,13.43 166.42,13.58 CN20.13 ; CN2019.13 187.96,21.63 v1(186.75,22.85) 187.13,23.23 C4816.1
MY14: length 46.6
  IN1 w0.14: v1(170.11,12.87) 172.02,14.78 178.72,14.78 184.17,20.24 184.93,20.24 v1(187.53,22.85) 187.53,25.56 186.05,27.04 185.43,27.04 182.64,29.84 180.87,29.84 180,30.71 178.32,30.71 177.4,29.79 177.4,29.3 177.15,29.05 177.15,28.57 v1(177.12,28.54)
  BOTTOM w0.127: CN2019.12 188.96,21.78 188.7,22.04 188.25,22.04 187.53,22.76 v1(187.53,22.85) 188.09,23.4 C4814.1 ; CN20.12 167.42,14.14 167.88,13.69 169.3,13.69 v1(170.11,12.87) ; U45.54 177.18,28.15 177.15,28.19 177.15,28.52 v1(177.12,28.54)
MY15: length 48.2
  IN1 w0.14: v1(170.77,12.87) 172.4,14.5 178.83,14.5 184.29,19.96 185.36,19.96 v1(188.25,22.85) 188.25,25.25 186.17,27.32 185.55,27.32 182.58,30.29 182.58,30.42 182,31.01 178.21,31.01 177.12,29.92 177.12,29.43 176.49,28.8 v1(176.49,28.75)
  BOTTOM w0.127: U45.55 176.78,28.15 176.54,28.39 176.54,28.7 v1(176.49,28.75) ; CN20.11 168.42,14.12 168.6,13.94 169.45,13.94 169.83,13.56 170.08,13.56 v1(170.77,12.87) ; C4813.1 188.91,23.51 v1(188.25,22.85) 188.79,22.3 189.08,22.3 189.46,21.91 189.78,21.91 189.96,21.74 CN2019.11
MY16: length 49.4
  IN1 w0.14: v1(175.77,28.75) 175.67,28.85 175.67,29.61 177.37,31.31 182.44,31.31 182.85,30.91 183.29,30.91 183.58,30.62 183.58,29.69 185.67,27.6 186.28,27.6 188.91,24.98 v1(188.91,22.85) 185.74,19.68 184.4,19.68 178.95,14.22 172.78,14.22 v1(171.43,12.87)
  BOTTOM w0.127: CN2019.10 190.96,21.7 190.85,21.81 190.7,21.81 190.5,22.02 190.04,22.02 189.78,22.28 189.78,22.28 189.68,22.37 189.39,22.37 189.23,22.53 189.22,22.53 v1(188.91,22.85) ; CN20.10 169.42,14.32 169.93,13.81 170.49,13.81 v1(171.43,12.87) ; U45.56 176.38,28.17 175.8,28.75 v1(175.77,28.75)
MY17: length 50.8
  IN1 w0.14: v1(175.11,28.67) 175.11,29.45 177.28,31.62 182.53,31.62 182.97,31.19 183.4,31.19 183.86,30.73 183.86,29.81 185.78,27.88 186.4,27.88 189.23,25.05 189.23,23.18 v1(189.57,22.85) 186.12,19.4 184.52,19.4 179.07,13.95 173.14,13.95 172.09,12.9 v1(172.09,12.87)
  BOTTOM w0.127: CN20.9 170.42,14.46 170.86,14.02 170.94,14.02 v1(172.09,12.87) ; CN2019.9 191.96,21.84 191.73,22.07 190.8,22.07 190.6,22.27 190.15,22.27 189.89,22.53 189.88,22.53 v1(189.57,22.85) ; U45.57 175.98,28.11 175.8,28.29 175.49,28.29 v1(175.11,28.67)
NBSWON#: length 172.6
  TOP w0.127: v1(154.3,20.45) 154.35,20.45 155.13,21.23 156.42,21.23 159.19,24 v1(159.19,24.35) 159.58,24.75 159.58,24.98 161,26.4 161,26.78 162.01,27.78 162.39,27.78 163.3,28.7 163.3,33.75 164.28,34.73 166.34,34.73 169.25,37.64 169.25,40.81 171.15,42.72 172.53,42.72 172.62,42.81 175.48,42.81 175.56,42.72 176,42.72 176.82,41.9 177.27,41.9 v1(177.3,41.88) ; v1(215.73,35.68) 215.73,42.44 212.6,45.56 v1(211.49,45.56) 208.44,45.56 208.12,45.88 196.69,45.88 192.45,50.12 191.43,50.12 189.82,51.73 186.39,51.73 182.94,55.19 v1(182.94,55.6)
  IN1 w0.14: v1(172.65,90.34) 172.65,88.92 172.68,88.88 172.68,88.5 172.68,88.49 172.68,87.85 172.26,87.44 172.26,79.58 173.13,78.71 173.13,75.06 172.54,74.48 172.54,70.78 177.83,65.5 177.83,64.69 177.83,62.33 178.83,61.32 178.83,60.16 180.7,58.29 181.59,58.29 183.04,56.84 183.04,55.7 v1(182.94,55.6)
  BOTTOM w0.127: R265.2 172.49,90.18 v1(172.65,90.34) ; v1(215.73,35.68) 216.79,36.74 R753.1 218.06,36.74 C785.2 218.07,36.21 217.79,35.94 SW2.2 SW2.1 ; v1(182.94,55.6) 182.07,54.73 182.07,53.41 181.29,52.62 180.73,52.62 180.28,53.07 179.08,53.07 177.78,51.77 177.78,48.99 177.32,48.53 R730.1 177.91,47.68 177.91,47.11 177.37,46.58 177.37,45.62 177.37,45.62 177.37,45.2 177.39,45.19 177.39,44.82 177.37,44.81 177.37,44.29 177.18,44.1 U45.107 177.18,42.05 177.3,41.93 v1(177.3,41.88) ; v1(159.19,24.35) 159.63,24.35 159.89,24.61 170.76,24.61 171.09,24.29 R11107.2 ; v1(154.3,20.45) 154.3,20.58 153.57,21.31 150.93,21.31 150.55,20.92 R776.2 C805.1
NGFF1_RST#_SSD: length 5.9
  IN1 w0.14: v1(163.68,93.16) v1(163.68,94.33)
  BOTTOM w0.127: CN23.50 162.5,95.88 162.5,94.5 162.67,94.33 v1(163.68,94.33) ; R960.1 163.9,91.38 163.82,91.46 v1(163.82,92.16) 163.82,93.03 v1(163.68,93.16)
NGFF3_PEDET: length 19.5
  TOP w0.127: v1(169.7,104.87) v1(169.2,104.36) 168.99,104.16 163.53,104.16 163.06,104.63 163.06,105.75 162.79,106.01 162.39,106.01 161.68,105.3 159.31,105.3 158.86,104.85 158.63,104.85 158.39,104.62 v1(158.04,104.62)
  BOTTOM w0.127: Q59.2 171.25,107.59 R961.2 171.2,106.45 170.42,105.67 R968.2 170.24,105.4 v1(169.7,104.87) ; v1(158.04,104.62) 157.75,104.32 CN23.69
NGFF_SATA_DET: length 40.5
  IN2 w0.14: v1(170.49,111.27) 170.49,111.7 169.12,113.08 168.54,113.08 163.64,117.96 160,121.61 157.54,121.61 156.6,122.55 149.51,122.55 148.15,121.19 147.03,121.19 v1(146.69,121.53)
  BOTTOM w0.127: R11283.1 171.24,111.27 v1(170.49,111.27) v1(169.83,111.27) 169.73,111.17 Q59.3 ; U35.G4 138.91,120.2 139.23,120.53 140.88,120.53 141.69,121.33 146.49,121.33 v1(146.69,121.53)
NGFF_SSD_CLK: length 83.2
  IN2 w0.114: v1(151.52,136.67) 151.67,136.67 151.84,136.84 151.84,137.01 151.72,137.13 150.98,137.13 149.99,136.14 139.44,136.14 138.17,134.87 130.21,134.87 129.08,133.74 128.29,133.74 126.74,132.19 124.48,132.19 122.52,130.23 117.27,130.23 116.11,129.08 116.11,128.19 116.34,127.96 116.87,127.96 116.93,128.02 116.93,128.15 116.67,128.42 v1(116.64,128.42)
  BOTTOM w0.114: v1(151.52,136.67) 151.72,136.67 151.83,136.57 151.83,136.49 151.87,136.44 151.87,135.88 152.25,135.5 153.65,135.5 154.55,134.6 154.55,133.23 156.19,131.59 156.19,125.39 162.38,119.2 162.38,110.63 161,109.25 161,105.37 161.53,104.84 161.53,104.54 161.43,104.44 161.35,104.44 161.25,104.34 CN23.55 ; v1(116.64,128.42) 116.74,128.42 116.87,128.29 116.87,127.7 116.74,127.58 116.6,127.58 R11113.1
NGFF_SSD_CLK#: length 83.2
  IN2 w0.114: v1(117.3,128.42) 117.15,128.26 117.15,127.93 116.96,127.74 116.25,127.74 115.89,128.1 115.89,129.17 117.18,130.45 122.43,130.45 124.39,132.4 126.65,132.4 128.2,133.95 128.99,133.95 130.12,135.08 138.08,135.08 139.35,136.35 149.9,136.35 150.89,137.34 151.81,137.34 152.06,137.1 152.06,136.88 v1(152.26,136.67)
  BOTTOM w0.114: v1(117.3,128.42) 117.28,128.39 R11112.1 ; v1(152.26,136.67) 152.09,136.5 152.09,135.97 152.34,135.72 153.74,135.72 154.77,134.69 154.77,133.32 156.41,131.68 156.41,125.48 162.6,119.29 162.6,110.54 161.22,109.16 161.22,105.46 161.75,104.93 CN23.53
NGFF_SSD_CLK#_C: length 4.3
  BOTTOM w0.076: U35.B42 116.34,123.29 116.74,123.7 116.74,125.35 116.93,125.54 116.93,126.67 R11112.2
NGFF_SSD_CLK_C: length 4.3
  BOTTOM w0.076: U35.A42 116.49,123.71 116.57,123.79 116.57,125.4 116.77,125.61 116.77,126.74 116.87,126.84 116.87,127.12 116.77,127.22 116.6,127.22 R11113.2
NV_PLLVDD: length 0.6
  BOTTOM w0.254: v1(177.21,124.04) 176.83,124.42 U3002.AD8
  vias: v1(177.12,123.24)
ODD_EN: length 9.3
  TOP w0.127: v1(223.35,107.11) v1(224.11,107.11) 224.41,107.11 224.44,107.08 R692.1 R704.1 R703.1
  BOTTOM w0.127: v1(223.35,107.11) 223.12,107.11 222.69,107.54 222.69,110.48 223.53,111.32 Q37.5
ODD_EN_Q: length 6.6
  BOTTOM w0.127: Q37.2 226.9,111.32 227.06,111.17 227.06,110.79 226.93,110.66 226.23,110.66 Q37.3 225.82,110.67 225.62,110.47 225.62,109.46 225.96,109.11 226.73,109.11 v1(227.06,108.78) 227.75,108.09 R695.2
ODD_POWER: length 130.1
  TOP w0.127: R704.2 225.76,105.94 226.29,105.4 v1(226.29,104.26) 226.29,103.86 225.84,103.4 v1(225.13,103.4)
  IN1 w0.14: v1(225.13,103.4) 225.13,103.63 224.75,104.01 224.21,104.01 223.88,103.68 223.88,101.88 217.71,95.7 217.71,88.79 219.26,87.24 219.26,71.38 217.46,69.58 217.46,65.22 216.56,64.33 216.56,63.12 214.81,61.37 214.81,60.22 213.66,59.06 v1(213.66,50.03)
  IN2 w0.14: v1(177.58,35.35) 177.6,35.37 178.25,35.37 178.56,35.68 179.01,35.68 179.47,36.13 185.14,36.13 187.84,38.83 187.94,38.93 187.94,46.07 188.47,46.6 189.13,46.6 189.46,46.93 189.79,46.93 193.96,42.77 199.27,42.77 201.42,40.62 206.27,40.62 208.14,42.49 208.69,42.49 213.66,47.45 v1(213.66,50.03)
  BOTTOM w0.127: v1(177.58,35.35) 177.58,30.22 176.8,29.45 175.1,29.45 173.15,31.4 U45.71
ODD_PRSNT#: length 209.3
  TOP w0.127: R217.2 228.04,104.93 C802.1 227.26,103.88 226.33,102.95 v1(226.19,102.95) 224.91,102.95 v1(224.47,103.4) ; v1(182.86,50.9) 182.96,50.79 188.19,50.79 188.93,50.06 189.57,50.06 189.82,49.8 192.41,49.8 196.59,45.63 207.92,45.63 v1(208.87,44.67)
  IN1 w0.14: v1(141.45,111.82) 141.92,112.29 142.53,112.29 143.41,111.4 143.85,111.4 144.31,110.94 147.79,110.94 148.72,110 151.66,110 153.1,111.44 156.79,111.44 157.97,110.26 157.97,107.88 158.74,107.11 160.03,107.11 160.18,107.27 160.18,112.3 160.75,112.87 163.64,112.87 167.6,108.91 167.6,96.95 166.29,95.65 166.29,92.41 166.29,92.18 164.46,90.35 164.46,84.27 165.59,83.14 165.62,83.14 165.82,82.94 165.82,82.91 167.09,81.64 167.09,81.51 168.34,80.26 168.34,76.81 168.34,75.45 168.7,75.09 168.7,72.35 169.49,71.56 169.49,70.27 169.49,69.99 173.51,65.97 173.51,65.16 173.78,64.89 173.78,64.89 174.5,64.16 174.5,63.64 174.5,61.33 174.9,60.94 174.9,56.53 175.49,55.95 175.49,55.75 176.27,54.97 176.27,54.97 178.01,53.23 178.01,51.57 178.93,50.65 182.61,50.65 v1(182.86,50.9) ; v1(208.87,44.67) 209.11,44.67 214.18,49.74 214.18,59.19 215.09,60.1 215.09,61.01 217.56,63.47 217.56,64.93 217.73,65.11 217.73,69.46 219.54,71.27 219.54,87.36 218.01,88.88 218.01,95.61 224.47,102.07 v1(224.47,103.4)
  BOTTOM w0.076: v1(141.45,111.82) 141.28,111.98 140.43,111.98 U35.AB2
ODD_PRSNT#_C: length 6.8
  TOP w0.127: v1(232.21,103.78) 231.84,104.15 v1(231.07,104.15) R216.1 C330.1 R217.1
  BOTTOM w0.127: v1(232.21,103.78) 234.02,105.59 CN9.8
PCBEEP: length 2.2
  BOTTOM w0.127: U23.12 206.6,36.89 206.64,36.93 v1(206.64,37.03) C476.1
PCBEEP_EC: length 38.4
  TOP w0.127: v1(196.5,36.77) 196.5,37.33 199.04,39.88 210.44,39.88 v1(210.85,39.47) v1(211.36,38.96)
  BOTTOM w0.127: v1(196.5,36.77) 196.45,36.72 196.45,31.76 193.4,28.72 193.4,27.75 192.02,26.36 185.27,26.36 185.18,26.45 U45.34 ; D10.2 210.37,37.97 v1(211.36,38.96)
PCH_ACPRESENT: length 11.5
  BOTTOM w0.079: 131.85,100.34 131.85,101.85 132.21,102.21 U35.AY15
  BOTTOM w0.127: 131.85,100.34 131.83,100.32 131.83,100.06 133.5,98.39 133.77,98.39 136.33,95.83 136.33,95.14 136.59,94.88 R651.2 137.34,94.37 R676.2
PCH_AZ_CODEC_BITCLK: length 120.5
  IN2 w0.114: v1(190,50.92) 190.08,51 191.01,51 194.84,47.17 196.21,47.17 196.96,46.43 199.52,46.43 200.36,45.59 202.23,45.59 204.32,43.49 204.32,42.69 v1(204.68,42.34)
  BOTTOM w0.114: v1(204.68,42.34) 204.68,42.01 204.78,41.9 204.78,39.54 205.06,39.26 205.06,38.04 204.75,37.73 C493.2 204.04,37.25 204.04,36.47 204.2,36.31 U23.6 ; R644.1 C739.1 129.84,93.63 130.1,93.36 130.1,90.7 144.76,76.04 153.09,76.04 153.9,76.85 v1(156.47,76.85) 158.83,76.85 159.39,76.3 160.6,76.3 163.57,79.27 166.42,79.27 166.92,78.77 170.72,78.77 172.27,77.22 172.27,75.65 171.6,74.98 171.6,65.03 173.49,63.13 177.55,63.13 178.33,62.35 181.74,62.35 186.16,57.93 186.16,57.68 190.23,53.61 190.23,52.06 189.95,51.79 189.95,50.97 v1(190,50.92)
PCH_AZ_CODEC_RST#: length 118
  TOP w0.114: v1(202.42,42.87) v1(202.93,43.38) 203,43.45 205.31,43.45 v1(205.75,43.02)
  IN2 w0.114: v1(202.42,42.87) 200.36,44.93 196.55,44.93 195.64,45.84 195.08,45.84 v1(190.66,50.26)
  BOTTOM w0.114: U23.11 206.2,39.46 206.36,39.62 206.36,42.41 v1(205.75,43.02) ; v1(190.66,50.26) 191.16,50.76 191.16,51.26 191.85,51.95 191.85,53.33 187.31,57.88 187.31,58.19 186.85,58.64 186.84,58.64 186.65,58.84 186.65,58.85 182.26,63.23 180.65,63.23 179.88,64.01 173.89,64.01 172.48,65.42 172.48,74.62 173.23,75.38 173.23,77.49 171.08,79.65 167.28,79.65 166.79,80.14 160.57,80.14 159.52,79.1 153.63,79.1 152.35,77.82 145.78,77.82 132.26,91.34 R660.1 ; Q29.1 202.29,43 v1(202.42,42.87)
PCH_AZ_CODEC_SDIN0: length 122
  IN2 w0.114: v1(191.6,51.07) 195.15,47.52 196.3,47.52 197.08,46.73 199.64,46.73 200.49,45.88 202.35,45.88 204.83,43.4 v1(204.83,42.97)
  BOTTOM w0.114: v1(191.6,51.07) 192.3,51.78 v1(192.3,52) 192.3,53.34 187.64,58.01 187.64,58.29 182.4,63.53 180.77,63.53 180,64.3 174.01,64.3 172.77,65.54 172.77,74.5 173.53,75.26 173.53,77.61 171.2,79.94 168.6,79.94 167.71,80.83 166.62,80.83 166.22,80.44 160.44,80.44 159.4,79.39 153.51,79.39 152.23,78.12 146.27,78.12 132.75,91.64 132.75,93.9 132.42,94.23 132.42,96.08 131.88,96.62 131.88,97.66 129.48,100.07 129.48,100.54 129.35,100.68 129.35,101.94 U35.BA21 ; v1(204.83,42.97) 205.19,42.62 205.19,42.23 205.39,42.03 205.39,39.39 205.54,39.24 R359.2
PCH_AZ_CODEC_SDOUT: length 118.4
  IN2 w0.114: v1(204.02,42.01) 204.02,42.46 201.19,45.28 196.63,45.28 195.76,46.15 195.45,46.15 190.89,50.71 190.45,50.71 v1(190,50.26)
  BOTTOM w0.102: 204.15,41.07 204.15,39.57 203.94,39.36
  BOTTOM w0.114: R645.1 130.61,90.77 144.87,76.51 152.82,76.51 152.84,76.53 152.89,76.53 154.16,77.8 v1(158.66,77.8) 159.87,76.59 160.48,76.59 163.45,79.56 166.54,79.56 167.04,79.06 170.84,79.06 172.56,77.34 172.56,75.53 171.89,74.86 171.89,65.17 173.64,63.42 177.67,63.42 178.45,62.64 181.88,62.64 186.47,58.06 186.47,57.8 191.17,53.11 191.17,52.24 190.86,51.94 190.53,51.94 190.28,51.68 190.28,51.28 190.46,51.1 190.46,50.72 v1(190,50.26) ; U23.5 203.8,37.34 203.94,37.48 203.94,39.36 ; 204.15,41.07 204.15,41.88 v1(204.02,42.01)
PCH_AZ_CODEC_SYNC: length 117.8
  IN2 w0.114: v1(190.72,51.47) 190.79,51.55 191.79,51.55 192.06,51.28 192.06,51.07 195.31,47.82 196.45,47.82 197.24,47.04 199.78,47.04 200.64,46.17 202.47,46.17 205.29,43.35 205.29,42.79 v1(205.72,42.36)
  BOTTOM w0.114: R667.1 131.63,94.51 131.63,94.5 v1(131.63,91.82) 131.63,91.3 145.41,77.53 152.47,77.53 153.75,78.8 159.64,78.8 160.69,79.85 166.66,79.85 167.16,79.36 170.96,79.36 172.85,77.46 172.85,75.41 172.19,74.74 172.19,65.3 173.76,63.72 179.76,63.72 180.53,62.94 182.12,62.94 187,58.06 187,57.75 191.55,53.21 191.55,52.06 190.96,51.48 v1(190.72,51.47) ; v1(205.72,42.36) 205.72,42.34 205.84,42.21 205.84,39.37 205.95,39.26 205.95,36.31 205.8,36.16 U23.10
PCH_BATLOW#: length 50.5
  TOP w0.127: TP74.1 160.02,72.77 160.1,72.85 R628.2 160.66,72.88 160.66,73.78 160.46,73.98 159.77,73.98 159.29,74.47 158.76,74.47 158.22,75 158.22,75.46 157.96,75.73 157.96,76.84 v1(157.49,77.31)
  IN1 w0.14: v2(134,103.88) 134,102.75 137.78,98.98 148.46,98.98 149.72,97.72 151.03,96.4 151.03,92.11 152.23,90.92 152.23,87.36 155.15,84.44 155.15,80.37 157.49,78.03 v1(157.49,77.31)
  BOTTOM w0.127: v2(134,103.88) 133.58,104.17 U35.AU13
PCH_BLON: length 84.8
  TOP w0.127: v1(114.86,158.77) 114.61,159.02 v1(114.1,159.02) 113.98,158.9 R67.1
  IN1 w0.076: v2(135.12,115.19) 135.64,115.71 136.56,115.71 136.72,115.88 138.02,115.88 138.12,115.98
  IN1 w0.127: 138.12,115.98 138.33,116.2
  IN1 w0.14: 138.33,116.2 142.9,116.2 143.41,115.69 148.27,115.69 150.15,117.57 150.3,117.57 150.58,117.85 150.58,118.36 150.17,118.76 150.17,119.73 149.51,120.39 149.51,121.91 148.27,123.16 148.27,128.47 138.84,137.89 127.51,137.89 125.63,139.77 125.63,141.88 122.84,144.67 118.4,144.67 114.86,148.2 v1(114.86,158.77)
  BOTTOM w0.127: U35.R12 134.72,115.19 v2(135.12,115.19)
PCH_BLON_C: length 4.2
  TOP w0.127: R66.2 113.85,157.36 R67.2 114.74,157.49 R65.2 114.87,157.33 114.47,156.93 114.25,156.93 v1(114.06,156.75) 114.06,156.5 114.36,156.2 114.36,155.6 Q3.5
PCH_BLON_R: length 367.4
  TOP w0.127: v1(105.8,151.2) 105.8,152.17 107.47,153.84 107.47,154.79 108.41,155.73 108.41,158.12 108.88,159.2 108.94,159.34 110.3,160.7 111.41,160.7 v1(111.78,160.33) 113.09,159.02 R66.1
  IN1 w0.14: v1(161.09,36.29) 160.41,36.29 158.5,34.39 154.47,34.39 146.35,26.26 125.56,26.26 122.33,29.48 114.71,29.48 113.86,28.63 110.67,28.63 110.09,29.2 107.03,29.2 105.46,30.78 87.66,30.78 79.89,23.01 71.29,23.01 66.8,18.52 66.02,18.52 65.13,19.41 50.34,19.41 46.84,22.91 42.17,22.91 v1(39.45,20.19) ; v1(27.9,18.71) 27.69,18.92 27.69,23.02 28.23,23.56 28.23,27.14 31.31,30.22 31.31,34.98 33.25,36.93 33.25,51.41 32.73,51.94 32.73,53.06 25.5,60.28 25.5,64.68 29.7,68.87 29.7,69.33 31.94,71.58 33.78,71.58 35.09,72.89 35.09,75.29 34.68,75.7 34.68,76.98 36.28,78.58 36.28,82.23 36.82,82.78 37.13,82.78 37.9,83.55 37.9,85.31 40.77,88.18 40.77,109.29 49.49,118 61.12,118 63.54,120.43 69.51,120.43 70.71,121.62 72.7,121.62 81.41,130.33 81.41,130.33 81.51,130.43 81.59,130.49 81.93,130.72 82.13,130.79 83.61,131.31 87.31,133.8 89.48,133.8 90.33,134.65 90.33,135.97 91.08,136.72 91.78,136.72 103.38,148.33 103.38,150.34 104.25,151.2 v1(105.8,151.2)
  BOTTOM w0.127: v1(27.9,18.71) 28.24,18.37 37.64,18.37 v1(39.45,20.19) ; v1(161.09,36.29) 161.35,36.04 163.48,36.04 165.67,33.85 167.24,33.85 167.72,34.34 169.32,34.34 170.12,35.14 170.12,35.71 169.89,35.94 169.89,36.79 170.34,37.23 170.34,37.84 170.7,38.2 U45.88
PCH_BRIGHT: length 132.8
  IN1 w0.076: v2(134.46,116.31) 134.46,116.43 135.61,117.57 136.09,117.57 136.4,117.89 137.16,117.89 137.27,118
  IN1 w0.14: v1(108.29,132.33) 108.29,133.24 114.1,139.06 114.1,140.69 116.02,142.6 116.02,144.09 ; 116.02,144.09 116.02,146.21 114.31,147.92 114.31,156.59 113.95,156.94 113.95,159 114.48,159.53 114.48,163.06 117.43,166.01 124.44,166.01 127.01,168.57 130.87,168.57 131.27,168.98 131.27,170.02 130.59,170.71 127.11,170.71 126.32,171.5 125.91,171.5 123.73,169.31 v1(121.7,169.31) ; 116.02,144.09 116.05,144.06 122.51,144.06 125.08,141.5 125.08,139.49 127.56,137 138.74,137 147.71,128.04 147.71,122.78 148.63,121.85 148.63,121.42 148.01,120.8 148.01,120.62 146.79,119.4 139.5,119.4 138.36,118.26 137.52,118.26 137.27,118
  BOTTOM w0.127: R546.1 108.76,131.85 v1(108.29,132.33) ; U35.R11 134.79,115.73 134.46,116.06 v2(134.46,116.31) ; v1(121.7,169.31) 121.7,169.82 121.44,170.07 121.23,170.07 CN5.27
PCH_DP_HPD: length 12.3
  TOP w0.127: R564.2 R10846.1 146.86,118.88 146.86,118.27 v1(146.72,118.13)
  IN1 w0.14: v2(137.76,117.27) 138.28,117.78 138.63,117.78 138.82,117.6 142.12,117.6 143.16,118.64 146.21,118.64 v1(146.72,118.13)
  BOTTOM w0.127: U35.L7 137.62,117.55 137.62,117.41 v2(137.76,117.27)
PCH_MBCLK0_R: length 26.5
  TOP w0.127: v2(137.76,115.32) 138.01,115.56 138.03,115.56 138.31,115.84 139.93,115.84 R578.2 ; v1(152.66,115.39) 152.66,116.1 152.51,116.25 151.1,116.25 150.97,116.38 150.97,116.53 151.1,116.66 v1(152.86,116.66) 153.45,116.66 153.57,116.78 153.57,117.39 153.66,117.48 Q32.6
  IN2 w0.14: v2(137.76,115.32) 138.25,115.81 139.67,115.81 140.14,115.34 146.25,115.34 146.77,114.82 152.07,114.82 152.1,114.85 152.84,114.85 152.94,114.95 152.94,115.21 152.84,115.31 152.74,115.31 v1(152.66,115.39)
  BOTTOM w0.127: U35.R7 137.43,115.65 v2(137.76,115.32)
PCH_MBDAT0_R: length 26.5
  TOP w0.127: R580.2 139.57,116.1 138.17,116.1 137.91,115.84 137.54,115.84 v2(137.09,116.29) ; v1(153.22,115.82) v1(154.16,116.76) 154.39,116.99 155,116.99 155.38,117.37 155.38,118.51 155.65,118.78 Q32.3
  IN2 w0.14: v1(153.22,115.82) 152.43,115.82 151.72,115.11 146.89,115.11 146.37,115.63 140.29,115.63 139.82,116.1 138.1,116.1 137.85,115.84 137.47,115.84 137.09,116.23 v2(137.09,116.29)
  BOTTOM w0.127: v2(137.09,116.29) 137.09,116.04 U35.R8
PCH_ODD_EN: length 111.3
  TOP w0.127: v1(221.34,103.5) v1(222.15,103.5) 223.42,103.5 224.31,104.39 225.08,104.39 R703.2 ; v1(148.01,121.81) 158.04,121.81 162.64,117.22 162.64,113.87 163.19,113.32 163.19,109.89 163.51,109.57 163.51,107.88 165.02,106.37 171.74,106.37 171.97,106.14 179.2,106.14 179.81,105.53 v1(179.97,105.53)
  IN1 w0.076: v2(133.85,116.31) 133.92,116.31 134.3,116.69 134.49,116.69 135.54,117.74 136.02,117.74 136.33,118.06 136.91,118.06 137.29,118.43 137.29,118.58 137.29,118.59 137.29,118.91 137.29,118.92 137.29,119.5 137.57,119.78 138.21,119.78 138.46,120.03
  IN1 w0.14: 138.46,120.03 139.12,120.03 139.38,119.78 144.51,119.78 145.37,120.64 147.33,120.64 148.01,121.33 v1(148.01,121.81)
  BOTTOM w0.127: v2(133.85,116.31) 133.85,116.42 134.18,116.75 U35.N12 ; v1(179.97,105.53) 179.94,105.51 179.94,104.36 180.64,103.66 186.64,103.66 187.02,103.28 192.39,103.28 192.83,102.85 207.61,102.85 208.21,103.45 214.23,103.45 215.6,104.82 220.02,104.82 v1(221.34,103.5)
PCH_PWRBTN#: length 12.5
  BOTTOM w0.079: 132.26,100.65 132.54,100.93 132.54,101.27 132.27,101.54 U35.BA15
  BOTTOM w0.127: R677.2 138.74,93.88 138.74,96.03 137.85,96.92 135.82,96.92 133.94,98.8 133.68,98.8 132.26,100.21 132.26,100.65
PCH_PWROK: length 386.8
  IN1 w0.14: v1(39.07,30.47) 39.07,29.03 37.7,27.66 37.7,20.21 39.7,18.21 43.84,18.21 44.61,17.45 64.31,17.45 65.22,16.54 67.64,16.54 72.15,21.05 80.96,21.05 88.73,28.82 104.65,28.82 107.24,26.23 113.77,26.23 115.3,24.71 116.41,24.71 118.82,22.3 123.7,22.3 125.42,24.01 138.99,24.01 140.12,22.88 146.16,22.88 155.38,32.1 164.98,32.1 165.54,32.66 167.06,32.66 167.54,32.18 170.14,32.18 172.6,34.64 v1(173.36,34.64) 173.41,34.69 173.41,35.28 175.32,37.18 175.32,37.87 175.32,37.88 175.32,38.26 174.87,38.72 174.87,39.43 174.27,40.03 174.27,41.53 173.62,42.18 173.01,42.18 171.66,43.53 171.66,45.74 170.85,46.56 170.85,51.84 171.3,52.29 171.3,52.74 170.05,54 170.05,58.84 169.68,59.2 169.68,62.24 164.43,67.5 164.43,68.8 163.24,69.98 163.24,78.98 160.66,81.55 v1(160.18,81.55)
  BOTTOM w0.127: R103.2 91.75,121.3 90.96,120.52 89.57,120.52 89.21,120.16 88.83,120.16 87.71,119.04 82.45,119.04 76.05,112.64 75.34,112.64 71.81,109.11 69.35,109.11 59.06,98.83 50.44,98.83 45.17,93.55 45.17,80.81 49.47,76.51 49.47,71.26 47.07,68.86 47.07,68.12 33.28,54.33 33.28,46.73 36.59,43.42 36.59,41.51 36.04,40.96 36.04,36.94 39.07,33.91 v1(39.07,31.57) v1(39.07,30.47) ; R647.2 R648.1 133.67,93.63 133.41,93.36 133.41,92.55 145.51,80.45 158.77,80.45 159.87,81.55 v1(160.18,81.55) ; U45.78 172.28,34.2 172.73,34.64 v1(173.36,34.64)
PCH_RSMRST#: length 12.8
  BOTTOM w0.079: U35.AY17 130.71,102.03 130.71,101.2 130.68,101.16
  BOTTOM w0.127: 130.68,101.16 130.68,99.73 132.55,97.86 132.55,97.27 133.41,96.41 134.3,96.41 135.06,95.65 R661.2 135.3,95.53 135.57,95.27 135.57,94.26 R642.1 R655.2
PCH_SLP_A#: length 81.7
  IN1 w0.14: v1(170.41,78.12) 170.47,78.18 170.47,81.36 170.22,81.61 170.08,81.75 170.08,82.77 168.57,84.29 168.57,85.63 167.98,86.22 167.98,87.19 169.17,88.39 169.17,90.95 v1(170.16,91.94) ; v1(160.2,75.84) 160.2,75.98 159.36,76.83 157.28,76.83 156.9,77.21 156.9,78.22 154.87,80.26 154.87,84.32 151.95,87.24 151.95,90.8 150.76,91.99 150.76,96.21 148.29,98.67 137.65,98.67 133.58,102.74 133.58,106.65 133.28,106.95 132.74,106.95 132.36,106.57 v2(132.21,106.57)
  BOTTOM w0.127: v1(160.2,75.84) 160.28,75.76 160.77,75.76 v1(161.08,76.07) 163.78,78.77 166.21,78.77 166.76,78.22 170.32,78.22 v1(170.41,78.12) ; v2(132.21,106.57) 131.88,106.8 U35.AN16 ; v1(170.16,91.94) 169.6,91.94 169.27,91.61 169.27,91.31 169.26,91.3 169.26,90.67 169.27,90.66 169.27,90.52 169.59,90.21 R273.2
PCH_SLP_LAN#: length 2.4
  TOP w0.127: v2(133.09,103.86) 133.09,103.46 133.56,102.99 TP30.1
  BOTTOM w0.114: U35.AW15 132.52,103.33 132.52,103.49 132.89,103.86 v2(133.09,103.86)
PCH_SLP_S5#: length 61.5
  IN1 w0.14: v1(168.08,84.73) 167.09,85.72 167.09,88.83 167.62,89.36 167.62,91.13 v1(168.23,91.74)
  BOTTOM w0.089: 131.5,100.83 131.53,100.86 131.53,101.29 131.35,101.47 131.35,101.89 131.32,101.92 131.32,102.2 131.64,102.52 U35.AY16
  BOTTOM w0.127: R279.2 168.49,90.21 168.23,90.47 v1(168.23,91.74) ; v1(168.08,84.73) 168.01,84.66 168.01,83.35 167.38,82.72 v1(166.81,82.72) 160.03,82.72 159.41,82.72 158.15,81.46 148.72,81.46 144.92,85.26 142.37,85.26 136.33,91.31 136.33,94 135.82,94.51 135.82,95.75 133.6,97.97 133.33,97.97 131.4,99.91 131.4,100.73 131.5,100.83
PCH_SLP_SUS#: length 38.2
  IN2 w0.14: v2(133.12,106.48) 133.57,106.03 133.57,103.67 133.89,103.35 134.27,103.35 140.04,97.58 148.11,97.58 150.58,95.12 150.58,92.48 149.19,91.09 149.19,88.12 149.66,87.65 v1(149.97,87.65)
  BOTTOM w0.127: TP4369.1 153.71,86.1 153.05,86.76 150.68,86.76 149.97,87.47 v1(149.97,87.65) ; U35.AN15 v2(133.12,106.48)
PCH_SLP_WLAN#: length 5.7
  BOTTOM w0.127: U35.BB17 130.94,100.95 130.94,99.76 132.75,97.95 132.75,97.45 133.28,96.92 TP23.1
PCH_SPI_CLK: length 95.8
  TOP w0.127: v1(157.21,49.37) 157.84,48.75 168.28,48.75 169.61,50.08 v1(176.59,50.08) 177.37,50.08 177.56,49.89 178.78,49.89 179.44,50.55 C747.1 180.15,50.55 R684.2
  IN2 w0.14: v1(157.21,49.37) 157.77,49.92 157.77,50.87 157.24,51.4 157.24,52.98 156.83,53.4 156.83,54.02 157.32,54.52 157.32,57.06 156.83,57.55 156.83,58.31 157.32,58.81 157.32,67.72 156.94,68.1 156.94,74.33 156.48,74.78 156.48,83.98 156.23,84.23 156.23,87.21 156.48,87.45 156.48,89 157,89.53 157,98.51 156.01,99.51 151.29,99.51 148.72,102.08 145.12,102.08 144.93,102.27 144.23,102.27 143.76,102.74 142.63,102.74 v1(142.17,103.19)
  BOTTOM w0.079: v1(142.17,103.19) 141.77,103.59 141.45,103.59 141.19,103.86 140.11,103.86 139.86,103.61 U35.AV2
PCH_SPI_CLK_EC: length 15.2
  TOP w0.127: R687.1 v1(180.9,53.08)
  BOTTOM w0.127: U45.105 176.38,43.91 176.04,44.25 176.04,44.79 175.57,45.26 175.57,47.81 C4726.1 175.09,48.58 177.53,51.02 177.53,51.88 178.98,53.33 180.66,53.33 v1(180.9,53.08)
PCH_SPI_CS0#: length 96
  TOP w0.127: v1(157.84,51.48) 158.12,51.2 158.5,51.2 159.09,50.62 v1(162.06,50.62) 162.82,50.62 163.66,51.45 165.59,51.45 166.17,52.04 167.83,52.04 175.03,59.24 177.93,59.24 R602.2 178.81,58.93 v1(178.87,59)
  IN2 w0.14: v1(142.91,103.22) 143.03,103.35 144.07,103.35 144.45,102.97 145.27,102.97 145.62,102.61 149.92,102.61 150.45,102.08 150.45,101.09 151.5,100.03 156.22,100.03 157.54,98.72 157.54,93.11 157.99,92.65 157.99,89.78 157,88.78 157,87.24 156.75,86.99 156.75,84.45 157,84.2 157,75 157.46,74.54 157.46,68.32 157.84,67.94 v1(157.84,51.48)
  BOTTOM w0.079: 142.55,103.65 142.45,103.76 141.52,103.76 141.25,104.02 139.78,104.02 U35.AU3
  BOTTOM w0.127: U41.1 178.36,58.49 v1(178.87,59) ; 142.55,103.65 142.91,103.3 v1(142.91,103.22)
PCH_SPI_IO2: length 95.9
  TOP w0.127: v1(155.33,49.7) 155.53,49.7 156.09,50.26 v1(156.09,50.69) 156.09,51.22 157.19,52.32 158.84,52.32 158.89,52.27 165.11,52.27 165.69,52.85 167.57,52.85 174.72,60 179.57,60 180.62,58.96 R589.1
  IN2 w0.14: v1(141.43,102.25) 141.03,101.85 141.03,100.98 142.37,99.64 149.03,99.64 153.88,94.79 153.88,92.28 152.83,91.22 152.83,76.71 153.6,75.94 153.6,63.46 153.94,63.12 153.94,51.34 154.92,50.36 154.92,50.11 v1(155.33,49.7)
  BOTTOM w0.079: v1(141.43,102.25) 141.22,102.25 140.97,102.5 140.69,102.5 140.19,103 U35.AW2
PCH_SPI_IO3: length 91.5
  TOP w0.127: v1(154.03,49.73) 154.03,49.4 v1(154.37,49.05) 154.62,48.81 155.86,48.81 157.11,50.06 157.88,50.06 158.68,49.26 168.07,49.26 169.4,50.59 177.62,50.59 R239.1
  IN2 w0.14: v1(154.03,49.73) 154.03,49.88 153.16,50.76 153.16,62.79 152.81,63.13 152.81,75.61 152.04,76.38 152.04,91.55 153.09,92.6 153.09,94.74 148.77,99.05 141.94,99.05 140.09,100.91 140.09,102.43 v2(138.73,103.79)
  BOTTOM w0.079: U35.AU4 138.86,103.92 v2(138.73,103.79)
PCH_SPI_SI: length 102.7
  TOP w0.127: R691.2 183.5,53.16 v1(183.44,53.21) 182.48,54.17 182.48,55.95 182.68,56.15 182.68,57.88 181.16,59.41 180.56,59.41 179.69,60.28 174.6,60.28 167.5,53.18 165.46,53.18 164.83,52.55 159,52.55 158.95,52.6 157.07,52.6 156.23,51.76 v1(155.45,51.76)
  IN2 w0.14: v1(155.45,51.76) 155.01,52.2 155.01,63.56 154.67,63.9 154.67,65.2 155.42,65.95 155.42,76.67 154.9,77.19 154.9,87.71 155.18,87.99 155.18,89.54 155.71,90.06 155.71,95.63 154.81,96.52 153.52,96.52 148.54,101.49 144.96,101.49 144.71,101.75 142.63,101.75 v2(142.09,102.28)
  BOTTOM w0.079: U35.AV3 139.46,103.33 140.5,103.33 140.69,103.14 140.69,103.14 140.95,103.14 141.41,102.69 141.69,102.69 v2(142.09,102.28)
PCH_SPI_SI_EC: length 22.1
  TOP w0.127: v1(181.44,53.59) 182.17,52.85 R654.1 182.58,52.35 182.81,52.58 182.81,53.14 181.79,54.16 v1(181.79,54.17)
  BOTTOM w0.127: v1(181.44,53.59) 180.59,54.44 179.37,54.44 179.18,54.25 179.18,54.25 177.46,52.53 176.61,52.53 176.18,52.11 176.18,51.26 175.68,50.76 175.68,50.75 173.23,48.31 173.23,46.45 173.45,46.24 173.45,45.47 173.7,45.22 R735.1 174.42,44.73 174.42,44.58 175.18,43.82 U45.102
PCH_SPI_SO: length 96.4
  TOP w0.127: v1(155.43,50.41) 155.2,50.41 154.87,50.08 154.87,49.53 155.18,49.22 155.66,49.22 156.57,50.13 156.57,51.07 157.44,51.94 158.68,51.94 159.48,51.14 v1(159.72,51.14) 162.8,51.14 163.53,51.86 165.44,51.86 166.05,52.47 167.72,52.47 174.87,59.62 179.22,59.62 179.51,59.34 R650.1
  IN2 w0.14: v1(155.43,50.41) 154.34,51.51 154.34,63.28 153.99,63.62 153.99,76.1 153.22,76.87 153.22,91.06 154.27,92.11 154.27,94.8 152.66,96.41 149.18,99.89 143.14,99.89 142.16,100.87 v2(142.16,101.24)
  BOTTOM w0.089: U35.AW3 139.83,102.75 139.83,102.31 139.89,102.25 139.89,102.24 140.1,102.03 140.31,102.03 140.45,101.89 141.24,101.89 141.4,101.72 141.68,101.72
  BOTTOM w0.127: v2(142.16,101.24) 141.68,101.72
PCH_SPI_SO_EC: length 17.1
  TOP w0.127: R588.1 v1(179.51,55.54) 179.51,54.05 v1(179.56,53.99)
  BOTTOM w0.127: U45.103 175.58,43.8 175.27,44.11 175.25,44.11 174.67,44.69 174.67,45.41 174.67,45.41 174.67,46.52 174.62,46.57 174.62,46.94 174.65,46.97 174.65,47.54 R736.1 173.92,48.63 176.44,51.15 176.44,52 176.71,52.28 177.57,52.28 179.28,53.99 v1(179.56,53.99)
PCH_SUSPWRACK: length 85.7
  TOP w0.127: R11114.2 155.85,71.98 v1(155.89,71.94) 156.33,71.5 v1(157.18,71.5) 157.28,71.39 R11140.1
  IN1 w0.14: v1(155.15,43.17) 155.23,43.25 155.91,43.25 156.12,43.46 156.12,44.03 159.01,46.92 159.01,51.99 158.53,52.46 158.53,54.22 158.41,54.35 158.41,58.62 157.94,59.09 157.94,69.64 157.1,70.48 157.1,70.94 156.1,71.94 v1(155.89,71.94) ; v1(183.6,37.46) 183.6,36.98 181.79,35.17 181.79,33.73 181.31,33.24 175.47,33.24 171.18,28.96 169.73,28.96 169.13,29.56 157.18,29.56 156.98,29.76 v1(156.97,29.76)
  BOTTOM w0.127: U45.15 185.74,35.8 185.02,36.52 184.25,36.52 183.6,37.17 v1(183.6,37.46) ; v1(155.15,43.17) 155.12,43.15 155.12,38.65 155.59,38.18 155.59,32.39 156.7,31.29 156.7,30.02 v1(156.97,29.76)
PCH_TRST#: length 22.4
  IN1 w0.14: v1(102.8,130.83) 102.8,130.65 103.1,130.35 104.35,130.35 v1(104.83,130.83)
  BOTTOM w0.076: 106.99,126.26 107.23,126.02 107.23,123.59 107.55,123.27 U35.B59 ; 106.61,125.52 106.72,125.41 106.72,122.91 106.43,122.62 U35.C61
  BOTTOM w0.127: v1(104.83,130.83) 104.83,129.56 104.97,129.42 R534.2 105.34,128.8 105.97,128.16 105.97,127.27 106.99,126.26 ; 106.61,125.52 105.21,126.92 105.21,127.78 104.32,128.67 103.31,128.67 102.8,129.18 v1(102.8,130.83)
PCH_TYPEC_UPFB#: length 160.9
  TOP w0.127: v2(138.41,117.27) 139,117.27 139.4,117.67 140.09,117.67 v1(140.18,117.76) 140.29,117.88 145.17,117.88 145.45,117.6 147.81,117.6 148.16,117.95 148.16,119.3 147.94,119.53 145.6,119.53 144.86,120.26 v1(144.86,121.91) ; v1(29.65,103.12) R11252.1 v1(30.43,102.39) R11251.1
  IN1 w0.14: v1(50.96,102.46) 50.96,104.29 51.47,104.79 64.6,104.79 84.28,124.48 89.06,124.48 92.51,127.93 95.59,127.93 96.01,128.35 107.18,128.35 110.12,131.29 110.88,131.29 111.84,130.32 120,130.32 122.92,133.24 140.01,133.24 144.13,129.13 144.13,125.19 144.86,124.45 v1(144.86,121.91)
  BOTTOM w0.127: v1(50.96,102.46) 50.12,101.62 48.98,101.62 46.34,98.98 32.98,98.98 30.43,101.53 v1(30.43,102.39) ; U35.L6 138.28,117.54 138.28,117.39 v2(138.41,117.27)
PCH_VRALERT#: length 31.6
  TOP w0.114: v2(134.52,107.98) 134.99,107.5 136.28,107.5 137.13,106.65 137.13,105.79
  TOP w0.127: 137.13,105.79 138.21,104.72 139.2,104.72 141.2,102.71 143.48,102.71 143.56,102.64 143.57,102.64 143.77,102.43 144.89,102.43 144.99,102.33 151.47,102.33 152.2,101.59 157.11,101.59 157.59,101.11 TP19.1 159.24,101.11 159.68,100.67 160.08,100.67 160.56,100.19 160.56,99.06 R211.2
  BOTTOM w0.127: v2(134.52,107.98) 134.5,107.96 U35.AM11
PCI_PLTRST#: length 46.7
  TOP w0.127: v2(134.95,107.1) 135.87,107.1 136.24,106.73 136.24,106.32 138.3,104.27 139.01,104.27 140.04,103.25 140.04,102.46 140.75,101.75 144.61,101.75 144.94,101.42 148.01,101.42 148.27,101.16 v1(150.37,101.16) 156.93,101.16 157.52,100.57 159.15,100.57 159.49,100.22 v1(159.9,100.22)
  IN2 w0.14: v1(159.9,100.22) 160.84,99.28 v1(160.84,88.01)
  BOTTOM w0.127: v2(134.95,107.1) 135.25,106.8 U35.AN10 ; U14.1 162.45,85.48 162.59,85.62 162.59,86 162.46,86.13 U14.2 161.27,86.13 160.41,86.99 160.41,87.57 v1(160.84,88.01)
PCIE_CLKREQ_NGFF_SSD#: length 14.9
  TOP w0.127: v1(154.77,94.18) 154.06,94.89 R11111.1
  BOTTOM w0.127: v1(154.77,94.18) 155.38,93.57 v1(155.38,93.15) 155.38,91.18 155.15,90.95 154.57,90.95 154.39,90.78 154.39,90.31 154.66,90.04 156.22,90.04 158.52,92.34 160.97,92.34 161.45,92.82 R11110.2
PCIE_CLKREQ_NGFF_SSD#_R: length 2.3
  BOTTOM w0.127: R11110.1 162.11,94.07 162,94.18 162,95.88 CN23.52
PCIE_CLKREQ_WLAN#: length 115.6
  TOP w0.114: R253.1 177.34,177.04 R241.1 177.34,175.72 v1(177.35,175.71) 177.4,175.71 v1(177.91,175.2) ; v1(154.74,92.86) R224.1
  IN2 w0.114: v1(161.65,161.89) 161.3,161.54 161.3,160.62 161.45,160.46 162.74,159.17 164.24,157.67 164.24,149.09 162.68,147.53 162.68,143.74 163.15,143.27 163.15,139.75 157.84,134.44 v1(153.98,134.44)
  BOTTOM w0.114: v1(153.98,134.44) 153.78,134.23 153.78,133.09 155.73,131.13 155.73,125.22 161.94,119.01 161.94,110.81 160.45,109.32 160.45,104.63 159.31,103.5 159.31,101.62 157.26,99.56 155.15,99.56 154.84,99.26 154.68,99.15 154.32,98.78 154.21,98.62 154.21,97.58 155.25,96.54 155.25,94.79 155.09,94.63 154.58,94.63 154.23,94.28 154.23,93.06 154.44,92.86 v1(154.74,92.86) ; v1(161.65,161.89) 161.65,162.25 162.97,163.57 162.97,166.39 166.58,170 167.29,170 168.4,171.1 174.54,171.1 177.88,174.44 177.88,175.18 v1(177.91,175.2) 177.97,175.26 Q23.3
PCIE_LAN_WAKE#: length 409.7
  TOP w0.127: v1(46.82,76.19) 46.97,76.35 R713.2 ; v1(175.85,58.8) 175.13,58.8 170.25,53.92 170.25,52.59 169.99,52.33 169.82,52.33 169.07,51.58 166.5,51.58 165.92,51 v1(165.18,51) v1(164.37,51)
  IN1 w0.14: v1(164.37,51) 164.52,50.85 164.52,48.15 159.63,43.26 159.63,42.06 157.75,40.18 156.74,40.18 149.29,32.74 144.64,32.74 142.34,30.45 128.28,30.45 125.1,33.62 110.01,33.62 109.72,33.92 86.39,33.92 86.35,33.88 85.93,33.88 79.91,27.85 79.91,26.52 78.99,25.6 62.52,25.6 60.64,23.72 54.13,23.72 52.99,24.86 49,24.86 44.05,29.81 44.05,29.83 44.05,32.62 44.79,33.36 44.79,34.67 v1(43.92,35.53) ; v1(175.85,58.8) 175.46,59.19 175.46,61.17 175.06,61.56 175.06,63.41 175.06,66.12 170.84,70.34 170.84,74.75 169.54,76.05 169.54,81.33 169.41,81.47 169.41,81.85 168.73,82.53 167.91,82.53 167.54,82.89 167.54,83.42 v1(167.27,83.69) 166.81,84.16 166.81,88.95 167.34,89.48 167.34,91.53 167.65,91.83 167.65,95.3 169.02,96.67 169.02,103.02 170.4,104.4 170.4,105.92 171.1,106.61 171.1,109.05 167.63,112.52 167.63,113.65 156.37,124.91 156.37,132.02 158.15,133.8 159.11,133.8 v1(159.7,134.39) ; v1(35.86,43.3) 35.86,44.15 35.08,44.94 35.08,52.17 33.81,53.44 33.81,56.24 35.19,57.61 35.19,60.54 36.52,61.88 36.52,63.12 37.29,63.88 37.59,63.88 38.74,65.02 39.34,65.02 43.11,68.79 43.11,69.45 44.34,70.68 46.18,70.68 47.33,71.83 47.33,75.92 47.05,76.19 v1(46.82,76.19)
  IN2 w0.14: v1(159.7,134.39) 164.57,139.26 164.57,147.31 165.19,147.93 165.19,158.02 162.9,160.32 162.9,161.82 v1(162.79,161.92) ; v1(35.86,43.3) 35.86,41 41.33,35.53 v1(43.92,35.53)
  BOTTOM w0.127: v1(162.79,161.92) 164.17,163.29 164.17,166.29 166.96,169.08 167.67,169.08 168.78,170.19 174.92,170.19 178.89,174.15 179.1,174.15 R244.1 ; U35.BB15 132.05,100.87 132.05,100.13 133.59,98.59 133.85,98.59 135.78,96.67 137.72,96.67 138.36,96.03 138.36,95.39 R250.1 137.85,90.95 142.75,86.05 145.25,86.05 149.07,82.22 157.47,82.22 159.54,84.3 160.31,84.3 160.86,83.74 167.23,83.74 v1(167.27,83.69)
PCIE_LAN_WAKE#_R: length 15.5
  TOP w0.127: U15.39 41.59,71.26 42.11,70.75 v1(42.28,70.75) ; v1(42.48,80.53) R702.2 R709.1 44.5,79.4 Q39.1 44.81,79.27 v1(45.69,78.39)
  IN1 w0.14: v1(45.69,78.39) 45.45,78.39 42.83,75.78 42.83,71.14 42.44,70.75 v1(42.28,70.75)
PCIE_RCOMPN: length 1.3
  TOP w0.305: v2(137.72,120.59) 138.05,120.59 R562.2
  BOTTOM w0.305: v2(137.72,120.59) 137.88,120.59 138.13,120.34 U35.F5
PCIE_RCOMPP: length 1.7
  TOP w0.305: v2(138.97,121.38) 138.64,121.71 R562.1
  BOTTOM w0.305: v2(138.97,121.38) 138.8,121.38 138.65,121.23 138.39,121.23 U35.E5
PCIE_REQ_LAN#_R: length 11.8
  TOP w0.114: U15.29 37.3,68.99 37.24,68.93 37.24,68.45 36.94,68.14 36.94,66.09 36.58,65.73 35.36,65.73 v1(35.06,65.42) 34.85,65.22 33.83,65.22 33.2,64.59 R276.1 ; R276.1 33.71,64.04 33.71,63.27 34.35,62.63 Q25.1 ; R276.1 R277.2
PCIE_RX5+_LAN: length 155.6
  TOP w0.114: C4601.2 33.38,66.06 33.38,65.93 33.08,65.63 31.77,65.63 31.11,64.97 31.11,61.53 30.99,61.41 30.9,61.41 v1(30.64,61.67)
  IN2 w0.114: v2(126.73,121.36) 126.6,121.48 126.37,121.48 126.25,121.36 126.25,120.4 125.95,120.1 125.57,120.1 124.96,119.49 106.65,119.49 105.86,120.28 101.64,120.28 100.96,120.96 97.05,120.96 95.29,122.71 91.53,122.71 88.65,119.83 85.01,119.83 83,117.83 82,117.83 73.67,109.49 54.51,109.49 48.85,103.83 48.85,100.65 46.53,98.32 46.53,84.83 48.01,83.34 48.01,81.22 49.88,79.36 49.88,70.8 48.39,69.31 47.58,69.31 45.27,67 44.76,67 39.91,62.15 38.11,62.15 37.37,61.41 30.9,61.41 v1(30.64,61.67)
  BOTTOM w0.114: U35.E23 127.26,121.07 127.26,121.43 127.16,121.53 126.9,121.53 v2(126.73,121.36)
PCIE_RX5+_LAN_C: length 4.1
  TOP w0.127: C4601.1 33.43,67.64 33.43,67.86 34.09,68.52 35.13,68.52 35.7,69.09 U15.25
PCIE_RX5-_LAN: length 155.6
  TOP w0.114: v1(30.64,60.88) 30.95,61.2 31.08,61.2 31.17,61.28 31.21,61.28 31.32,61.4 31.32,61.44 31.32,64.88 31.86,65.41 33.17,65.41 33.59,65.84 33.59,66.06 C4602.2
  IN2 w0.114: v2(126.73,120.67) 126.7,120.67 126.52,120.49 126.46,120.43 126.46,120.3 126.04,119.88 125.66,119.88 125.05,119.27 106.56,119.27 105.77,120.06 101.56,120.06 100.87,120.75 96.96,120.75 95.2,122.5 91.62,122.5 88.74,119.62 85.1,119.62 83.09,117.61 82.09,117.61 73.76,109.28 54.6,109.28 49.07,103.74 49.07,100.56 46.74,98.23 46.74,84.92 48.23,83.43 48.23,81.31 50.09,79.45 50.09,70.71 48.48,69.1 47.67,69.1 45.36,66.78 44.85,66.78 40,61.93 38.2,61.93 37.46,61.2 30.95,61.2 v1(30.64,60.88)
  BOTTOM w0.114: v2(126.73,120.67) 127.77,120.67 U35.E22
PCIE_RX5-_LAN_C: length 4.1
  TOP w0.127: U15.26 36.1,69.06 35.31,68.27 34.25,68.27 33.71,67.74 33.71,67.47 C4602.1
PCIE_RX6+_WLAN: length 136.8
  IN2 w0.114: v1(125.84,121.28) 125.84,121.25 125.61,121.03 125.36,121.03 125.02,120.7 124.59,120.7 124.01,120.11 122.83,120.11 122.3,120.65 122.2,120.65 121.74,121.11 121.74,123.07 120.66,124.15 120.66,126.38 125.11,130.84 129.13,130.84 131.25,132.96 138.96,132.96 140.2,134.2 150.92,134.2 151.33,134.6 153.26,134.6 153.87,135.21 157.91,135.21 161.05,138.36 161.05,145.96 157.54,149.47 157.54,154.71 160.28,157.45 160.28,162.05 162.71,164.47 163.75,164.47 166.05,166.77 166.05,167.94 167.52,169.41 191.36,169.41 194.34,172.4 194.34,174.14 v1(194.57,174.37)
  BOTTOM w0.114: U35.E25 126.13,120.99 v1(125.84,121.28) ; CN10.41 191.95,182 192.09,181.86 193.53,181.86 194.46,180.93 194.46,178.44 195.19,177.71 196.01,177.71 196.3,177.41 196.3,176.42 194.89,175.01 194.48,175.01 194.33,174.86 194.33,174.61 v1(194.57,174.37)
PCIE_RX6-_WLAN: length 136.9
  IN2 w0.114: v2(125.79,120.59) 125.79,120.72 125.68,120.83 125.44,120.83 125.08,120.48 124.68,120.48 124.12,119.92 122.75,119.92 122.22,120.45 122.09,120.45 121.52,121.02 121.52,122.98 120.44,124.06 120.44,126.47 125.02,131.06 129.04,131.06 131.16,133.18 138.87,133.18 140.11,134.41 150.83,134.41 151.24,134.82 153.17,134.82 153.78,135.43 157.82,135.43 160.84,138.45 160.84,145.87 157.32,149.38 157.32,154.8 160.06,157.54 160.06,162.14 162.62,164.69 163.66,164.69 165.83,166.86 165.83,168.03 167.43,169.63 191.27,169.63 194.13,172.49 194.13,174.15 v1(193.91,174.37)
  BOTTOM w0.114: CN10.43 191.95,181.5 192.09,181.64 193.44,181.64 194.24,180.84 194.24,178.35 195.1,177.49 195.92,177.49 196.08,177.32 196.08,176.51 194.8,175.23 194.39,175.23 194.11,174.95 194.11,174.57 v1(193.91,174.37) ; v2(125.79,120.59) 126.01,120.59 U35.F25
