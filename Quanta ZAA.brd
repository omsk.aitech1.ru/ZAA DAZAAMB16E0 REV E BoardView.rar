# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ21: length 73
  IN1 w0.14: v1(93.2,48.13) 93.2,48.16 92.76,48.6 92.76,53.95 92.65,54.07 92.49,54.07 92.38,54.18 92.38,54.34 92.49,54.46 92.65,54.46 92.76,54.57 92.76,54.74 92.65,54.85 92.41,54.85 92.3,54.97 92.3,55.13 92.41,55.25 92.65,55.25 92.76,55.36 92.76,55.52 92.65,55.64 92.39,55.64 92.27,55.76 92.27,55.92 92.39,56.03 92.51,56.03 92.62,56.15 92.62,56.31 92.51,56.43 92.39,56.43 92.27,56.54 92.27,63.09 91.97,63.39 91.97,68.82 91.59,69.2 91.59,85.84 91.46,85.97 91.32,85.97 91.2,86.1 91.2,90.23 89.8,91.63 89.8,96.31 92.63,99.15 98.93,99.15 v1(99.31,98.77)
  BOTTOM w0.079: U35.AY65 103.71,102.16 103.71,101.93 103.66,101.8 103.66,101.53 103.49,101.19 103.49,100.95 102.43,99.89 102.01,99.89 101.57,99.45 99.99,99.45 v1(99.31,98.77)
  BOTTOM w0.127: JDIM1.49 94.72,49.41 93.48,48.16 93.23,48.16 v1(93.2,48.13)
M_A_DQ22: length 73
  IN1 w0.079: 100.19,95.39 100.19,96.6 v1(100.62,97.03) ; 100.29,95.3 100.29,94.92 100.14,94.77 100.14,94.39
  IN1 w0.089: 100.29,95.3 100.19,95.39
  IN1 w0.14: v1(97.43,48.66) 97.43,48.69 96.65,49.47 96.65,50.07 96.76,50.19 97,50.19 97.12,50.3 97.12,50.46 97,50.58 96.76,50.58 96.65,50.69 96.65,59.14 97.27,59.77 97.27,62.66 96.24,63.69 96.24,65.49 97.28,66.53 97.28,70.96 97.17,71.07 96.64,71.07 96.53,71.19 96.53,71.35 96.64,71.47 97.17,71.47 97.28,71.58 97.28,71.74 97.17,71.86 96.64,71.86 96.53,71.97 96.53,72.14 96.64,72.25 97.17,72.25 97.28,72.37 97.28,72.53 97.17,72.65 96.64,72.65 96.53,72.76 96.53,72.92 96.64,73.04 97.17,73.04 97.28,73.16 97.28,73.32 97.17,73.43 96.64,73.43 96.53,73.55 96.53,73.71 96.64,73.83 97.17,73.83 97.28,73.94 97.28,74.11 97.17,74.22 96.64,74.22 96.53,74.34 96.53,74.5 96.64,74.61 97.17,74.61 97.28,74.73 97.28,74.89 97.17,75.01 96.64,75.01 96.53,75.12 96.53,75.29 96.64,75.4 97.17,75.4 97.28,75.52 97.28,75.68 97.17,75.8 96.64,75.8 96.53,75.91 96.53,76.07 96.64,76.19 97.17,76.19 97.28,76.3 97.28,76.47 97.17,76.58 96.64,76.58 96.53,76.7 96.53,83.26 96.39,83.4 96.39,88.27 100.14,92.02 100.14,94.39
  BOTTOM w0.079: v1(100.62,97.03) 100.85,97.03 102.37,98.55 102.85,98.55 103.94,99.64 105.01,99.64 105.54,100.17 105.54,101.25 105.27,101.52 U35.BA63
  BOTTOM w0.127: JDIM1.63 98.22,50.42 98.46,50.18 98.46,49.4 97.72,48.66 v1(97.43,48.66)
M_A_DQ23: length 72
  IN1 w0.079: 99.8,94.39 99.8,94.85 100.01,95.06 100.01,97.07 v1(100.62,97.68)
  IN1 w0.14: v1(97.64,46.45) 96.96,47.13 96.96,48.48 96.33,49.11 96.33,59.74 96.15,59.92 96.15,62.61 95.9,62.85 95.9,66.04 96.04,66.18 96.04,66.67 96.15,66.79 96.82,66.79 96.94,66.91 96.94,67.07 96.82,67.18 96.15,67.18 96.04,67.3 96.04,67.46 96.15,67.58 96.82,67.58 96.94,67.69 96.94,67.86 96.82,67.97 96.15,67.97 96.04,68.09 96.04,68.25 96.15,68.36 96.82,68.36 96.94,68.48 96.94,68.64 96.82,68.76 96.15,68.76 96.04,68.87 96.04,69.04 96.15,69.15 96.82,69.15 96.94,69.27 96.94,69.43 96.82,69.55 96.15,69.55 96.04,69.66 96.04,69.82 96.15,69.94 96.82,69.94 96.94,70.05 96.94,70.22 96.82,70.33 96.15,70.33 96.04,70.45 96.04,88.63 99.8,92.39 99.8,94.39
  BOTTOM w0.079: U35.BB63 105.35,101.01 105.35,100.21 104.95,99.82 103.87,99.82 102.77,98.72 102.27,98.72 101.22,97.68 v1(100.62,97.68)
  BOTTOM w0.127: v1(97.64,46.45) 96.75,45.56 96.75,44.52 96.97,44.3 JDIM1.58
M_A_DQ24: length 64.8
  IN1 w0.14: v1(98.9,49.43) 98.97,49.43 99.34,49.8 99.34,50.67 99.22,50.79 98.87,50.79 98.75,50.9 98.75,51.06 98.87,51.18 99.22,51.18 99.34,51.29 99.34,51.46 99.22,51.57 98.87,51.57 98.75,51.69 98.75,51.85 98.87,51.97 99.22,51.97 99.34,52.08 99.34,52.24 99.22,52.36 98.87,52.36 98.75,52.48 98.75,52.64 98.87,52.75 99.22,52.75 99.34,52.87 99.34,53.03 99.22,53.15 98.87,53.15 98.75,53.26 98.75,53.43 98.87,53.54 99.22,53.54 99.34,53.66 99.34,55.03 99.22,55.15 98.81,55.15 98.69,55.26 98.69,55.43 98.81,55.54 99.22,55.54 99.34,55.66 99.34,55.82 99.22,55.93 98.81,55.93 98.69,56.05 98.69,56.21 98.81,56.33 99.22,56.33 99.34,56.44 99.34,59.59 98.65,60.28 98.65,63.79 99.23,64.38 99.23,65.53 98.72,66.05 98.72,88.6 101.34,91.23 101.34,95.17 101.4,95.23 101.4,95.77 v1(102.72,97.09)
  BOTTOM w0.079: v1(102.72,97.09) 103.16,97.52 103.16,98.06 104.2,99.11 105.18,99.11 106.03,99.96 106.03,101.24 106.3,101.51 U35.BA61
  BOTTOM w0.127: v1(98.9,49.43) 99.4,49.93 99.4,50.29 99.22,50.46 JDIM1.67
M_A_DQ25: length 65.7
  IN1 w0.14: v1(99.45,46.65) 99.45,46.62 99.32,46.5 98.43,46.5 98.3,46.62 98.3,64.1 98.84,64.64 98.84,65.37 98.37,65.84 98.37,88.78 100.94,91.35 100.94,95.24 101.05,95.35 101.05,96.07 v1(102.72,97.74)
  BOTTOM w0.079: U35.AW61 106.4,102.85 106.09,102.54 106.09,101.99 105.86,101.77 105.86,100.03 105.12,99.28 104.1,99.28 102.85,98.04 102.85,97.87 v1(102.72,97.74)
  BOTTOM w0.127: JDIM1.70 99.97,46.13 v1(99.45,46.65)
M_A_DQ26: length 64.8
  IN1 w0.14: v1(102.97,46.89) 102.88,46.98 102.88,48.2 102.5,48.58 102.5,50.37 102.61,50.49 103.02,50.49 103.14,50.6 103.14,50.76 103.02,50.88 102.61,50.88 102.5,51 102.5,51.16 102.61,51.27 103.02,51.27 103.14,51.39 103.14,51.55 103.02,51.67 102.61,51.67 102.5,51.78 102.5,51.95 102.61,52.06 103.02,52.06 103.14,52.18 103.14,52.34 103.02,52.45 102.61,52.45 102.5,52.57 102.5,52.73 102.61,52.85 102.95,52.85 103.07,52.96 103.07,53.13 102.95,53.24 102.61,53.24 102.5,53.36 102.5,54.83 101.99,55.34 101.99,62.8 102.17,62.97 102.17,88.13 103.52,89.48 103.52,94.2 v1(104.65,95.33)
  BOTTOM w0.079: U35.BB59 107.66,101.04 107.66,100.22 107.28,99.84 107.28,99.53 105.72,97.96 105.72,96.97 105.1,96.36 105.1,95.79 v1(104.65,95.33)
  BOTTOM w0.127: JDIM1.84 103.47,46.4 102.98,46.89 v1(102.97,46.89)
M_A_DQ27: length 66.8
  IN1 w0.14: v1(102.97,45.57) 102.63,45.57 102.47,45.72 102.47,48.2 102.22,48.45 102.22,51.25 102.05,51.42 101.92,51.42 101.81,51.53 101.81,51.69 101.92,51.81 102.1,51.81 102.22,51.92 102.22,52.09 102.1,52.2 101.87,52.2 101.76,52.32 101.76,52.48 101.87,52.6 102.01,52.6 102.12,52.71 102.12,52.88 102.01,52.99 101.86,52.99 101.75,53.11 101.75,53.27 101.86,53.38 102.02,53.38 102.14,53.5 102.14,53.66 102.02,53.78 101.82,53.78 101.7,53.89 101.7,54.06 101.82,54.17 102.02,54.17 102.13,54.28 102.13,54.62 101.66,55.08 101.66,64.47 101.76,64.57 101.76,88.22 103.16,89.61 103.16,94.21 104.18,95.23 104.18,95.59 104.57,95.98 v1(104.65,95.98)
  BOTTOM w0.079: U35.AW59 106.94,103.04 106.76,102.86 106.76,102.31 106.67,102.19 106.67,102.02 106.74,101.84 106.74,101.62 106.73,101.61 106.73,101.61 106.73,101.6 106.69,101.51 106.69,101.32 106.73,101.22 106.74,101.18 106.74,100.88 106.52,100.66 106.52,99.74 105.3,98.52 104.43,98.52 104.11,98.2 104.11,96.52 v1(104.65,95.98)
  BOTTOM w0.127: JDIM1.80 102.47,45.07 v1(102.97,45.57)
M_A_DQ28: length 64.2
  IN1 w0.14: v1(99.47,45.21) 99.53,45.15 99.85,45.15 99.98,45.28 99.98,46.79 99.66,47.11 99.66,47.42 99.55,47.53 99.01,47.53 98.89,47.65 98.89,47.81 99.01,47.93 99.52,47.93 99.66,48.07 99.66,59.95 99.05,60.56 99.05,63.69 99.58,64.22 99.58,65.72 99.07,66.23 99.07,88.31 101.74,90.98 101.74,95.46 v1(102.72,96.44)
  BOTTOM w0.079: v1(102.72,96.44) 103.38,97.1 103.38,98.04 104.27,98.93 105.23,98.93 106.19,99.89 106.19,100.98 U35.BB61
  BOTTOM w0.127: v1(99.47,45.21) 98.97,44.71 JDIM1.66
M_A_DQ29: length 65.5
  IN1 w0.14: v1(102.72,95.76) 102.16,95.21 102.16,90.84 99.45,88.13 99.45,66.36 99.94,65.87 99.94,64.13 99.43,63.62 99.43,62.37 99.54,62.26 99.64,62.26 99.76,62.14 99.76,61.98 99.64,61.86 99.54,61.86 99.43,61.75 99.43,61.59 99.54,61.47 99.63,61.47 99.74,61.36 99.74,61.19 99.63,61.08 99.54,61.08 99.43,60.96 99.43,60.72 99.94,60.21 99.94,56.25 100.05,56.14 100.34,56.14 100.46,56.02 100.46,55.86 100.34,55.75 100.05,55.75 99.94,55.63 99.94,55.47 100.05,55.35 100.4,55.35 100.52,55.24 100.52,55.07 100.4,54.96 100.05,54.96 99.94,54.84 99.94,54.68 100.05,54.56 100.4,54.56 100.52,54.45 100.52,54.29 100.4,54.17 100.05,54.17 99.94,54.06 99.94,52.55 100.05,52.44 100.76,52.44 100.88,52.32 100.88,52.16 100.76,52.04 100.05,52.04 99.94,51.93 99.94,51.77 100.05,51.65 100.76,51.65 100.88,51.54 100.88,51.37 100.76,51.26 100.05,51.26 99.94,51.14 99.94,50.95 100.05,50.83 100.58,50.83 100.66,50.75 100.66,50.07 100.55,49.96 100.38,49.96 v1(100.22,50.11)
  BOTTOM w0.079: v1(102.72,95.76) 103.17,96.21 103.17,96.36 103.64,96.83 103.64,97.99 104.37,98.72 105.26,98.72 106.36,99.82 106.36,100.72 106.57,100.93 106.57,101.16 106.53,101.28 106.53,101.29 106.53,101.54 106.58,101.67 106.58,101.8 106.53,101.92 106.53,101.92 106.5,102.02 106.5,102.28 U35.AY61
  BOTTOM w0.127: JDIM1.71 v1(100.22,50.11)
M_A_DQ30: length 65.5
  IN1 w0.14: v1(104.65,94.68) 103.86,93.89 103.86,89.32 102.53,87.99 102.53,66.4 103.36,65.56 103.36,64.51 103.23,64.38 102.68,64.38 102.56,64.27 102.56,64.1 102.68,63.99 103.32,63.99 103.44,63.87 103.44,63.71 103.32,63.6 102.68,63.6 102.56,63.48 102.56,63.32 102.68,63.2 103.32,63.2 103.44,63.09 103.44,59.92 103.32,59.8 102.49,59.8 102.37,59.69 102.37,59.53 102.49,59.41 103.32,59.41 103.44,59.29 103.44,56.27 103.32,56.16 102.84,56.16 102.72,56.04 102.72,55.88 102.84,55.76 103.32,55.76 103.44,55.65 103.44,55.49 103.32,55.37 102.94,55.37 102.82,55.25 102.82,55.09 102.94,54.98 103.32,54.98 103.44,54.86 103.44,50.04 103.31,49.91 v1(103.1,49.91)
  BOTTOM w0.079: v1(104.65,94.68) 105.54,95.57 105.54,95.68 105.34,95.88 105.34,96.02 105.44,96.12 105.57,96.12 105.75,95.94 105.9,95.94 106.01,96.05 106.01,96.2 105.9,96.31 105.9,96.48 106.03,96.61 106.03,97.98 106.34,98.28 106.45,98.28 106.69,98.05 106.8,98.05 106.92,98.17 106.92,98.28 106.69,98.52 106.69,98.63 106.81,98.76 106.92,98.76 107.16,98.52 107.27,98.52 107.4,98.64 107.4,98.75 107.16,98.99 107.16,99.1 107.45,99.39 107.45,99.77 107.91,100.23 107.91,101.15 107.83,101.33 107.74,101.52 107.63,101.74 U35.BA59
  BOTTOM w0.127: v1(103.1,49.91) 103.22,50.04 JDIM1.83
M_A_DQ31: length 66.3
  IN1 w0.14: v1(104.65,94.03) 104.21,93.59 104.21,89.18 102.87,87.84 102.87,66.86 103.82,65.9 103.82,60.55 103.94,60.43 104.4,60.43 104.52,60.31 104.52,60.15 104.4,60.04 103.94,60.04 103.82,59.92 103.82,59.76 103.94,59.64 104.4,59.64 104.52,59.53 104.52,59.36 104.4,59.25 103.94,59.25 103.82,59.13 103.82,56.28 103.94,56.16 104.27,56.16 104.38,56.05 104.38,55.88 104.27,55.77 103.94,55.77 103.82,55.65 103.82,55.49 103.94,55.37 104.27,55.37 104.38,55.26 104.38,55.1 104.27,54.98 103.94,54.98 103.82,54.86 103.82,54.7 103.94,54.59 104.27,54.59 104.38,54.47 104.38,54.31 104.27,54.19 103.94,54.19 103.82,54.08 103.82,53.91 103.94,53.8 104.27,53.8 104.38,53.68 104.38,53.52 104.27,53.41 103.94,53.41 103.82,53.29 103.82,48.7 103.7,48.57 103.23,48.57 v1(103.19,48.61)
  BOTTOM w0.079: v1(104.65,94.03) 106.39,95.78 106.39,97.33 107.66,98.6 107.66,99.75 108.07,100.15 108.07,101.18 108.02,101.3 107.94,101.57 107.94,101.86 107.62,102.18 U35.AY59
  BOTTOM w0.127: JDIM1.79 102.22,48.85 102.47,48.61 v1(103.19,48.61)
M_A_DQ32: length 67.8
  IN1 w0.079: v1(119.38,93.29) 119.62,93.05 119.62,90.75 119.81,90.57
  IN1 w0.14: v1(127.15,46.66) 127.72,46.66 128.68,47.62 128.68,51.35 129.54,52.21 129.54,55.19 130.5,56.14 130.5,62.86 128.9,64.45 128.9,75.19 129.05,75.34 129.24,75.34 129.36,75.45 129.36,75.61 129.24,75.73 129.01,75.73 128.89,75.84 128.89,76.01 129.47,76.58 129.47,78.68 124.69,83.46 124.69,85.68 119.81,90.57
  BOTTOM w0.079: U35.AY39 118.67,102.18 118.4,101.91 118.4,101.62 118.3,101.38 118.3,101.36 118.23,101.23 118.23,100.02 118.44,99.81 118.44,99.18 118.17,98.9 118.17,94.5 v1(119.38,93.29)
  BOTTOM w0.127: JDIM1.170 126.97,44.22 126.67,44.52 126.67,46.17 v1(127.15,46.66)
M_A_DQ33: length 65.7
  IN1 w0.079: v1(119.38,98.49) 118.76,97.88 118.76,93.09 119.06,92.79 119.06,92.58
  IN1 w0.14: 119.06,92.58 119.06,90.49 123.99,85.56 123.99,83.18 128.2,78.97 128.2,64 129.22,62.99 129.22,55.78 128.8,55.37 128.8,52.44 126.55,50.18 126.55,48.57 127.01,48.12 v1(127.15,48.12)
  BOTTOM w0.079: v1(119.38,98.49) 119.76,98.88 119.76,100.65 119.55,100.87 119.55,101.18 119.62,101.36 119.62,101.43 119.54,101.68 119.54,101.81 119.62,102.04 119.62,102.23 119.54,102.38 119.54,102.82 119.33,103.04 U35.AW39
  BOTTOM w0.127: v1(127.15,48.12) 127.89,48.85 127.89,50.29 127.72,50.46 JDIM1.173
M_A_DQ34: length 68.2
  IN1 w0.079: 120.63,91.45 120.43,91.64 120.43,96.79 v1(119.38,97.84)
  IN1 w0.14: v1(131.57,48.74) 131.15,49.16 131.15,51.4 131.47,51.73 131.47,54.66 132.64,55.83 132.64,59.86 132.85,60.07 132.85,63.1 131.36,64.59 131.36,69.07 131.71,69.42 131.71,71.53 131.6,71.64 131.11,71.64 130.99,71.76 130.99,71.92 131.11,72.03 131.54,72.03 131.66,72.15 131.66,72.31 131.54,72.43 131.1,72.43 130.99,72.54 130.99,72.71 131.1,72.82 131.57,72.82 131.68,72.94 131.68,73.1 131.57,73.22 131.1,73.22 130.99,73.33 130.99,73.49 131.1,73.61 131.55,73.61 131.66,73.72 131.66,73.89 131.55,74 131.1,74 130.98,74.12 130.98,74.28 131.1,74.4 131.38,74.4 131.5,74.51 131.5,79.31 126.61,84.19 126.61,85.46 120.63,91.45
  BOTTOM w0.079: v1(119.38,97.84) 119.93,98.39 119.93,100.72 119.71,100.94 119.71,101.17 119.78,101.32 119.78,101.44 119.72,101.67 119.72,101.81 119.79,102.03 119.79,102.28 U35.AY37
  BOTTOM w0.127: v1(131.57,48.74) 130.41,49.9 130.41,50.21 130.22,50.39 JDIM1.183
M_A_DQ35: length 68.5
  IN1 w0.079: 120.79,91.69 120.6,91.89 120.6,94.68 v1(121.15,95.24)
  IN1 w0.14: 120.79,91.69 126.98,85.51 126.98,84.32 131.84,79.45 131.84,78.87 131.96,78.76 132.3,78.76 132.42,78.64 132.42,78.48 132.3,78.36 131.96,78.36 131.84,78.25 131.84,78.09 131.96,77.97 132.3,77.97 132.42,77.85 132.42,77.69 132.3,77.58 131.96,77.58 131.84,77.46 131.84,76.51 131.96,76.4 132.3,76.4 132.42,76.28 132.42,76.12 132.3,76 131.96,76 131.84,75.89 131.84,75.72 131.96,75.61 132.3,75.61 132.42,75.49 132.42,75.33 132.3,75.21 131.96,75.21 131.84,75.1 131.84,74.94 131.96,74.82 132.3,74.82 132.42,74.71 132.42,74.54 132.3,74.43 132.22,74.43 132.09,74.3 132.09,74.02 132.22,73.89 132.3,73.89 132.42,73.78 132.42,73.61 132.3,73.5 132.2,73.5 132.08,73.38 132.08,73.22 132.2,73.11 132.3,73.11 132.42,72.99 132.42,72.83 132.3,72.71 132.2,72.71 132.08,72.6 132.08,72.43 132.2,72.32 132.3,72.32 132.42,72.2 132.42,72.04 132.3,71.92 132.2,71.92 132.08,71.81 132.08,71.65 132.2,71.53 132.3,71.53 132.42,71.41 132.42,71.25 132.3,71.14 132.2,71.14 132.08,71.02 132.08,69.31 131.72,68.94 131.72,64.69 133.79,62.61 133.79,60.85 133.24,60.3 133.24,60.01 132.96,59.73 132.96,55.78 131.79,54.61 131.79,53.5 131.91,53.39 132.27,53.39 132.39,53.26 132.39,53.09 132.27,52.97 131.93,52.97 131.79,52.83 131.79,51.62 131.57,51.4 v1(131.57,50.06)
  BOTTOM w0.079: v1(121.15,95.24) 120.42,95.97 120.42,100.72 120.42,101.74 120.2,101.96 120.2,102.51 119.89,102.82 U35.AW37
  BOTTOM w0.127: v1(131.57,50.06) 131.22,50.41 JDIM1.187
M_A_DQ36: length 66.2
  IN1 w0.079: v1(119.38,94.59) 118.95,94.17 118.95,93.15 119.37,92.73 119.37,92.57
  IN1 w0.14: v1(127.15,49.45) 127.61,49.45 127.74,49.33 127.74,47.94 127.86,47.81 128.09,47.81 128.22,47.94 128.22,51.36 129.19,52.33 129.19,55.25 130.18,56.25 130.18,62.66 128.55,64.29 128.55,76.38 128.67,76.5 128.81,76.5 128.92,76.61 128.92,76.77 128.81,76.89 128.67,76.89 128.55,77 128.55,77.17 128.67,77.28 128.97,77.28 129.09,77.4 129.09,77.56 128.97,77.68 128.67,77.68 128.55,77.79 128.55,77.96 128.67,78.07 128.97,78.07 129.09,78.19 129.09,78.35 128.97,78.46 128.67,78.46 128.55,78.58 128.55,79.11 124.34,83.32 124.34,85.64 119.37,90.62 119.37,92.57
  BOTTOM w0.079: v1(119.38,94.59) 118.52,95.44 118.52,98.79 118.77,99.04 118.77,99.95 118.56,100.16 118.56,100.98 U35.BB39
  BOTTOM w0.127: JDIM1.169 126.72,50.43 126.67,50.38 126.67,49.93 v1(127.15,49.45)
M_A_DQ37: length 66.7
  IN1 w0.079: v1(119.38,93.94) 119.81,93.5 119.81,91.07 120.03,90.85
  IN1 w0.14: v1(127.14,45.34) 127.55,45.34 129.05,46.84 129.05,51.15 130.46,52.56 130.46,55.63 130.82,55.98 130.82,62.99 129.25,64.55 129.25,70.27 129.45,70.47 129.45,74.98 129.81,75.34 129.81,78.83 125.03,83.61 125.03,85.85 120.03,90.85
  BOTTOM w0.079: U35.BA39 118.67,101.59 118.52,101.45 118.52,101.44 118.52,101.44 118.39,101.18 118.39,100.09 118.61,99.88 118.61,99.11 118.34,98.83 118.34,94.98 v1(119.38,93.94)
  BOTTOM w0.127: JDIM1.174 127.97,44.77 127.4,45.34 v1(127.14,45.34)
M_A_DQ38: length 67.4
  IN1 w0.079: 121.11,91.79 120.75,92.14 120.75,94.19 v1(121.15,94.59)
  IN1 w0.14: 121.11,91.79 127.35,85.55 127.35,84.43 132.76,79.02 132.76,69.5 132.2,68.94 132.2,64.65 134.11,62.75 134.11,60.72 133.55,60.17 133.55,59.87 133.28,59.6 133.28,55.78 133.62,55.43 133.62,52.49 132.02,50.88 132.02,48.57 129.66,46.21 v1(129.66,44.8)
  BOTTOM w0.079: U35.BA37 120.26,101.46 120.26,95.48 v1(120.54,95.2) v1(121.15,94.59)
  BOTTOM w0.127: v1(129.66,44.8) 129.97,44.49 JDIM1.182
M_A_DQ39: length 66.3
  IN1 w0.14: v1(130.1,45.38) 130.1,46.19 132.34,48.42 132.34,50.7 133.93,52.3 133.93,56.63 134.69,57.39 134.69,62.75 133.23,64.2 133.23,68.69 133.12,68.8 133.12,79.14 127.7,84.56 127.7,85.55 127.43,85.83 127.4,85.83 121.15,92.07 v1(121.15,93.94)
  BOTTOM w0.079: v1(121.15,93.94) 120.09,95 120.09,100.79 119.99,100.89 U35.BB37
  BOTTOM w0.127: v1(130.1,45.38) 130.1,44.95 130.65,44.4 130.79,44.4 130.97,44.22 JDIM1.186
M_A_DQ40: length 70.7
  IN1 w0.079: 122.87,91.27 122.66,91.48 122.5,91.48 121.78,92.2 121.78,96.57 v1(121.15,97.19)
  IN1 w0.14: 122.87,91.27 128.7,85.44 128.7,84.97 134.94,78.72 134.94,74.63 134.15,73.84 134.15,69.15 134.25,69.05 134.25,64.38 135.46,63.17 135.46,55.28 134.83,54.65 134.83,51.94 133.54,50.64 133.54,49.35 132.95,48.76 132.95,46.91 131.91,45.87 131.43,45.87 131.11,46.19 v1(130.78,46.19)
  BOTTOM w0.079: U35.AY35 121.22,102.28 121.22,102.02 121.26,101.92 121.26,101.92 121.3,101.8 121.3,101.66 121.25,101.54 121.25,101.28 121.29,101.17 121.29,100.62 121.08,100.41 121.08,99.37 121.75,98.71 121.75,97.79 v1(121.15,97.19)
  BOTTOM w0.127: JDIM1.194 132.97,44.27 131.06,46.19 v1(130.78,46.19)
M_A_DQ41: length 71.2
  IN1 w0.079: 122.58,91.1 121.61,92.07 121.61,96.08 v1(121.15,96.54)
  IN1 w0.14: 122.58,91.1 128.35,85.33 128.35,84.83 134.6,78.58 134.6,74.81 134.48,74.7 134.32,74.7 134.2,74.81 134.2,78.43 134.09,78.54 133.93,78.54 133.81,78.43 133.81,68.99 133.89,68.91 133.89,64.29 135.14,63.04 135.14,56.46 135.01,56.33 134.52,56.33 134.4,56.2 134.4,55.99 134.52,55.86 134.81,55.86 134.93,55.74 134.93,55.57 134.81,55.44 134.6,55.44 134.48,55.32 134.48,52 132.93,50.45 v1(132.93,50.06)
  BOTTOM w0.079: v1(121.15,96.54) 120.59,97.11 120.59,100.65 120.59,100.65 120.59,101.77 120.81,101.99 120.81,102.54 121.12,102.85 U35.AW35
  BOTTOM w0.127: JDIM1.195 133.22,50.44 132.95,50.16 132.95,50.07 v1(132.93,50.06)
M_A_DQ42: length 70.9
  IN1 w0.14: v1(122.9,92.71) 123.66,92.71 128.41,87.96 128.92,87.96 137.96,78.92 137.96,76.23 137.85,76.12 137.68,76.12 137.57,76.23 137.57,78.63 137.45,78.74 137.29,78.74 137.17,78.63 137.17,69.63 137.01,69.47 137.01,69.05 136.9,68.94 136.67,68.94 136.56,68.82 136.56,68.66 136.67,68.54 136.9,68.54 137.01,68.43 137.01,68.26 136.9,68.15 136.66,68.15 136.54,68.03 136.54,67.87 136.66,67.76 136.9,67.76 137.01,67.64 137.01,67.48 136.9,67.36 136.66,67.36 136.54,67.25 136.54,67.08 136.66,66.97 136.9,66.97 137.01,66.85 137.01,64.36 138.11,63.27 138.11,56.12 137.67,55.69 137.67,52.64 136.73,51.7 136.73,51.23 135.74,50.23 v1(135.74,50.04)
  BOTTOM w0.079: U35.AY33 122.35,102.18 122.62,101.91 122.62,101.56 122.67,101.46 122.78,101.21 122.78,100.82 122.6,100.63 122.6,100.36 122.76,100.19 122.76,98.06 123.44,97.38 123.44,93.25 v1(122.9,92.71)
  BOTTOM w0.127: v1(135.74,50.04) 136.22,50.52 JDIM1.207
M_A_DQ43: length 69.8
  IN1 w0.079: v1(122.9,93.35) 123.38,93.35 128.46,88.27 128.65,88.27
  IN1 w0.14: v1(135.77,48.66) 135.82,48.66 136.4,49.25 136.4,50.31 137.06,50.97 137.06,51.62 138,52.56 138,55.52 138.99,56.51 138.99,62.88 137.43,64.45 137.43,66.66 137.52,66.75 137.52,75.66 137.63,75.77 137.8,75.77 137.91,75.66 137.91,75.29 138.03,75.17 138.19,75.17 138.31,75.29 138.31,79.13 129.17,88.27 128.65,88.27
  BOTTOM w0.079: U35.AW33 121.68,103.04 121.49,102.84 121.49,102.31 121.4,102.19 121.4,102.02 121.46,101.84 121.46,101.61 121.46,101.6 121.45,101.6 121.41,101.5 121.41,101.33 121.45,101.22 121.45,100.55 121.25,100.35 121.25,99.44 121.91,98.77 121.91,94.34 v1(122.9,93.35)
  BOTTOM w0.127: JDIM1.203 135.22,49.21 v1(135.77,48.66)
M_A_DQ44: length 68.9
  IN1 w0.079: v1(121.15,97.84) 121.94,97.05 121.94,92.33 122.57,91.71 122.88,91.71 123.14,91.45
  IN1 w0.14: 123.14,91.45 129.05,85.54 129.05,85.1 135.28,78.86 135.28,74.47 134.5,73.68 134.5,69.38 134.6,69.28 134.6,64.48 136.33,62.75 136.33,59.96 135.74,59.38 135.74,55.08 135.14,54.47 135.14,51.83 133.83,50.52 133.83,49.22 133.24,48.64 133.24,46.77 131.35,44.87 v1(130.79,44.87)
  BOTTOM w0.079: U35.BB35 121.02,100.96 120.92,100.86 120.92,100.52 120.92,100.52 120.92,99.3 121.58,98.64 121.58,98.27 v1(121.15,97.84)
  BOTTOM w0.127: JDIM1.190 131.97,44.12 131.22,44.87 v1(130.79,44.87)
M_A_DQ45: length 69.5
  IN1 w0.079: v1(121.15,98.49) 122.11,97.54 122.11,92.42 122.63,91.9 123.11,91.9 123.45,91.56
  IN1 w0.14: 123.45,91.56 129.39,85.62 129.39,85.24 135.63,79.01 135.63,70.31 135.51,70.2 135.35,70.2 135.23,70.31 135.23,71.67 135.12,71.79 134.95,71.79 134.84,71.67 134.84,69.52 134.96,69.41 134.96,64.57 136.65,62.88 136.65,55.34 135.49,54.19 135.49,51.78 134.25,50.53 134.25,49.09 133.76,48.61 v1(133.76,48.46)
  BOTTOM w0.079: v1(121.15,98.49) 121.15,98.78 120.75,99.18 120.75,101.24 121.02,101.51 U35.BA35
  BOTTOM w0.127: JDIM1.191 132.22,49.31 133.08,48.46 v1(133.76,48.46)
M_A_DQ46: length 69.7
  IN1 w0.079: 128.59,88.8 128.48,88.8 123.66,93.62 123.66,96.07 v1(122.93,96.8)
  IN1 w0.14: 128.59,88.8 129.62,88.8 139,79.41 139,74.6 138.88,74.47 138.8,74.47 138.68,74.35 138.68,74.17 138.8,74.05 138.88,74.05 139,73.92 139,73.79 138.88,73.66 138.33,73.66 138.2,73.54 138.2,65.83 139,65.03 139,63.95 140.33,62.62 140.33,56.69 139.19,55.54 139.19,52.91 137.65,51.38 137.65,50.71 137.27,50.33 137.27,48.71 136.48,47.92 v1(136.48,45.18)
  BOTTOM w0.079: U35.BA33 122.45,101.63 122.45,101.49 122.5,101.44 122.63,101.17 122.63,100.9 122.44,100.7 122.44,100.29 122.6,100.12 122.6,97.13 v1(122.93,96.8)
  BOTTOM w0.127: v1(136.48,45.18) 136.47,45.18 JDIM1.208
M_A_DQ47: length 68.8
  IN1 w0.079: v1(122.93,96.15) 123.5,95.58 123.5,93.49 128.46,88.53 128.69,88.53
  IN1 w0.14: 128.69,88.53 129.4,88.53 138.65,79.27 138.65,74.9 138.53,74.78 137.99,74.78 137.86,74.65 137.86,74.5 137.99,74.37 138.2,74.37 138.31,74.26 138.31,74.11 138.2,74 137.99,74 137.86,73.87 137.86,66.61 137.84,66.59 137.84,64.55 139.29,63.1 139.29,56.25 138.87,55.82 138.87,53.01 137.36,51.5 137.36,50.83 136.98,50.45 136.98,48.88 136.2,48.1 136.2,45.96 135.97,45.73 v1(135.8,45.73)
  BOTTOM w0.079: v1(122.93,96.15) 122.43,96.64 122.43,100.06 122.27,100.22 122.27,100.81 122.35,100.89 U35.BB33
  BOTTOM w0.127: v1(135.8,45.73) 135.47,45.41 JDIM1.204
M_A_DQ48: length 72.8
  IN1 w0.079: v1(124.81,93.29) 124.81,92.99 128.49,89.32 128.65,89.32
  IN1 w0.14: v1(137.89,48.78) 138.54,49.43 138.54,51.01 140.12,52.6 140.12,55.27 141.89,57.03 141.89,62.56 140,64.44 140,65.48 139.22,66.27 139.22,68.59 139.33,68.71 139.49,68.71 139.61,68.59 139.61,66.54 139.72,66.42 139.89,66.42 140,66.54 140,79.82 130.51,89.32 128.65,89.32
  BOTTOM w0.079: U35.AY31 123.65,102.27 123.34,101.97 123.34,101.57 123.2,101.22 123.2,100.84 123.39,100.66 123.39,99.81 123.7,99.49 123.7,94.4 v1(124.81,93.29)
  BOTTOM w0.127: JDIM1.211 137.22,49.19 137.63,48.78 v1(137.89,48.78)
M_A_DQ49: length 73.3
  IN1 w0.079: v1(124.81,98.49) 124.74,98.49 124.05,97.79 124.05,93.49 128.46,89.07 128.63,89.07
  IN1 w0.14: 128.63,89.07 130.26,89.07 139.66,79.68 139.66,69.3 139.54,69.19 139.38,69.19 139.26,69.3 139.26,72.91 139.15,73.02 138.98,73.02 138.87,72.91 138.87,66.1 139.66,65.31 139.66,64.28 140.67,63.26 140.67,56.45 139.81,55.58 139.81,52.69 138.25,51.13 138.25,50.68 137.89,50.32 v1(137.89,50.1)
  BOTTOM w0.079: v1(124.81,98.49) 124.84,98.52 124.84,100.43 124.54,100.72 124.54,101.23 124.55,101.25 124.59,101.35 124.59,101.46 124.52,101.7 124.52,101.79 124.61,102.04 124.61,102.26 124.56,102.35 124.56,102.79 124.32,103.04 U35.AW31
  BOTTOM w0.127: JDIM1.215 138.22,50.44 v1(137.89,50.1)
M_A_DQ50: length 72.2
  IN1 w0.079: v1(124.81,97.84) 125.99,96.67 125.99,93.28 128.63,90.63 129.3,90.63
  IN1 w0.14: 129.3,90.63 132.59,90.63 142.22,81 142.22,80.27 142.34,80.16 142.79,80.16 142.9,80.04 142.9,79.88 142.79,79.76 142.34,79.76 142.22,79.65 142.22,79.49 142.34,79.37 142.79,79.37 142.9,79.26 142.9,79.09 142.79,78.98 142.34,78.98 142.22,78.86 142.22,78.7 142.34,78.58 142.79,78.58 142.9,78.47 142.9,78.3 142.79,78.19 142.34,78.19 142.22,78.07 142.22,77.91 142.34,77.8 142.79,77.8 142.9,77.68 142.9,77.52 142.79,77.4 142.34,77.4 142.22,77.29 142.22,77.12 142.34,77.01 142.67,77.01 142.78,76.89 142.78,76.73 142.67,76.61 142.34,76.61 142.22,76.5 142.22,76.34 142.34,76.22 142.58,76.22 142.7,76.11 142.7,75.94 142.58,75.83 142.34,75.83 142.22,75.71 142.22,73.01 142.54,72.69 142.54,67.79 142.9,67.43 142.9,64.45 144.35,63 144.35,56.3 142.54,54.49 142.54,51.7 141.33,50.49 v1(141.33,50.01)
  BOTTOM w0.079: v1(124.81,97.84) 125.22,98.24 125.22,98.7 125,98.91 125,100.48 124.7,100.79 124.7,101.18 124.76,101.32 124.76,101.45 124.7,101.68 124.7,101.81 124.77,102.02 124.77,102.28 U35.AY29
  BOTTOM w0.127: JDIM1.225 140.72,50.42 141.14,50.01 v1(141.33,50.01)
M_A_DQ51: length 73.4
  IN1 w0.079: v1(126.41,95.24) 127.35,94.31 127.35,92.62 128.5,91.47 129.4,91.47
  IN1 w0.14: v1(141.47,45.25) 142.71,46.49 142.71,50.57 144.27,52.12 144.27,54.87 145.96,56.57 145.96,62.89 143.94,64.92 143.94,81.01 133.48,91.47 129.4,91.47
  BOTTOM w0.079: U35.AW29 124.87,102.82 125.18,102.51 125.18,101.96 125.4,101.74 125.4,100.79 125.5,100.7 125.5,99.27 125.73,99.03 125.73,95.92 v1(126.41,95.24)
  BOTTOM w0.127: v1(141.47,45.25) JDIM1.228
M_A_DQ52: length 71.3
  IN1 w0.079: v1(124.81,94.59) 125.38,94.02 125.38,92.97 128.52,89.83 128.68,89.83
  IN1 w0.14: v1(136.99,45.58) 139.12,47.71 139.12,50.77 140.76,52.4 140.76,55.01 142.52,56.77 142.52,62.94 140.7,64.76 140.7,67.06 141.01,67.37 141.01,68.86 140.9,68.98 140.82,68.98 140.7,69.09 140.7,69.26 140.82,69.37 140.9,69.37 141.01,69.49 141.01,69.65 140.9,69.76 140.82,69.76 140.7,69.88 140.7,70.04 140.82,70.16 140.9,70.16 141.01,70.27 141.01,70.44 140.9,70.55 140.81,70.55 140.7,70.67 140.7,70.83 140.81,70.95 140.9,70.95 141.01,71.06 141.01,71.22 140.9,71.34 140.81,71.34 140.7,71.45 140.7,71.62 140.81,71.73 140.9,71.73 141.01,71.85 141.01,72.05 140.88,72.18 140.82,72.18 140.69,72.31 140.69,80.11 130.97,89.83 128.68,89.83
  BOTTOM w0.079: v1(124.81,94.59) 124.03,95.37 124.03,99.63 123.72,99.94 123.72,100.84 123.65,100.91 U35.BB31
  BOTTOM w0.127: JDIM1.212 137.47,45.1 v1(136.99,45.58)
M_A_DQ53: length 71.8
  IN1 w0.079: 128.72,89.55 128.5,89.55 125.22,92.84 125.22,93.75 125.02,93.94 v1(124.81,93.94)
  IN1 w0.14: v1(136.99,46.9) 137.53,46.9 138.83,48.2 138.83,50.89 140.44,52.5 140.44,55.14 142.21,56.9 142.21,62.75 140.35,64.6 140.35,67.28 140.47,67.4 140.55,67.4 140.67,67.51 140.67,67.67 140.55,67.79 140.47,67.79 140.35,67.9 140.35,68.07 140.47,68.18 140.55,68.18 140.67,68.3 140.67,68.46 140.55,68.58 140.47,68.58 140.35,68.69 140.35,79.96 130.76,89.55 128.72,89.55
  BOTTOM w0.079: U35.BA31 123.65,101.73 123.6,101.68 123.6,101.68 123.37,101.19 123.37,100.91 123.55,100.72 123.55,99.87 123.87,99.56 123.87,94.88 v1(124.81,93.94)
  BOTTOM w0.127: v1(136.99,46.9) 137.27,46.9 138.47,45.7 JDIM1.216
M_A_DQ54: length 71.3
  IN1 w0.079: v1(126.41,94.59) 127.05,93.95 127.05,92.68 128.53,91.21 129.33,91.21
  IN1 w0.14: 129.33,91.21 133,91.21 143.59,80.61 143.59,64.75 144.99,63.35 144.99,56.04 143.95,55 143.95,52.22 142.42,50.69 142.42,46.85 v1(141.53,45.96)
  BOTTOM w0.079: v1(126.41,94.59) 125.56,95.44 125.56,98.94 125.33,99.17 125.33,100.62 125.24,100.72 125.24,100.93 125.24,100.93 125.24,101.24 125.24,101.24 125.24,101.33 124.97,101.59 U35.BA29
  BOTTOM w0.127: v1(141.53,45.96) 140.47,44.9 JDIM1.224
M_A_DQ55: length 71
  IN1 w0.079: v1(126.41,93.94) 126.41,93.09 128.57,90.93 129.3,90.93
  IN1 w0.14: v1(141.36,48.58) 142.05,49.27 142.05,50.76 142.86,51.57 142.86,54.36 144.67,56.17 144.67,63.18 143.25,64.61 143.25,67.57 142.88,67.94 142.88,72.84 143.01,72.97 143.11,72.97 143.22,73.08 143.22,73.23 143.11,73.34 142.68,73.34 142.56,73.46 142.56,73.62 142.68,73.74 143.11,73.74 143.23,73.85 143.23,74.01 143.11,74.13 142.68,74.13 142.56,74.24 142.56,74.41 142.68,74.52 143.12,74.52 143.24,74.64 143.24,74.8 143.12,74.92 142.81,74.92 142.69,75.03 142.69,75.2 142.81,75.31 143.13,75.31 143.25,75.43 143.25,80.46 132.78,90.93 129.3,90.93
  BOTTOM w0.079: v1(126.41,93.94) 125.4,94.95 125.4,98.76 125.17,98.99 125.17,100.56 125.07,100.65 125.07,100.99 U35.BB29
  BOTTOM w0.127: JDIM1.229 141.72,50.29 141.96,50.06 141.96,49.19 v1(141.36,48.58)
M_A_DQ56: length 76.9
  IN1 w0.14: v1(126.41,97.19) 126.54,97.19 126.83,97.48 130.86,97.48 132.88,95.46 135.38,95.46 148.36,82.48 148.36,67.38 148.48,67.26 148.64,67.26 148.76,67.38 148.76,68.9 148.87,69.01 149.04,69.01 149.15,68.9 149.15,66.32 149.71,65.75 149.71,63.49 151.5,61.7 151.5,58.12 150.4,57.02 150.4,52.34 147.88,49.83 147.07,49.83 v1(147.02,49.78)
  BOTTOM w0.079: v1(126.41,97.19) 126.98,97.76 126.98,98.73 126.16,99.55 126.16,100.79 126.3,100.93 126.3,101.12 126.28,101.17 126.24,101.28 126.23,101.41 126.23,101.54 126.28,101.64 126.28,101.82 126.23,101.97 126.2,102.04 126.2,102.28 U35.AY27
  BOTTOM w0.127: v1(147.02,49.78) 146.12,49.78 145.72,50.18 JDIM1.245
M_A_DQ57: length 76.9
  IN1 w0.14: v1(145.65,44.55) 146.39,45.29 146.39,49.91 147.92,51.45 147.92,54.12 150.02,56.21 150.02,58.58 149.36,59.24 149.36,65.62 148.02,66.96 148.02,82.33 135.23,95.12 132.73,95.12 130.75,97.1 126.97,97.1 v1(126.41,96.54)
  BOTTOM w0.079: v1(126.41,96.54) 125.99,96.97 125.99,99.02 125.66,99.35 125.66,100.77 125.57,100.86 125.57,101.77 125.8,102 125.8,102.54 126.1,102.85 U35.AW27
  BOTTOM w0.127: JDIM1.246 145.97,44.22 v1(145.65,44.55)
M_A_DQ58: length 77.1
  IN1 w0.14: v1(143.82,46.04) 144.15,46.38 144.15,50.23 146.14,52.22 146.14,54.92 147.72,56.49 147.72,62.76 146.15,64.33 146.15,68.81 145.37,69.59 145.37,72.43 145.48,72.54 145.64,72.54 145.76,72.43 145.76,71.73 145.87,71.61 146.04,71.61 146.15,71.73 146.15,80.85 134.81,92.19 134.81,92.64 134.35,93.1 128.78,93.1 v1(128.37,92.69)
  BOTTOM w0.079: v1(128.37,92.69) 128.84,93.16 128.84,97.71 128.79,97.76 128.79,98.47 127.77,99.48 127.77,101.21 127.65,101.46 127.61,101.53 127.61,101.9 127.33,102.18 U35.AY25
  BOTTOM w0.127: JDIM1.232 142.47,44.85 143.67,46.04 v1(143.82,46.04)
M_A_DQ59: length 77.4
  IN1 w0.14: v1(143.8,44.72) 143.95,44.72 144.53,45.31 144.53,50.01 146.46,51.94 146.46,54.64 148.14,56.32 148.14,62.87 146.5,64.51 146.5,69.01 145.71,69.8 145.71,70.9 145.82,71.02 145.99,71.02 146.1,70.9 146.1,70.65 146.22,70.53 146.38,70.53 146.5,70.65 146.5,80.99 135.25,92.23 135.25,92.74 134.5,93.49 128.53,93.49 v1(128.37,93.32)
  BOTTOM w0.079: v1(128.37,93.32) 127.16,94.53 127.16,98.79 126.32,99.62 126.32,100.31 126.32,100.31 126.32,100.64 126.32,100.64 126.32,100.71 126.46,100.85 126.46,101.15 126.43,101.22 126.39,101.32 126.39,101.41 126.38,101.42 126.39,101.51 126.44,101.63 126.44,101.84 126.36,102.07 126.36,102.17 126.44,102.28 126.44,102.8 126.47,102.83 126.47,102.83 126.64,103 126.64,103 126.68,103.04 U35.AW25
  BOTTOM w0.127: v1(143.8,44.72) 143.47,44.4 JDIM1.236
M_A_DQ60: length 75.2
  IN1 w0.14: v1(126.41,97.84) 131.01,97.84 133.04,95.81 135.53,95.81 148.71,82.63 148.71,69.8 148.82,69.68 148.98,69.68 149.1,69.8 149.1,70.23 149.22,70.34 149.38,70.34 149.49,70.23 149.49,66.46 150.07,65.88 150.07,63.68 151.85,61.89 151.85,57.86 150.74,56.75 150.74,52.27 147.4,48.93 147.4,48.84 v1(147.02,48.46)
  BOTTOM w0.079: U35.BB27 126,101.02 125.99,101.01 125.99,99.49 126.82,98.66 126.82,98.25 v1(126.41,97.84)
  BOTTOM w0.127: JDIM1.249 146.72,50.41 146.91,50.22 147.23,50.22 147.58,49.88 147.58,48.73 147.31,48.46 v1(147.02,48.46)
M_A_DQ61: length 75.8
  IN1 w0.14: v1(147.05,45.69) 147.05,46.78 147.71,47.44 147.71,48.82 151.09,52.2 151.09,56.59 152.24,57.74 152.24,62.02 150.42,63.84 150.42,66.01 149.84,66.6 149.84,70.52 149.05,71.3 149.05,82.8 135.7,96.15 133.18,96.15 131.14,98.19 126.95,98.19 126.65,98.49 v1(126.41,98.49)
  BOTTOM w0.079: v1(126.41,98.49) 126.19,99.06 125.83,99.42 125.83,100.84 125.73,100.93 125.73,101.29 125.82,101.38 U35.BA27
  BOTTOM w0.127: JDIM1.250 146.97,45.62 v1(147.05,45.69)
M_A_DQ62: length 75.7
  IN1 w0.079: v1(128.39,96.54) 127.77,95.92 127.77,92.46 128.55,91.68 129.38,91.68 129.63,91.93 130.18,91.93
  IN1 w0.14: v1(143.31,49.98) 143.31,50.31 144.89,51.89 144.89,54.72 146.38,56.21 146.38,63.02 144.68,64.73 144.68,80.37 144.79,80.49 144.96,80.49 145.07,80.37 145.07,76.47 145.19,76.35 145.35,76.35 145.47,76.47 145.47,80.51 134.54,91.44 134.2,91.44 133.71,91.93 130.18,91.93
  BOTTOM w0.079: U35.BA25 127.33,101.59 127.48,101.44 127.48,101.43 127.49,101.43 127.6,101.18 127.6,99.39 128.39,98.61 v1(128.39,97.33) v1(128.39,96.54)
  BOTTOM w0.127: JDIM1.237 143.72,50.4 v1(143.31,49.98)
M_A_DQ63: length 74.8
  IN1 w0.079: 129.48,92.15 129.24,91.91 128.55,91.91 127.95,92.51 127.95,95.45 v1(128.39,95.89)
  IN1 w0.14: v1(143.31,48.66) 143.37,48.66 143.79,49.09 143.79,50.28 145.83,52.32 145.83,55.14 147.4,56.71 147.4,62.57 145.81,64.16 145.81,68.66 145.02,69.45 145.02,75.41 145.14,75.52 145.3,75.52 145.42,75.41 145.42,73.68 145.53,73.57 145.69,73.57 145.81,73.68 145.81,80.66 134.67,91.81 134.2,91.81 133.3,92.71 130.05,92.71 129.48,92.15
  BOTTOM w0.079: U35.BB25 127.33,100.97 127.44,100.86 127.44,99.31 127.97,98.77 127.97,96.31 v1(128.39,95.89)
  BOTTOM w0.127: v1(143.31,48.66) 143.18,48.66 142.72,49.12 JDIM1.233
M_A_DQS0: length 84.9
  IN1 w0.127: v1(84.24,47.07) 84.77,47.6 84.77,47.75 84.94,47.92 84.94,51.04 83.73,52.26 82.82,52.26 81.98,53.09 81.98,57.78 81.63,58.14 80.79,58.14 80.34,58.59 80.34,71.58 81.28,72.52 81.28,78.32 82.57,79.61 82.57,98.95 91.2,107.58 93.94,107.58 v1(94.75,108.39)
  BOTTOM w0.079: U35.AM69 101.53,107.34 101.27,107.6 100.81,107.6 100.59,107.7 100.44,107.7 100.28,107.64 99.8,107.64 99.73,107.7 97.85,107.7 97.82,107.74 95.01,107.74 94.75,108 v1(94.75,108.39)
  BOTTOM w0.127: v1(84.24,47.07) 84.24,47.25 84.69,47.7 84.89,47.7 85.61,48.41 85.61,50.27 85.72,50.38 JDIM1.13
M_A_DQS1: length 75.9
  IN1 w0.079: 92.91,103.26 93.16,103.51 97.16,103.51 98.2,104.55 98.36,104.55 v2(98.72,104.92)
  IN1 w0.089: 92.9,103.26 92.91,103.26
  IN1 w0.127: 92.9,103.26 87.08,97.43 87.08,84.54 87.44,84.18 87.44,70.96 88.03,70.37 88.03,55.56 89.48,54.11 89.48,46.43 89.98,45.93 90.12,45.93 90.27,46.09 90.27,46.41 v1(90.1,46.58)
  BOTTOM w0.079: U35.AT70 101.16,104.73 101.1,104.67 100.75,104.67 100.6,104.62 100.42,104.62 100.29,104.67 99.81,104.67 99.65,104.51 98.46,104.51 98.41,104.57 98.41,104.73 98.6,104.92 v2(98.72,104.92)
  BOTTOM w0.127: v1(90.1,46.58) 90.1,46.14 90.26,45.99 90.49,45.99 90.89,45.59 90.89,44.3 90.97,44.21 JDIM1.34
M_A_DQS2: length 72.6
  IN1 w0.102: 94.63,64.3 94.63,64.56
  IN1 w0.127: 94.63,64.3 94.53,64.21 94.17,64.21 93.9,63.95 93.9,63.3 94.1,63.11 94.17,63.04 94.47,63.04 94.65,62.85 94.65,62.54 94.64,62.53 94.64,59.92 94.46,59.73 94.13,59.73 93.87,59.47 93.87,58.95 94.13,58.69 94.57,58.69 94.63,58.63 94.63,57.41 94.64,57.39 94.64,56.15 94.45,55.96 94.19,55.96 93.96,55.74 93.96,55.21 94.2,54.97 94.51,54.97 94.63,54.85 94.63,54.12 94.64,54.11 94.64,53.28 94.89,53.03 95.17,53.03 95.28,52.93 95.28,52.34 95.17,52.24 94.67,52.24 94.41,51.98 94.41,51.3 94.67,51.04 95.16,51.04 95.26,50.95 95.26,50.63 95.18,50.55 95.13,50.55 95.05,50.47 94.9,50.47 94.65,50.23 94.65,49.44 94.07,48.87 94.07,47.68 94.66,47.1 95.31,47.1 95.67,47.47 95.68,47.47 96.11,47.9 v1(96.14,47.9) ; v1(99.19,96.03) 98.73,95.57 98.73,93.34 94.63,89.23 94.63,88.5 94.63,88.49 94.63,86.4 94.63,86.4 94.63,69.6 94.63,69.6 94.63,65.31 94.63,65.3 94.63,64.56
  BOTTOM w0.079: U35.AY64 104.51,102.56 104.46,102.52 104.38,102.52 104.31,102.44 104.3,102.44 104.22,102.31 104.17,102.17 104.17,101.95 104.23,101.8 104.23,101.67 104.15,101.51 104.15,101.32 104.23,101.15 104.23,100.91 102.58,99.26 102.07,99.26 101.76,98.95 100.43,98.95 100.04,98.56 100.04,96.36 99.71,96.03 99.37,96.03 v1(99.19,96.03)
  BOTTOM w0.127: v1(96.14,47.9) 95.93,47.9 95.67,48.15 95.67,48.41 96.11,48.84 96.11,50.22 96.22,50.34 JDIM1.55
M_A_DQS3: length 65.7
  IN1 w0.127: v1(104.64,97.29) 104.64,97.22 104.38,96.96 103.86,96.96 103.65,96.74 103.65,95.41 102.55,94.31 102.55,90.3 100.88,88.63 100.88,54.43 101.16,54.14 101.16,50.58 101.01,50.43 101.01,48.5 101.73,47.77 101.73,46.67 101.47,46.41 101.24,46.41 101.05,46.6 101.05,46.86 v1(101.11,46.91)
  BOTTOM w0.079: U35.BA60 106.96,102.27 107,102.31 107.15,102.31 107.17,102.29 107.17,102.29 107.25,102.13 107.25,102 107.19,101.87 107.19,101.61 107.26,101.45 107.26,101.37 107.18,101.19 107.18,100.84 107.33,100.69 107.33,100.34 106.86,99.87 106.86,99.64 105.21,97.99 105.21,97.25 105.01,97.05 104.88,97.05 104.64,97.29 v1(104.64,97.29)
  BOTTOM w0.127: JDIM1.76 101.47,44.21 101.37,44.32 101.37,44.86 101.82,45.31 101.82,46.26 101.55,46.53 101.36,46.53 101.11,46.78 v1(101.11,46.91)
M_A_DQS4: length 67.3
  IN1 w0.089: v1(119.38,95.89) 119.58,96.09 119.77,96.09 120.01,95.86 120.01,91.33 120.23,91.1 120.23,91.09 120.26,91.06 120.26,91.03 120.27,91.02
  IN1 w0.127: 120.27,91.02 125.68,85.62 125.68,83.87 130.46,79.09 130.46,75.08 130.1,74.72 130.1,71.02 130.37,70.75 130.63,70.75 130.75,70.64 130.75,70.26 130.61,70.12 130.37,70.12 130.1,69.85 130.1,68.68 130.46,68.32 130.46,64.37 132,62.84 132,60.75 131.44,60.19 131.44,55.67 130.87,55.11 130.87,52.31 130.35,51.79 130.35,48.75 130.27,48.67 129.89,48.67 129.72,48.83 v1(129.72,49.46)
  BOTTOM w0.079: U35.AY38 119.23,102.52 119.21,102.5 119.15,102.5 119.03,102.45 118.94,102.31 118.9,102.2 118.9,101.93 118.95,101.82 118.95,101.65 118.87,101.49 118.87,101.33 118.95,101.16 118.95,100.9 118.76,100.71 118.76,100.24 118.98,100.03 118.98,98.99 118.79,98.81 118.79,96.34 119.01,96.13 119.28,96.13 119.38,96.03 v1(119.38,95.89)
  BOTTOM w0.127: v1(129.72,49.46) 129.72,49.04 129.62,48.94 129.2,48.94 129.05,49.09 129.05,50.36 129.22,50.53 JDIM1.179
M_A_DQS5: length 70.4
  IN1 w0.079: v1(122.93,94.04) 122.47,93.58 122.47,92.57 122.82,92.22 123.68,92.22 127.42,88.48 127.48,88.48 127.49,88.47
  IN1 w0.127: 127.49,88.47 127.49,88.47 136.53,79.43 136.53,69.9 135.85,69.21 135.85,64.72 137.18,63.39 137.18,52.77 136.18,51.77 136.18,51.27 135.28,50.38 135.28,46.75 134.91,46.37 134.77,46.37 134.56,46.16 v1(134.56,45.78)
  BOTTOM w0.079: v1(122.93,94.04) 122.74,94.24 122.73,94.24 122.72,94.25 122.55,94.25 122.1,94.69 122.1,99.92 121.91,100.11 121.91,101.22 121.97,101.36 121.97,101.47 121.9,101.64 121.9,101.84 121.98,102.02 121.98,102.09 121.92,102.23 121.87,102.31 121.83,102.33 121.75,102.33 121.68,102.27 121.68,102.06 U35.BA34
  BOTTOM w0.127: JDIM1.200 134.47,44.45 134.13,44.79 134.13,46.25 134.32,46.44 134.45,46.44 134.56,46.33 v1(134.56,45.78)
M_A_DQS6: length 72.3
  IN1 w0.079: v2(124.81,95.89) 125.21,95.89 125.6,95.5 125.6,93.08 127.79,90.89 127.79,90.86 127.79,90.85
  IN1 w0.127: 127.79,90.85 128.52,90.13 131.64,90.13 141.34,80.42 141.34,72.64 141.66,72.32 141.66,67.43 142,67.09 142,64.44 143.69,62.74 143.69,56.69 141.87,54.86 141.87,52.26 140.6,50.99 140.6,49.01 140.02,48.42 139.72,48.42 139.63,48.51 v1(139.63,49.17)
  BOTTOM w0.079: U35.AY30 124.21,102.52 124.19,102.5 124.05,102.5 124.02,102.47 123.94,102.33 123.94,102.32 123.89,102.23 123.89,102.21 123.87,102.16 123.87,101.96 123.88,101.94 123.88,101.93 123.93,101.82 123.93,101.67 123.9,101.6 123.86,101.5 123.86,101.31 123.94,101.13 123.94,100.61 123.88,100.55 123.88,100.54 123.88,100.53 123.88,100.03 124.24,99.67 124.24,96.27 124.39,96.12 124.71,96.12 124.81,96.02 v2(124.81,95.89)
  BOTTOM w0.127: v1(139.63,49.17) 139.63,48.59 139.53,48.49 139.04,48.49 138.74,48.79 138.74,48.98 139.63,49.87 139.63,50.37 139.72,50.47 JDIM1.221
M_A_DQS7: length 76.5
  IN1 w0.127: v1(145.69,45.92) 145.69,46.29 145.55,46.43 145.28,46.43 144.95,46.76 144.95,49.68 147.1,51.82 147.1,54.46 148.74,56.1 148.74,63.25 147.14,64.85 147.14,81.87 134.81,94.19 128.62,94.19 v1(128.39,93.97)
  BOTTOM w0.079: v1(128.39,93.97) 128.39,94.11 128.27,94.23 128.01,94.23 127.44,94.8 127.44,98.82 127.12,99.14 127.12,100.64 126.94,100.83 arc(126.91,100.87) 126.9,100.92 126.9,100.99 126.9,101.15 arc(126.9,101.16) 126.9,101.17 126.93,101.35 126.94,101.45 arc(126.94,101.45) 126.94,101.46 126.91,101.58 126.91,101.59 arc(126.91,101.6) 126.91,101.6 126.88,101.68 arc(126.87,101.71) 126.87,101.74 126.88,101.77 126.9,101.81 arc(126.9,101.82) 126.9,101.83 126.93,101.97 arc(126.93,101.98) 126.93,101.98 126.94,102.05 arc(126.94,102.06) 126.94,102.06 126.93,102.14 arc(126.93,102.15) 126.93,102.16 126.93,102.16 arc(126.93,102.17) 126.92,102.18 126.91,102.22 arc(126.9,102.23) 126.9,102.24 126.85,102.31 126.81,102.33 126.73,102.33 126.66,102.27 U35.BA26
  BOTTOM w0.127: JDIM1.242 144.97,44.1 144.83,44.24 144.83,45.93 145.39,46.49 145.48,46.49 145.69,46.29 v1(145.69,45.92)
M_A_DQS8: length 4.5
  TOP w0.127: v1(105.99,48.66) 105.99,48.58 v1(105.54,48.13) 105.44,48.03 R10891.2
  BOTTOM w0.127: JDIM1.97 106.72,49.39 v1(105.99,48.66)
M_A_DQS#0: length 84.9
  IN1 w0.127: v1(84.24,48.34) 83.95,48.05 83.95,47.71 84.1,47.56 84.41,47.56 84.54,47.69 84.54,47.89 84.7,48.06 84.7,50.94 83.63,52.01 82.72,52.01 81.74,52.99 81.74,57.68 81.53,57.9 80.69,57.9 80.1,58.49 80.1,71.68 81.04,72.62 81.04,78.42 82.33,79.71 82.33,99.05 91.11,107.83 92.66,107.83 92.66,107.83 93.62,107.83 93.63,107.82 93.86,107.82 94.16,108.12 94.16,108.3 v1(94.08,108.39)
  BOTTOM w0.079: U35.AM70 100.97,107.44 100.78,107.44 100.56,107.54 100.46,107.54 100.3,107.47 99.73,107.47 99.66,107.54 97.79,107.54 97.78,107.53 94.93,107.53 v1(94.08,108.39)
  BOTTOM w0.127: v1(84.24,48.34) 84.24,47.99 84.3,47.94 84.79,47.94 85.37,48.51 85.37,50.24 85.22,50.38 JDIM1.11
M_A_DQS#1: length 75.8
  IN1 w0.079: 92.99,103.68 97.09,103.68 98.09,104.68 98.09,104.89 v1(98.06,104.93)
  IN1 w0.127: v1(90.1,45.31) 90.1,45.45 89.24,46.31 89.24,54.01 87.79,55.46 87.79,70.27 87.2,70.86 87.2,84.08 86.84,84.44 86.84,97.53 92.99,103.68
  BOTTOM w0.079: U35.AT69 101.43,104.51 100.79,104.51 100.66,104.47 100.66,104.47 100.63,104.46 100.38,104.46 100.25,104.51 99.88,104.51 99.72,104.35 98.39,104.35 98.24,104.5 98.24,104.75 v1(98.06,104.93)
  BOTTOM w0.127: JDIM1.32 90.47,44.18 90.65,44.36 90.65,45.49 90.39,45.74 90.25,45.74 90.1,45.59 v1(90.1,45.31)
M_A_DQS#2: length 72.6
  IN1 w0.127: v1(94.87,47.9) 94.87,47.93 95,48.06 95.53,48.06 95.65,47.93 95.65,47.77 95.22,47.34 94.76,47.34 94.32,47.78 94.32,48.76 94.88,49.33 94.88,49.34 94.88,49.35 94.88,49.35 94.88,50.13 94.99,50.24 95.19,50.24 95.48,50.53 95.48,51.04 95.26,51.27 94.77,51.27 94.64,51.39 94.64,51.88 94.77,52.01 95.27,52.01 95.53,52.27 95.53,53 95.27,53.26 94.99,53.26 94.87,53.38 94.87,54.11 94.88,54.12 94.88,54.92 94.6,55.2 94.31,55.2 94.19,55.32 94.19,55.64 94.28,55.73 94.55,55.73 94.87,56.05 94.87,57.39 94.88,57.41 94.88,58.7 94.66,58.92 94.23,58.92 94.1,59.05 94.1,59.38 94.23,59.5 94.55,59.5 94.87,59.82 94.87,62.44 94.88,62.45 94.88,62.95 94.56,63.27 94.26,63.27 94.13,63.4 94.13,63.85 94.26,63.98 94.65,63.98 94.87,64.2 94.87,64.54 94.88,64.56 94.88,65.3 94.88,65.31 94.88,69.6 94.88,69.6 94.88,86.4 94.88,86.4 94.88,88.49 94.88,88.5 94.88,89.13 98.97,93.23 98.97,95.36 99.09,95.48 99.29,95.48 v1(99.37,95.4)
  BOTTOM w0.079: U35.BA64 104.6,102.25 104.53,102.33 104.42,102.33 104.42,102.32 104.37,102.24 104.33,102.14 104.33,101.98 104.4,101.82 104.4,101.66 104.32,101.46 104.32,101.36 104.4,101.16 104.4,100.84 102.65,99.09 102.14,99.09 101.83,98.78 100.5,98.78 100.21,98.49 100.21,96.29 100.2,96.28 100.2,96.24 99.42,95.47 ; 99.37,95.42 v1(99.37,95.4)
  BOTTOM w0.127: v1(94.87,47.9) 95.18,47.9 95.43,48.15 95.43,48.51 95.87,48.94 95.87,50.24 95.72,50.38 JDIM1.53 ; 99.37,95.42 99.42,95.47
M_A_DQS#3: length 65.7
  IN1 w0.127: v1(104.65,96.63) 104.54,96.74 103.97,96.74 103.89,96.65 103.89,95.31 102.79,94.21 102.79,90.2 101.12,88.53 101.12,54.54 101.4,54.25 101.4,50.48 101.25,50.33 101.25,48.6 101.97,47.87 101.97,46.59 101.11,45.73 v1(101.11,45.64)
  BOTTOM w0.079: U35.AY60 107.06,102.56 107.14,102.48 107.21,102.48 107.3,102.39 107.41,102.17 107.41,101.97 107.35,101.84 107.35,101.64 107.42,101.5 107.42,101.32 107.35,101.18 107.35,100.91 107.49,100.76 107.49,100.28 107.03,99.82 107.03,99.57 105.39,97.93 105.39,97.19 105.08,96.88 104.9,96.88 v1(104.65,96.63)
  BOTTOM w0.127: v1(101.11,45.64) 101.11,46.03 101.36,46.29 101.45,46.29 101.58,46.16 101.58,45.41 101.13,44.96 101.13,44.37 100.97,44.21 JDIM1.74
M_A_DQS#4: length 67.3
  IN1 w0.089: v2(119.37,96.52) 119.64,96.26 119.84,96.26 120.17,95.93 120.17,91.4 120.4,91.17 120.46,91.17
  IN1 w0.127: 120.46,91.17 125.92,85.71 125.92,83.97 130.7,79.19 130.7,74.98 130.34,74.62 130.34,71.12 130.47,70.99 130.73,70.99 130.99,70.74 130.99,70.16 130.71,69.88 130.47,69.88 130.34,69.75 130.34,68.78 130.7,68.42 130.7,64.47 132.24,62.94 132.24,60.65 131.68,60.09 131.68,55.57 131.11,55.01 131.11,52.21 130.59,51.69 130.59,48.65 130.37,48.42 129.96,48.42 v1(129.72,48.19)
  BOTTOM w0.079: U35.BA38 119.33,102.06 119.33,102.27 119.27,102.33 119.18,102.33 119.14,102.31 119.09,102.23 119.06,102.16 119.06,101.96 119.12,101.83 119.12,101.64 119.04,101.45 119.04,101.37 119.12,101.17 119.12,100.84 118.92,100.64 118.92,100.31 119.14,100.09 119.14,98.93 118.96,98.74 118.96,96.41 119.07,96.3 119.15,96.3 v2(119.37,96.52)
  BOTTOM w0.127: v1(129.72,48.19) 129.72,48.52 129.55,48.7 129.1,48.7 128.81,48.99 128.81,50.39 128.72,50.47 JDIM1.177
M_A_DQS#5: length 70.4
  IN1 w0.079: v2(122.93,94.67) 122.32,94.06 122.32,92.51 122.76,92.07 123.61,92.07 127.26,88.42 127.26,88.4 127.32,88.35 127.32,88.3 127.32,88.3
  IN1 w0.127: v1(134.56,47.05) 134.56,46.71 134.65,46.62 134.82,46.62 135.04,46.85 135.04,50.48 135.93,51.37 135.93,51.87 136.95,52.88 136.95,63.28 135.6,64.62 135.6,69.31 136.29,70 136.29,79.33 127.32,88.29 127.32,88.3
  BOTTOM w0.079: U35.AY34 121.78,102.52 121.8,102.5 121.86,102.5 121.98,102.45 121.98,102.45 122.07,102.3 122.14,102.13 122.14,101.98 122.06,101.8 122.06,101.66 122.13,101.5 122.13,101.33 122.07,101.19 122.07,100.17 122.26,99.99 122.26,94.76 122.61,94.4 122.66,94.4 v2(122.93,94.67)
  BOTTOM w0.127: JDIM1.198 133.97,44.61 133.89,44.69 133.89,46.35 134.22,46.68 134.32,46.68 134.56,46.92 v1(134.56,47.05)
M_A_DQS#6: length 72.2
  IN1 w0.079: 127.94,91 127.93,91.01 127.9,91.01 125.76,93.14 125.76,95.59 v1(124.81,96.54)
  IN1 w0.127: 127.94,91 128.57,90.37 131.73,90.37 141.58,80.52 141.58,72.74 141.9,72.42 141.9,67.53 142.24,67.19 142.24,64.54 143.93,62.84 143.93,56.59 142.11,54.76 142.11,52.16 140.85,50.89 140.85,48.91 140.12,48.18 139.91,48.18 v1(139.63,47.9)
  BOTTOM w0.079: v1(124.81,96.54) 124.55,96.28 124.45,96.28 124.4,96.34 124.4,99.73 124.03,100.09 124.03,100.46 124.1,100.53 124.1,101.16 124.03,101.36 124.03,101.48 124.06,101.56 124.1,101.65 124.1,101.83 124.03,101.99 124.03,102.13 124.05,102.18 124.05,102.2 124.09,102.28 124.11,102.31 124.12,102.32 124.17,102.34 124.25,102.34 124.31,102.27 124.31,102.06 U35.BA30
  BOTTOM w0.127: JDIM1.219 139.22,50.43 139.39,50.27 139.39,49.97 138.5,49.08 138.5,48.69 138.94,48.24 139.42,48.24 139.63,48.04 v1(139.63,47.9)
M_A_DQS#7: length 76.5
  IN1 w0.127: v1(128.37,94.62) 128.55,94.44 134.91,94.44 147.38,81.97 147.38,64.95 148.98,63.35 148.98,56 147.34,54.36 147.34,51.72 145.19,49.58 145.19,46.86 145.38,46.67 145.56,46.67 145.69,46.79 v1(145.69,47.19)
  BOTTOM w0.079: U35.AY26 126.76,102.66 126.95,102.48 127.05,102.31 127.06,102.29 127.1,102.14 127.09,101.96 arc(127.09,101.96) 127.09,101.95 127.07,101.85 127.05,101.78 127.03,101.72 127.07,101.62 127.09,101.48 arc(127.09,101.47) 127.1,101.45 127.09,101.35 127.09,101.34 arc(127.09,101.33) 127.09,101.32 127.06,101.16 arc(127.06,101.15) 127.06,101.13 127.06,101.09 127.06,100.98 arc(127.07,100.93) 127.1,100.89 127.22,100.77 127.22,100.77 127.24,100.75 arc(127.27,100.71) 127.28,100.66 127.28,99.21 127.6,98.89 127.6,94.87 128.08,94.4 128.14,94.4 128.24,94.5 128.25,94.5 v1(128.37,94.62)
  BOTTOM w0.127: v1(145.69,47.19) 145.69,46.92 145.5,46.73 145.29,46.73 144.59,46.03 144.59,44.2 144.47,44.09 JDIM1.240
M_A_DQS#8: length 3.3
  TOP w0.127: v1(106.05,50.05) 106.05,50.49 v1(105.59,50.95) 105.47,51.07 R10894.2
  BOTTOM w0.127: v1(106.05,50.05) 106.22,50.22 JDIM1.95
M_A_EVENT#: length 6.6
  TOP w0.127: R10885.2 R10890.1 117.16,44.09 117.16,45.56 v1(116.61,46.1)
  BOTTOM w0.127: JDIM1.134 115.97,45.47 v1(116.61,46.1)
M_A_ODT0_DIMM: length 70.3
  IN1 w0.079: 118.39,92.59 118.39,98.8 118.79,99.21 118.79,100.06 118.18,100.67 118.18,101.15 116.23,103.1 116.23,104.72 v2(115.78,105.18)
  IN1 w0.216: 118.39,92.59 118.39,90.08 122.8,85.67 122.8,82.64 126.87,78.57 126.87,68.28 126.45,67.87 126.45,67.03 126.6,66.87 126.83,66.87 126.98,66.72 126.98,66.51 126.83,66.35 126.6,66.35 126.45,66.2 126.45,63.96 127.84,62.57 127.9,62.57 128.05,62.42 128.05,62.2 127.9,62.05 127.84,62.05 127.69,61.9 127.69,61.68 127.84,61.53 127.9,61.53 128.05,61.38 128.05,61.16 127.9,61.01 127.84,61.01 127.69,60.86 127.69,55.8 127.06,55.17 127.06,52.78 125.03,50.76 125.03,49 125.43,48.61 v1(125.62,48.61)
  BOTTOM w0.191: v1(125.62,48.61) 124.09,48.61 123.22,49.47 JDIM1.155
  BOTTOM w0.203: U35.AT45 v2(115.78,105.18)
M_A_ODT1_DIMM: length 71.3
  IN1 w0.079: 118.75,92.58 118.75,92.79 118.58,92.96 118.58,98.71 118.96,99.09 118.96,100.16 118.35,100.77 118.35,101.32 117.23,102.45 117.23,104 v2(116.7,104.53)
  IN1 w0.216: 118.75,92.58 118.75,90.25 123.31,85.7 123.31,82.86 127.36,78.8 127.36,67.89 127.5,67.75 127.5,65.08 127.35,64.92 127.04,64.92 126.92,64.8 126.92,64.53 127.04,64.4 127.35,64.4 127.5,64.25 127.5,64.02 128.57,62.96 128.57,60.75 128.41,60.6 128.32,60.6 128.17,60.44 128.17,60.23 128.32,60.08 128.57,60.08 128.7,59.95 128.7,59.68 128.57,59.56 128.32,59.56 128.17,59.4 128.17,59.19 128.32,59.03 128.59,59.03 128.71,58.91 128.71,58.64 128.59,58.51 128.32,58.51 128.17,58.36 128.17,58.15 128.32,57.99 128.58,57.99 128.71,57.87 128.71,57.6 128.58,57.47 128.32,57.47 128.17,57.32 128.17,57.1 128.32,56.95 128.64,56.95 128.79,56.8 128.79,56.49 128.66,56.35 128.35,56.35 128.24,56.24 128.24,55.68 128.1,55.54 128.1,55.28 127.9,55.08 127.69,55.08 127.54,54.93 127.54,54.64 127.69,54.5 128.13,54.5 128.29,54.34 128.29,54.13 128.13,53.97 127.72,53.97 127.56,53.82 127.56,53.61 127.72,53.45 128.13,53.45 128.29,53.3 128.29,53.09 128.13,52.93 127.8,52.93 127.41,52.54 127.41,52.32 127.54,52.19 127.54,51.98 127.38,51.83 127.17,51.83 127.04,51.96 126.82,51.96 126.67,51.8 126.67,51.59 126.8,51.46 126.8,51.24 126.65,51.09 126.43,51.09 126.3,51.22 126.09,51.22 125.62,50.75 v1(125.62,49.93)
  BOTTOM w0.191: v1(125.62,49.93) 125.15,49.93 124.72,50.36 JDIM1.161
  BOTTOM w0.203: U35.AT43 v2(116.7,104.53)
