# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V_S5: length 89.1
  TOP w0.381: PC235.2 PR86.1 62.4,70.31 62.4,69.6 63.41,68.58 68.06,68.58 69.1,69.62 69.1,77.32 66.49,79.93 66.49,89.81 64.47,91.83 63.59,91.83
  IN1 w0.508: 137.72,128.32 137.72,129.48 135.82,131.39 130.74,131.39 129.9,130.55 122.23,130.55 120.1,128.42 v1(118.09,128.42)
  BOTTOM w0.203: v1(133.28,124.23) 133.28,124.25 133.01,123.98 U35.A14
  BOTTOM w0.254: U35.A10 135.49,124.38 136.58,125.47 137.7,125.47 138.52,126.3 141.78,126.3 v1(143.16,127.68)
  BOTTOM w0.305: U35.N15 132.36,116.92 v2(132.36,117.02) ; v2(132.36,116.18) U35.P15 ; U35.N16 131.71,116.92 v2(131.71,117.02) 131.53,116.84 131.53,116.74 U35.N17 ; v2(129.76,113.67) 129.76,113.76 U35.V20 U35.V21 ; U35.N18 130.41,116.92 v2(130.41,116.99) 130.41,117.11 U35.L19 U35.K19 ; v2(128.24,109) 128.6,108.64 129.02,108.64 U35.AK20 ; v2(131.11,117.86) 131.11,118 U35.K17 ; U35.L15 132.4,117.73 v2(132.4,117.86) 132.4,117.99 U35.K15 ; U35.L21 128.79,117.34 v2(129.11,117.02) 129.11,116.92 U35.N20 ; v2(129.76,111.99) 130.97,111.99 U35.AB17 ; v2(129.76,111.99) U35.AB20 ; v2(129.76,111.99) 130.09,112.31 U35.AB19 130.27,112.59 130.27,112.78 U35.Y18 ; v2(130.42,114.51) 130.42,114.59 U35.T19 129.92,115.09 129.61,115.09 U35.T20 ; v2(131.71,116.18) U35.P16 ; U35.AF18 v2(130.41,110.31) 130.09,110.64 U35.AF19 ; U35.AF20 v2(129.11,111.15) U35.AF21 ; U35.P18 130.41,116.09 v2(130.41,116.18) ; v2(132.39,114.5) 132.39,114.37 132.67,114.09 U35.V15
  BOTTOM w0.381: C698.2 143.3,127.54 v1(143.16,127.68)
  BOTTOM w0.508: R512.2 118.27,128.24 v1(118.09,128.42)
  vias: v1(62.11,90.43) v1(74.96,98.83) v1(142.12,120.31) v1(142.8,120.31) v1(143.54,121.89) v1(144.2,121.89) v1(144.41,116.18) v1(145.07,116.16) v3(60.41,91.59) v3(61.7,91.57) v3(63.02,91.9) v3(74.1,97.3) v3(74.1,96.54) v3(74.1,95.78) v3(74.86,97.3) v3(74.86,96.54) v3(74.86,95.78) v3(75.62,97.3) v3(75.62,96.54) v3(75.62,95.78)
+1V_S5_ON: length 231.6
  TOP w0.127: PR83.2 65.82,70.19 v1(65.46,69.83)
  IN1 w0.14: v1(42.12,33.67) 42.12,34.35 41.66,34.82 41.66,42.87 40.65,43.87 40.65,53.38 39.98,54.06 39.98,59.42 39.98,59.71 41.94,61.67 42.65,62.37 44.49,62.37 45.11,61.75 48.85,61.75 53.95,66.84 53.95,68.85 55.73,70.63 59.76,70.63 60.23,70.16 65.13,70.16 v1(65.46,69.83) ; v1(40.27,32.68) 39.83,32.25 39.83,28.95 38.26,27.38 38.26,20.62 39.81,19.07 41.03,19.07 43.11,21.15 45.65,21.15 48.51,18.29 64.67,18.29 65.56,17.4 67.27,17.4 71.76,21.89 80.52,21.89 88.3,29.66 105,29.66 107.59,27.07 114.46,27.07 114.82,27.43 122.32,27.43 124.88,24.86 146.96,24.86 155.08,32.99 164.12,32.99 164.62,33.5 167.46,33.5 167.76,33.8 169.45,33.8 169.94,34.29 169.96,34.29 172.55,36.88 172.55,37.15 174.4,39 v1(174.4,39.19)
  IN2 w0.14: v1(40.27,32.68) 41.13,32.68 v1(42.12,33.67)
  BOTTOM w0.127: U45.95 172.36,41 172.5,40.86 172.5,40.44 172.95,39.99 173.63,39.99 174.4,39.21 v1(174.4,39.19)
+1V_SUS: length 99.7
  TOP w0.508: 77.25,99.77 71.08,99.77 70.41,99.11 67.44,99.11 66.48,100.07 v1(66.48,101.06) v1(66.48,101.75) ; v1(133.94,129.89) 134.1,129.89 134.64,129.35 R550.1
  IN1 w0.508: v1(133.94,129.89) 133.94,129.56 133.37,128.99 122.68,128.99 120.33,126.64 120.33,124.1 119.34,123.11 108.26,123.11 107.04,124.33 107.04,124.61 105.45,126.2 99.71,126.2 98.44,124.94 91.19,124.94 89.34,123.08 87.31,123.08 86.49,122.27 85.68,122.27 83.14,119.73 81.39,119.73 67.42,105.76 67.42,102.69 v1(66.48,101.75)
  vias: v1(77.43,104.31) v1(78.16,100.93) v3(78.24,99.84) v3(78.75,100.45)
+1V_VCCST: length 192.1
  TOP w0.254: v1(128.91,177.26) 128.91,177.44 129.33,177.85 v1(129.77,177.85) PR340.1 ; C819.2 99.62,132.51 v1(99.24,132.89) ; v1(133,129.84) 133.44,129.4 R550.2 133.44,128.74 133.81,128.37 135.34,128.37 135.9,127.81 140.93,127.81 142.73,129.61 150.25,129.61 155.58,134.94 v1(155.58,139.59) ; v1(104.32,132.86) 104.08,132.62 C818.2 ; C814.2 101.52,132.62 v1(101.28,132.86) 101.03,132.62 C817.2 ; PR341.1 131.17,174.74 PC6228.1 131.06,173.71 v1(130.54,173.71) ; v1(99.83,137.28) 99.83,137.87 C628.1
  IN1 w0.254: v1(130.54,173.71) 131.5,174.67 131.5,175.53 132.95,176.98 134.07,176.98 134.85,176.19 134.85,173.1 135.59,172.36 135.59,171.22 134.75,170.38 134.75,167.3 131.73,164.28 131.73,162.99 133.18,161.54 133.18,149.8 132.04,148.66 132.04,143.28 135.29,140.02 152.48,140.02 153.22,139.29 155.28,139.29 v1(155.58,139.59) ; v1(133,129.84) 122.64,129.84 119.31,126.51 119.31,124.38 118.67,123.74 109.76,123.74 106.78,126.72 99.49,126.72 99.41,126.64 95.18,126.64 94.37,127.45 v1(93.45,127.45) 92.56,127.45 89.08,123.97 84.26,123.97 82.48,122.19 82.48,121.25 v1(82.53,121.2)
  IN2 w0.254: v1(130.54,173.71) 130.82,173.98 130.82,175.36 v1(128.91,177.26)
  BOTTOM w0.203: 130.92,125.75 130.53,125.36 U35.A18
  BOTTOM w0.254: R788.1 R513.2 ; R513.2 v1(101.28,132.86) 101.58,133.17 C816.2 ; R513.2 R559.1 102.54,132.48 103.06,132.48 103.31,132.24 R514.1 R515.1 104.48,132.71 v1(104.32,132.86) ; v1(93.91,129.43) 94.16,129.19 R138.1 R761.2 93.66,127.65 v1(93.45,127.45) ; R85.2 84.98,121 82.73,121 v1(82.53,121.2) ; v1(99.83,137.28) 100.21,137.28 100.47,137.55 U33.5 ; R529.1 v1(99.24,132.89) 99.14,132.99 C815.2 ; Q31.3 98.15,134.49 v1(98.53,134.87) 98.6,134.8 R488.2 ; R134.1 v1(95.81,132.23)
+2.5V: length 10.7
  TOP w0.254: v1(155.56,55.42) 155.56,56.14 R11170.2 155.97,56.56 v1(155.97,57.25) 155.97,59.23 155.99,59.25 155.99,59.67 155.97,59.68 R11142.2
  BOTTOM w0.254: PQ6065.1 159.85,52.83 158.63,54.05 157.84,54.05 156.88,55.01 PR6298.1 155.96,55.01 v1(155.56,55.42)
+2.5V_SUS: length 10
  TOP w0.508: v1(170.11,46.88) 169.84,46.62 169.78,46.62 169.69,46.53 v1(169.09,46.53) 163.56,46.53 v1(161.25,44.22)
  vias: v1(148.75,61.95) v1(149.92,62.17) v1(149.92,61.51) v1(149.97,50.39) v1(149.97,49.73)
+3V: length 736.8
  TOP w0.203: v1(22.68,64.92) U13.26 ; v1(26.64,73.43) 29.99,76.78 35.01,76.78 35.26,76.52 35.52,76.52 35.7,76.34 U15.12 ; v1(22.54,71.9) 23.08,71.36 U13.14
  TOP w0.254: R9.2 117.29,175.14 117.56,175.41 Q2.2 ; Q2.5 121.27,175.41 121.65,175.79 122.1,175.79 R12.2 ; R576.2 157.53,118.37 157.28,118.13 Q32.2 ; R110.2 155.29,104.11 154.8,104.59 153.98,104.59 153.51,104.12 R204.2 ; Q32.5 153.6,118.13 153.4,118.33 153.4,119.58 v1(153.45,119.63) ; v1(177.45,108.02) 176.14,106.71 172.21,106.71 171.98,106.94 170.58,106.94 v1(169.68,107.84)
  TOP w0.381: R234.2 R228.2 150.6,90.7 v1(150.27,90.37) ; R110.2 156.98,104.08 157.41,104.52 157.41,104.87 v1(157.92,105.38) ; v1(40.52,42.67) 40.39,42.8 PR137.1 40.88,44.02 42.09,45.23 PR53.2 ; v1(158.58,105.33) 159,105.75 R115.2 ; R9.2 116.39,175.14 v1(116.13,175.4) ; R245.2 178.5,180.29 v1(178.34,180.45) ; R277.1 32.19,63.6 v1(32.65,63.14) ; PR107.2 41.18,51.87 41.18,51.31 41.16,51.28 v1(41.16,51.19) ; v1(52.28,21.99) 52.28,21.64 52.78,21.14 R426.2 ; R216.2 R209.2 ; v1(122.1,176.55) R12.2 ; R11263.1 38.03,59.46 35.67,57.09 33.13,57.09 32.77,57.45 v3(32.44,57.45) ; v1(62.81,68.29) 61.56,69.54 61.56,73.67 58.43,76.8 58.43,79.06 57.33,80.16 PR293.2 ; v1(161.58,101.77) 161.58,102.18 160.62,103.14 R207.1 R208.2
  TOP w0.508: v1(151.14,125.95) 148.9,123.72 147.86,123.72 v1(147.18,123.03) 147.18,122.98 146.8,122.6 146.39,122.6 145.52,121.74 145.52,120.37 v1(145.73,120.16) ; R11289.2 109,35.58 108.57,35.15 108.57,31.26 111.1,28.72 117.58,28.72 120.05,31.19 138.97,31.19 139.5,31.72 150.45,31.72 ; 212.83,61.69 210.55,61.69 210.04,62.2 210.04,62.83 211.87,64.66 211.87,66.26 213.29,67.69 213.29,82.24 211.61,83.92 211.61,105.05 213.16,106.6 214.66,106.6 v1(214.81,106.44) 215.02,106.24 v1(215.02,105.18) ; v1(26.64,73.43) 26.35,73.14 R11187.2 ; 150.45,31.72 151.09,31.08 151.09,26.11 v1(150.81,25.83) ; 150.45,31.72 151.09,32.35 v1(151.09,43.28) ; R58.2 109.4,156.36 109.28,156.48 v1(109.28,156.99) ; R10889.1 129.49,46.75 v1(129.52,46.78) ; R11134.2 155.77,63.84 155.4,64.21 v1(155.15,64.21) ; R781.2 153.3,119.78 v1(153.45,119.63) ; R11133.2 150.25,53.41 v1(151.59,54.76) 150.26,56.09 R10940.1 149.03,56.48 148.77,56.74 R10924.1 ; v1(22.68,64.92) 22.54,64.77 C4752.2 ; v1(127.16,59.68) 126.78,59.68 126.5,59.96 126.5,61.94 R10923.1 ; v1(24.01,52.83) 24.24,52.6 26.55,52.6 26.98,53.03 R722.1 ; v1(23.55,73.94) R11285.2 R11286.2 ; v1(212.91,184.7) 211.03,184.7 207.66,181.34 207.66,179.48 204.18,176 204.18,174.87 202.46,173.15 PR318.2 ; v1(163.96,63.77) 163.91,63.82 159.04,63.82 v1(156.85,66.01) ; v1(142.68,97.05) 140.14,94.51 v1(140.14,94.13) ; v1(201.05,42.31) 201.18,42.18 202.74,42.18 203.28,41.63 203.28,41.63 203.85,41.06 211.15,41.06 213.65,38.56 213.65,36.39 212.56,35.3 211.56,35.3 v1(210.3,36.55) 210.3,36.89 209.35,37.84 208.12,37.84 R365.1 ; v1(32.95,58.57) 32.95,59.74 33.43,60.22 Q25.2 35.09,60.22 35.34,60.46 R281.1 ; R209.2 230.55,106.18 v1(231.07,105.66) ; v1(168.81,50.83) 168.47,50.83 167.47,49.83 158.92,49.83 158.12,50.63 v1(157.13,50.63)
  TOP w0.635: v1(68.26,119.91) 66.15,117.8 66.15,116.21 v1(65.13,115.19)
  TOP w1.016: 135.37,181.97 135.37,182.51 137.47,184.6 138,184.6 139.33,185.92 139.33,187.04 140.72,188.44 145.88,188.44
  IN1 w0.254: v1(169.68,107.84) 169.46,108.06 169.41,108.06 168.45,109.02 168.42,109.02 164.09,113.35 159.72,113.35
  IN1 w0.381: v1(150.27,90.37) 150.51,90.37 150.99,89.89 150.99,85.05 v1(151.54,84.5)
  IN1 w0.508: v1(156.47,141.02) 156.47,138.45 152.79,134.77 152.79,125.78 152.63,125.62 ; v1(70.44,69.84) 68.88,68.29 v1(62.81,68.29) ; v1(121.82,168.4) 125.02,168.4 v1(125.56,168.93) ; v1(40.52,42.67) 40.8,42.39 40.8,34.41 41,34.21 41,33.32 41.69,32.63 41.69,30.55 41.05,29.92 41.05,27.07 42.78,25.34 44.02,25.34 45.78,23.59 46.84,23.59 48.04,22.4 51.23,22.4 51.63,21.99 v1(52.28,21.99) ; v1(203.59,189.86) 208.51,189.86 210.22,188.15 210.22,186.05 211.56,184.7 v1(212.91,184.7) 212.91,185.35 214.49,186.93 219.24,186.93 220.6,185.56 220.6,178.98 219.28,177.66 217.14,177.66 v1(216.14,176.66) ; v1(151.59,54.76) 152.36,54.76
  IN1 w1.016: v1(231.07,105.66) 231.07,105.15 229.83,103.91 229.83,99.66 232.67,96.82 232.67,90.12 231.07,88.52 231.07,87.65 227.69,84.27 225.13,84.27 221.39,80.54 221.39,66.04 ; 151.52,188.54 153.96,186.1 166.27,186.1 166.96,185.41 176.94,185.41 177.7,184.65 177.7,182.98 178.47,182.21 ; 185.86,58.08 185.83,58.11 183.37,58.11 182.16,59.32 181.12,59.32 179.83,60.61 179.83,61.74 178.82,62.74 178.82,64.28 178.82,65.91 173.54,71.19 173.54,74.07 174.12,74.65 174.12,86.05 175.37,87.29
  IN2 w0.508: v1(70.44,69.84) 71.72,69.84 74.04,67.52 74.04,59.68 74.86,58.86 74.86,55.72 v1(75.32,55.26) ; 128.28,46.76 128.28,53.74 126.24,55.77 126.24,58.8 127.13,59.68 v1(127.16,59.68) ; 128.28,46.76 128.3,46.78 v1(129.52,46.78) ; 128.28,46.76 128.28,43.66 128.99,42.95 134.3,42.95 135.29,41.96 135.29,40.96 v1(136.18,40.08) ; 129.37,179.72 130.64,178.45 132.34,178.45 132.64,178.15 132.64,176.23 132.77,176.11 132.77,174.52 134.91,172.38 v1(134.91,172.13)
  BOTTOM w0.127: v1(169.68,107.84) 169.68,108.63 171.33,110.28 R11283.2
  BOTTOM w0.254: v1(178.34,180.45) 178.34,179.78 178.62,179.5 Q23.5 ; R4201.2 176.83,108.99 177.45,108.38 v1(177.45,108.02) ; v1(94.09,134.31) 94.09,133.93 94.42,133.6 95.99,133.6 96.58,133.02 96.58,132.99 97.08,132.48 98.28,132.48 98.76,132 98.76,130.04 99.24,129.56 R533.1 ; C4025.2 219.63,106.04 U4002.5 ; U4001.5 213.96,106.55 C4024.2 ; C332.2 164.71,85.48 U14.5
  BOTTOM w0.305: PR197.1 PR196.1
  BOTTOM w0.381: R449.1 v1(125.56,168.93) ; R639.1 139.5,94.76 v1(140.14,94.13) 140.14,91.18 143.62,87.7 146.03,87.7 149.82,83.92 151.45,83.92 v1(151.54,83.82) ; C332.2 164.77,85 164.12,84.35 161.4,84.35 160.81,84.93 160.81,85.77 160.43,86.15 158.75,86.15 v1(157.24,84.64) ; v1(216.14,176.66) 216.24,176.76 PR296.2 ; v1(214.81,106.44) C4024.2 ; v1(147.18,123.03) 146.85,122.7 R561.1 ; v1(121.82,168.4) 122.18,168.4 122.37,168.59 R448.1 ; v1(142.68,97.05) 142.94,97.31 R630.1 ; R575.2 R574.2 R573.2 v1(145.73,120.16) ; PR196.1 133.93,172.1 134.8,172.1 134.83,172.13 v1(134.91,172.13) ; Q20.2 153.63,114.52 v1(153.55,114.45) ; v1(98.63,139.54) 98.63,139.52 98.41,139.29 R485.1
  BOTTOM w0.508: R378.1 v1(210.3,36.55) ; PR295.2 69.03,71.24 v1(70.44,69.84) ; v1(156.47,141.02) 156.42,141.02 157.48,142.07 R4205.2 ; v1(150.81,25.83) 153.95,25.83 R374.2 ; v1(218.04,63.87) 217.62,63.45 R318.1 ; v1(144.38,38.58) 145.35,39.55 R10872.1 ; R10880.1 147.39,39.55 v1(148.14,38.81) ; R609.1 68.09,120.08 v1(68.26,119.91) ; R444.2 120.72,168.16 v1(120.38,168.5) ; v1(191.67,59.89) 191.67,60.04 190.29,61.42 PR259.2 ; 65.61,114.56 v1(67.14,113.04) ; v1(163.96,63.77) 163.84,63.77 PR73.2 ; v1(215.02,105.18) 215.32,105.18 215.55,105.4 219.51,105.4 219.64,105.54 C4025.2 ; v1(168.81,50.83) 168.86,50.83 PR314.2 ; R631.2 R629.1 153.22,89.02 154.06,88.18 v1(154.72,88.18) ; v1(153.68,102.1) 153.32,101.75 R619.1 R618.2 R625.1
  BOTTOM w1.016: 153.04,187.01 153.98,186.07 167.09,186.07 167.77,185.39 176.61,185.39 177.32,184.68 177.32,183.1 178.59,181.84 178.83,181.84 178.96,181.71 179.1,181.71 179.82,180.99 181.89,180.99
  vias: v1(16.57,44.39) v1(17,54.6) v1(17.23,44.39) v1(17.66,54.63) v1(19.34,54.55) v1(20.99,44.39) v1(21.6,54.6) v1(21.77,44.44) v1(23.6,56.13) v1(23.58,55.44) v1(55.99,52.24) v1(109.99,164.18) v1(125.18,182.67) v1(125.66,182.19) v1(126.14,181.66) v1(126.65,181.02) v1(146.82,188.44) v1(147.48,188.44) v1(148.16,188.44) v1(148.88,188.41) v1(151.52,79.34) v1(151.52,78.63) v1(154.62,96.06) v1(154.74,93.52) v1(154.74,92.09) v1(157.82,117.65) v1(158.55,108.17) v1(159.06,107.74) v1(160,101.11) v1(174.45,101.11) v1(174.48,100.43) v1(178.59,87.65) v1(178.75,87.01) v1(181.64,179.88) v1(182.33,179.85) v1(182.99,179.85) v1(183.65,179.85) v1(188.45,57.96) v1(188.93,57.47) v1(190.84,43) v1(190.81,42.34) v1(200.39,42.79) v1(202.93,190.49) v1(203.61,190.52) v1(220.02,64.49) v1(220.02,63.84) v3(26.45,61.49) v3(26.45,60.73) v3(31.81,57.04) v3(31.83,56.2) v3(32.47,56.69) v3(51.39,53.11) v3(51.39,52.27) v3(51.42,51.33) v3(52.13,51.71) v3(52.15,52.78) v3(55.45,53.11) v3(56.22,53.11) v3(56.93,52.75) v3(113.52,169.03) v3(114.08,169.59) v3(133.25,181.58) v3(134.02,181.78)
+3V3_SATA_N1:
  vias: v1(175.93,94.63)
+3V3_SD_SW: length 66
  TOP w0.508: C4618.2 35.83,24.65 C4617.1 ; C4617.1 v1(34.03,24.65) ; C4617.1 34.73,23.87 34.87,23.73 CN4.4
  BOTTOM w0.508: v1(33.84,75.08) 33.33,75.58 31.32,75.58 29.01,73.27 29.01,73.1 v1(28.12,72.21) 27.62,71.7 27.62,65.85 27.87,65.6 27.87,60.75 26.75,59.63 26.75,53.31 25.56,52.12 25.56,42.84 27.11,41.3 27.11,35.99 28.5,34.59 28.5,26.63 29.28,25.85 32.83,25.85 v1(34.03,24.65)
+3V3_TPM: length 19.9
  TOP w0.508: v1(170.29,74.14) v1(170.29,73.12) v1(170.29,71.98) 170.29,71.06 167.82,68.6 v1(163.96,68.6)
  BOTTOM w0.203: U44.14 162.2,72.96 v1(162.06,73.1) 162.03,73.12 C774.1
  BOTTOM w0.254: 171.02,74.61 171.01,74.61 169.93,75.69 166.96,75.69 166.62,75.34 U44.22
  BOTTOM w0.381: v1(170.29,74.14) 170.54,74.14 171.02,74.61 C768.1 ; v1(170.29,73.12) 170.36,73.12 170.6,72.88 R744.1
  vias: v1(163.96,67.95)
+3V3_TPM_VSB:
  vias: v1(168,68.52)
+3V_DMIC: length 181.3
  TOP w0.254: U17.1 82.07,83.97 81.4,83.3 81.01,83.3 80.62,83.7 80.62,88.92 ; U16.2 U16.1 132.09,83.97 130.23,82.11 130.23,77.64 130.86,77.02 C376.1 C371.1 C373.1 130.86,73.31 131.37,72.79 134.04,72.79 138.11,68.72 151.93,68.72 v1(152.24,68.41) 156.11,68.41 156.29,68.59 157.42,68.59 v1(159.36,66.64) 159.7,66.3 159.7,66.18 160.75,65.13 164.43,65.13 164.9,64.66 169.11,64.66 170.52,66.07 v1(170.52,66.52) ; U4512.2 U4512.1 169.58,83.97 168.96,83.35 v1(168.85,83.35)
  IN1 w0.254: v1(175.55,62.1) 175.55,66.11 171.18,70.48 171.18,71.77 171.18,71.77 171.18,72.05 171.18,72.05 171.18,74.89 169.88,76.19 169.88,81.47 169.74,81.61 169.74,82.13 168.85,83.02 v1(168.85,83.35)
  BOTTOM w0.254: 80.44,89.94 81.66,91.16 88.42,91.16 94.48,85.1 126.36,85.1 136.9,74.56 141.96,74.56 147.77,68.76 151.89,68.76 v1(152.24,68.41) ; v1(175.55,62.1) 175.09,62.1 174.83,62.35 173.06,62.35 170.92,64.49 170.92,65.2 170.52,65.6 v1(170.52,66.52)
  vias: v1(79.73,89.81) v1(79.73,89.08)
+3V_EC:
  vias: v1(188.63,38.2)
+3V_GFX: length 218.1
  TOP w0.254: C4013.1 167.77,112.68 167.77,113.21 168.2,113.64 Q4301.5
  TOP w0.305: v1(187.02,110.49) 187.04,110.49 187,110.53 R4320.2
  TOP w0.381: v1(188.12,108) 188.12,108.5 187.89,108.73 R4210.1 ; R4318.2 v1(183.44,113.18) R4324.1 ; R4302.2 196.27,109.09 v1(196.63,108.73) ; C4028.2 189.54,108.15 189.19,108.5 189.19,108.72 v1(189.2,108.73) 188.91,109.03 R4303.2 ; R4301.2 v1(197.29,108.73) 197.28,108.72 197.28,107.95 C4041.1 ; v1(162.74,28.79) 162.74,35.96 161.55,37.15 v1(161.55,37.61)
  TOP w0.508: v1(179.73,63.11) v1(178.95,63.11) 175.55,63.11 171.08,58.64 v1(169.59,58.64) ; v1(181.72,108.86) 181.72,108.78 180.35,107.42 179.7,107.42 178.47,108.66 176.76,108.66 175.53,107.42 v1(174.71,107.42) R4003.2 172.46,107.42 172.26,107.61 171.41,107.61 170.19,108.83 Q4000.1 168.44,108.83 168.32,108.95 167.24,108.95 167.11,108.82 165.77,108.82 165.64,108.95 R4001.1 164.03,109.76 163.63,110.15 163.63,110.84 164.07,111.28 R4000.1 164.73,111.74 164.73,113.86 164.95,114.09 R4319.2 166.21,113.9 167.27,112.85 C4013.1 ; v1(163.76,53.84) 161.52,53.84 160.85,53.17 156.79,53.17 156.14,52.52 155.3,52.52 152.52,49.74 152.52,48.27 157.66,43.12 157.66,41.5 v1(161.55,37.61)
  IN1 w0.381: v1(162.74,28.79) 162.75,28.79 162.82,28.72 v1(165.49,28.72)
  IN1 w0.508: v1(179.73,63.11) 179.73,63.91 179.73,66.28 174.44,71.57 174.44,73.69 175.02,74.28 175.02,81.62 179.55,86.14 179.55,89.76 178.06,91.26 178.06,99.69 176.96,100.79 176.96,106.73 176.27,107.42 v1(174.71,107.42) ; v1(169.59,58.64) 169.59,55.66 167.73,53.8 163.8,53.8 v1(163.76,53.84)
  IN2 w0.508: 198.3,108.48 199.19,108.48 201.1,106.57 205.16,106.57 209.23,110.64 215.8,110.64 217.28,109.16 218.04,109.16 v1(218.07,109.14) ; 175.44,137.18 175.34,137.28 167.98,137.28 v1(167.82,137.43)
  BOTTOM w0.254: v1(189.97,106.73) 190.18,106.93 Q4300.2 Q4300.5
  BOTTOM w0.381: R4004.2 220.54,108.69 220.2,109.04 218.17,109.04 v1(218.07,109.14) ; R4316.1 R4317.1 185.48,112.41 v1(184.71,111.65) 185.52,110.85 R4341.2 ; R382.2 168.18,29.86 168.16,29.89 R740.2 167.58,29.74 167.16,29.32 166.08,29.32 v1(165.49,28.72) ; R4300.2 193.05,109.32 v1(193.1,109.37) ; R4342.2 182.09,108.49 v1(181.72,108.86) ; R4322.2 v1(183.44,113.18) ; R4321.2 189.4,113.8 v1(189.54,113.94) ; R4344.1 R4303.2 188.91,109.03 v1(189.2,108.73) ; R4323.2 186.99,110.52 v1(187.02,110.49)
  BOTTOM w0.508: v1(167.82,137.43) 167.57,137.69 157.64,137.69 157.13,138.2 R4204.2 ; v1(161.55,37.61) PR164.1 ; R4200.2 177.73,111.5 v1(177.7,111.53)
  vias: v1(173.83,127.43) v1(175.47,127.85) v1(188.04,124.04) v1(188.93,124.04)
+3V_LAN:
  vias: v1(46.67,65.94)
+3V_LDO_EC: length 234.7
  TOP w0.508: v1(176.31,46.7) 176.31,46.71 v1(179.08,46.71) 179.25,46.71 179.91,46.04 182.58,46.04 182.99,46.45 182.99,46.91 183.42,47.34 185.81,47.34 186.32,47.85 186.32,49.22 186.67,49.58 187.64,49.58 188.38,48.83 v1(188.86,48.83) ; v1(75.34,45.08) 75.34,44.83 82.07,38.09 v1(82.07,29.36) ; v1(170.8,52.57) 170.8,53.66 175.29,58.16 176.18,58.16 176.74,57.6 176.74,56.76 v1(176.84,56.66) ; v1(195.36,45.13) 207.3,45.13 208.46,43.96 v1(211.49,43.96) 213.48,43.96 215.27,42.17 215.27,36.12 215.02,35.87 v1(215.02,35.68) ; v1(109.3,33.19) 109.52,33.41 R11288.2
  IN1 w0.508: v1(163.96,45.71) 163.94,45.71 157.94,39.72 156.93,39.72 149.49,32.28 144.83,32.28 142.52,29.97 128.1,29.97 124.91,33.16 109.33,33.16 v1(109.3,33.19) 109.04,33.46 86.59,33.46 86.47,33.34 86.06,33.34 v1(82.07,29.36)
  IN2 w0.508: v1(189.46,48.58) 189.99,48.58 193.44,45.13 v1(195.36,45.13) ; v1(163.96,45.71) 168.03,49.78 168.99,49.78 170.72,51.51 170.72,52.5 v1(170.8,52.57)
  BOTTOM w0.508: 189.36,47.34 189.63,47.34 192.87,44.1 192.87,40.22 ; R741.2 172.22,50.29 172.03,50.48 172.03,51.32 170.8,52.55 v1(170.8,52.57) ; R731.2 R732.2 179.2,46.55 179.08,46.68 v1(179.08,46.71) ; 176.46,46.7 176.54,46.7 R730.2 ; 176.46,46.7 v1(176.31,46.7) ; 176.46,46.7 176.85,46.19 R11119.2 ; 192.87,40.22 D12.1 ; 192.87,40.22 192.87,39.26 192.06,38.44 192.06,36.58 R368.2 ; R753.2 216.63,37.52 215.02,35.91 v1(215.02,35.68) ; PR6296.2 63.2,38.2 64.4,39.39 74.76,39.39 75.37,40 75.37,45.05 v1(75.34,45.08) 75.34,46.83 76.03,47.52 76.03,49.69 PR6295.2
  vias: v1(176.84,56)
+3V_MAIN: length 119.2
  TOP w0.508: v1(179.99,108.07) v1(179.46,108.6) 178.77,109.29 174.71,109.29 174.6,109.18 R4003.1 172.05,109.18 Q4000.3 171.68,110.15 172.9,110.15 v1(172.95,110.21) ; 190.66,106.45 190.83,106.61 194.87,106.61 195.56,107.31 v1(196.48,107.31) 197.62,107.31 198.3,107.99 R4306.2 ; 190.66,106.45 190.66,108.02 189.95,108.73 189.93,108.73 v1(189.92,108.73) R4307.2 ; 190.66,106.45 189.34,105.13 187.97,105.13 v1(187.61,105.48) ; L4206.2 179.25,137.21 179.23,137.23 v1(179.23,137.26) ; v1(176.23,126.58) 176.33,126.58 176.75,127 C4032.2 176.87,127.34 178.05,127.34 C4033.1 ; v1(170.52,125.75) 170.06,125.3 169.62,125.3 169.46,125.14 168.03,125.14 167.24,125.93 164.12,125.93 v1(163.73,125.55) 163.73,121.36 165.11,119.98 v1(167.67,119.98)
  IN1 w0.508: v1(179.23,137.26) 178.77,137.71 177.81,137.71 177.37,138.15 176.26,138.15 175.8,137.69 175.8,131.01 174.68,129.89 174.68,126.44 175.11,126.01 175.83,126.01 176.23,126.41 v1(176.23,126.58)
  IN2 w0.508: v1(187.23,124.04) 187.23,117.57 190.81,113.99 190.81,111.78 189.92,110.89 v1(189.92,108.73) ; v1(179.99,108.07) 180.42,107.64 187.08,107.64 v1(187.13,107.59) 187.13,107.31 186.75,106.93 186.75,106.34 v1(187.61,105.48) ; v1(170.52,125.75) 170.52,125.34 171.35,124.51 174.22,124.51 176.23,126.51 v1(176.23,126.58)
  BOTTOM w0.508: 161.97,125.62 R4330.1 ; 161.97,125.62 163.66,125.62 v1(163.73,125.55) ; 161.97,125.62 R4331.1 ; v1(196.48,107.31) 196.04,107.74 196.04,108.21 195.92,108.33 R4305.2 ; v1(167.67,119.98) 167.67,118.97 168.48,118.16 168.48,116.48 170.52,114.45 Q4002.2 170.69,114.02 171.13,113.58 171.45,113.58 171.48,113.56 172.01,113.56 172.27,113.3 172.27,110.81 172.88,110.21 v1(172.95,110.21) 173.89,110.21 174.59,110.9 R4203.2
+3V_MAIN_EN: length 44.6
  TOP w0.127: v1(188.04,123.15) 188.46,122.73 188.46,119.33 189.29,118.51 189.29,115.34 187.48,113.53 187.48,112.65 R4320.1 187,112.16 187.46,111.7 187.46,111.12 187.64,110.94 187.64,110.57 187.43,110.37 187.43,108.43 187.66,108.2 187.66,106.7 v1(187.59,106.62) ; v1(181.01,106.95) 180.45,106.4 v1(180.22,106.4) 172.08,106.4 171.85,106.62 165.73,106.62 165.42,106.93 Q4001.2 164.74,107.8 164.37,108.17 R4001.2
  BOTTOM w0.127: v1(187.59,106.62) 187.41,106.45 185.56,106.45 185.35,106.24 184.33,106.24 183.83,106.75 181.21,106.75 v1(181.01,106.95)
  BOTTOM w0.152: v1(188.04,123.15) 188.04,123.16 187.63,123.58 U3002.L7
+3V_PCH_ME: length 7.2
  TOP w0.508: R649.1 v1(180.9,55.52) 180.9,54.4 180.22,53.72 180.22,52.68 R698.2
  BOTTOM w0.508: U41.8 178.36,51.71 v1(179.23,52.57)
+3V_POA: length 17.4
  TOP w0.508: v1(111.01,29.89) 111.07,29.89 111.55,30.37 C3000.2 111.55,31.3 v1(111.34,31.51) 111.34,32.69 Q75.3 111.56,33.8 111.31,34.06 R866.2
  BOTTOM w0.508: R2855.1 C3002.2 111.82,20.97 111.18,21.61 111.18,29.72 v1(111.01,29.89)
+3V_POA_R: length 2.6
  BOTTOM w0.305: R2855.2 112.83,17.67 112.25,17.09 CN95.1
+3V_RTC: length 268.5
  TOP w0.635: 147.53,68.15 147.45,68.08 147.45,64.15 148.22,63.39 152.69,63.39 154.03,62.05 154.03,54.73 150.68,51.38 150.68,49.04 151.82,47.9 151.82,46.22 152.86,45.18 152.86,25.72 148.62,21.48 126.96,21.48 122.64,25.8 119.61,25.8 117.56,27.86 110.98,27.86 107.04,31.8 107.04,34.79 106.13,35.71 93.4,35.71 88.27,40.84 82.63,40.84 81.91,41.56 81.91,41.97 77.01,46.87 C381.1 R299.1 ; 147.53,68.15 151.23,68.15 151.68,67.7 156.21,67.7 156.51,68 157.14,68 158.25,66.9 158.25,65.6 159.33,64.52 164.2,64.52 164.72,64 169.5,64 170.41,64.92 171.43,64.92 172.59,66.07 181.45,66.07 187.03,60.5 187.03,57.68 188.65,56.05 188.7,56.05 188.73,56.03 192.31,56.03 196.09,52.25 196.09,52.24 196.42,51.91 211.66,51.91 213.59,53.84 213.59,58.64 215.55,60.6 218,60.6 218.91,61.51 220.27,61.51 221.35,62.59 221.35,68.42 v1(220.88,68.88) 220.66,69.11 R719.1 219.9,70.36 R756.2 ; 147.53,68.15 137.69,68.15 133.94,71.9 130.79,71.9 129.85,72.84 R249.2 128.88,73.8 R252.2 ; R299.1 76.92,49.38 D7.3 ; R299.1 R300.1
+3V_RTC_1: length 2.5
  TOP w0.127: D7.1 73.6,51.59 v1(73.6,51.84)
  TOP w0.508: D7.1 74.16,50.94 R308.2
+3V_RTC_2: length 4.8
  TOP w0.508: R304.1 R301.2 77.79,51.7 77.53,51.96 v1(77.25,51.96) 75.89,51.96 75.51,51.58 D7.2
+3V_S5: length 533.6
  TOP w0.508: v1(53.04,16) 53.04,16.67 R440.2 ; v1(47.4,81.3) 47.8,81.3 R705.2 R708.2 R697.2 ; v1(137.35,96.16) 137.35,93.51 139.62,91.24 141.26,91.24 143.6,88.89 143.97,88.89 152.51,80.36 154.74,80.36 156.67,78.43 156.67,75.03 157.26,74.44 157.26,72.69 157.92,72.03 160.59,72.03 R628.1 161.88,72.07 161.98,71.97 ; C168.2 180.12,38.04 183.28,41.21 185.19,41.21 187.16,39.24 v1(188.6,39.24) ; 149.59,111.45 148.31,111.45 R193.1 ; R152.2 v1(152.72,118.13) R577.2 ; v1(162.13,100.48) 161.75,100.86 161.51,100.86 160.11,102.25 R205.2 ; 152.1,16.94 153.63,18.46 153.63,21.48 156.27,24.12 156.27,30.37 158.48,32.58 v1(158.48,35.12) ; R211.1 161.85,98.95 v1(162.11,99.21) ; R11278.2 36.87,113.21 36.61,112.95 v1(36.61,112.29) R11198.1 R11205.1 ; R439.2 v1(57.53,16.03) ; v1(185.5,48.05) 183.03,48.05 182.72,47.75 182.2,47.75 181.46,47.01 v1(181.46,46.78) ; R291.1 v1(165.85,98.35) ; v1(32.04,101.61) R11251.2
  IN1 w0.508: v1(180.73,61.28) 182.66,61.28 183.67,60.27 189.03,60.27 190.1,59.2 192.94,59.2 196.54,55.61 199.38,55.61 201.63,53.36 207.19,53.36 209.35,55.52 209.35,59.33 v1(209,59.68) 209,60.17 210.65,61.82 211.05,61.82 211.79,62.55 211.79,65.98 211.82,65.98 213.42,67.58 213.42,99.08 214.56,100.22 217.06,100.22 223.12,106.27 223.66,106.27 225.2,107.82 225.2,112.5 226.76,114.06 226.76,154.04 219.56,161.23 219.54,161.23 216.82,163.95 216.82,167.51 211.44,172.89 211.44,176.68 209.19,178.92 209.19,180.7 205.95,183.94 203.71,183.94 202.62,185.03 v1(202.62,186.33) ; 50.35,80.11 50.32,80.13 49.36,80.13 48.19,81.3 v1(47.4,81.3) ; 152.33,117.83 150.68,119.48 v1(150.68,120.29) 150.64,120.33 150.64,121.55 149,123.18 v1(149,125.93) ; 54.67,103.52 65.21,103.52 v1(66.66,104.97) 66.66,106.09 81.03,120.47 82.86,120.47 83.71,121.32 83.71,122.03 83.62,122.12 83.62,122.19 v1(83.56,122.25) 83.56,122.53 84.46,123.44 85.68,123.44 v1(86.16,122.96) ; 195.25,26.34 195.25,24.2 194.93,24.2 ; v1(175.85,53.23) 176.26,52.83 176.26,48.94 176.28,48.91 v1(176.31,48.91) ; v1(58.91,82.52) 57.97,82.52 56.83,81.38 55.66,81.38 52.08,84.96 52.08,89.1 51.11,90.06 48.95,90.06
  IN1 w1.016: 52.03,103.04 52.03,100.15 48.95,97.07 48.95,87.85 50.35,86.46 50.35,78.73
  IN2 w0.508: v1(57.53,16.03) 56.89,15.39 53.65,15.39 v1(53.04,16) ; v1(49.49,30.56) 48.76,30.56 47.17,32.15 47.17,36.6 46.16,37.61 46.16,45.75 47.41,47 v1(48.82,47)
  BOTTOM w0.254: v1(140.04,15.59) 140.04,15.18 139.73,14.88 Q43.5 Q43.2
  BOTTOM w0.508: v1(49.49,30.56) 50.18,30.56 53.04,27.7 v1(53.04,16) ; R682.1 88.53,101.61 79.18,110.97 75.72,110.97 71.41,106.65 68.33,106.65 v1(66.66,104.97) ; 50.46,55.17 48.92,53.64 48.92,47.05 48.87,47 v1(48.82,47) ; v1(32.04,101.61) 32.04,103.6 33.96,105.52 33.96,112.86 ; v1(181.46,46.78) 181.16,46.48 R733.2 R734.2 ; C812.2 195.67,32.01 193.46,29.8 192.54,28.88 192.54,27.87 191.77,27.1 v1(190.51,27.1) ; v1(86.16,122.96) 86.29,122.83 86.29,122.45 86.41,122.33 C808.2 86.66,122.33 86.91,122.58 U47.5 ; R250.2 v1(137.35,96.16) 136.84,95.66 R651.1 ; R290.2 R280.2 R275.2 R283.2 v1(150.17,112.55) ; R402.1 122.49,22.77 v1(122.63,22.91) ; v1(135.15,18.79) L19.1 ; v1(151.69,115.77) 151.42,115.49 R177.2 R586.1 R585.1 ; R543.2 R541.2 R542.2 R540.2 148.52,125.11 149,125.6 v1(149,125.93) ; v1(150.68,120.29) 150.68,119.68 150.44,119.44 R570.1 ; U43.5 201.11,184.86 C763.1 R716.1 202.1,185.81 v1(202.62,186.33) ; v1(176.31,48.91) 176.28,48.91 176.26,48.89 R11118.2 ; v1(209,59.68) PR104.1
  BOTTOM w1.016: 38.49,113.02 42.88,108.63 42.88,105.91 46.18,102.61 47.3,102.61 48.32,103.63 50.83,103.63
  vias: v1(30.77,112.49) v1(31.53,112.49) v1(32.8,103.07) v1(52.91,103.63) v1(53.6,103.63) v1(56.09,56.99) v1(150.12,116.17) v1(160.94,111.53) v1(161.42,111.07) v1(162.72,69.9) v1(162.72,69.24) v1(162.72,68.58) v1(167.98,61.26) v1(168.46,60.8) v1(168.94,60.34) v1(175.85,53.94) v1(185.5,48.71) v1(190.81,39.24) v1(190.84,38.5) v3(47.53,64.99) v3(47.48,64.13) v3(50.31,55.95) v3(50.35,55.18) v3(51.03,56.26) v3(51.05,55.51) v3(51.76,55.93) v3(51.75,55.18) v3(55.81,55.52) v3(56.32,56.08) v3(56.83,55.52) v3(120.48,15.05) v3(121.03,14.39) v3(121.3,15.09) v3(121.82,14.36) v3(122.12,15.09) v3(191.6,15.67) v3(191.6,14.9) v3(191.57,14.12) v3(191.57,13.33)
+3V_WLAN:
  vias: v1(203.97,188.7)
+3VPCU: length 544.7
  TOP w0.381: PR179.2 150.7,180.31 v1(150.37,180.64) ; PR14.2 158.79,176.19 v1(158.78,176.19) ; PR6284.1 v1(54.11,43.82) ; PR9.2 154.36,174.07 153.98,174.45 v1(153.98,175.15) 153.98,176.16 PR16.2
  TOP w0.508: 81.79,22.75 81.69,22.65 68.56,22.65 68.08,22.17 67.24,22.17 66.76,21.69 66.76,20.29 65.28,18.82 62.87,18.82 60.56,21.12 R429.2 R428.2 57.58,21.12 C555.1 ; R52.2 112.59,151.91 R53.1 111.83,151.15 v1(111.56,151.15) ; v1(197.26,28.95) 197.06,28.75 v1(197.06,25.67) 197.21,25.52 197.21,24.2 200.21,21.2 200.21,13.53 204.5,9.24 212.45,9.24 213.87,10.66 213.87,21.15 212.11,22.91 R388.1 212.11,32.31 v1(211.94,32.48) ; PC246.1 209.91,176.58 v1(209.2,177.29) ; v1(220.58,65.6) 220.3,65.88 217.2,65.88 ; 217.2,65.88 217.13,65.95 217.13,69.59 217.91,70.37 R757.2 ; 217.2,65.88 216.11,65.88 214.55,64.32 214.55,64.32 212.73,62.5 v1(210.72,62.5) ; v1(110.36,32.14) 110.29,32.2 R11290.2 ; MR1.1 88.45,4.67 87.51,5.61 84.77,5.61 80.21,10.16 R435.2 ; v1(66.96,55.44) 67.65,54.76 72.07,54.76 74.35,52.47 v1(75.37,52.47) 75.62,52.72 78.42,52.72 79.69,51.45 R304.2
  TOP w1.016: 79.28,42.54 79.28,42.34 83.11,38.5 83.11,27.73 81.79,26.41 81.79,14.96 79.91,13.08 C556.1
  IN1 w0.508: 155.02,176.19 v1(153.98,175.15) ; 155.02,176.19 v1(158.78,176.19) 159.42,176.19 161.17,174.44 180.24,174.44 181.41,175.61 191.04,175.61 198.1,182.67 202.88,182.67 204.02,181.53 v3(204.02,180.82) ; 155.02,176.19 155.1,176.27 155.1,177.92 153.9,179.12 153.9,182.49 150.48,185.92 143.08,185.92 141.92,184.75 138.41,184.75 138.21,184.55 136.4,184.55 135.34,183.48 135.34,181.68 134.02,180.36 130.84,180.36 130.37,179.89 129.33,179.89 128.3,178.86 125.51,178.86 122.31,175.66 120.02,175.66 117.99,173.63 117.99,172.94 117.47,172.42 117.47,171 115.93,169.46 115.93,167.12 112.72,163.91 112.72,163.87 112.71,163.85 112.71,160.24 111.05,158.59 111.05,157.3 111.74,156.61 111.74,155.52 112.03,155.23 112.03,151.62 v1(111.56,151.15) ; v1(208.08,60.68) 208.59,60.68 210.42,62.5 v1(210.72,62.5) 211.14,62.92 211.14,66.25 212.76,67.86 212.76,100.53 212.96,100.73 ; v1(226.03,50.83) 226.03,40.75 219.44,34.16 215.22,34.16 213.54,32.48 v1(211.94,32.48) ; v1(227.77,109.57) 227.77,106.88 228.15,106.5 228.15,105.58 227.77,105.2 227.77,101.11 v1(227.39,100.73)
  IN2 w0.508: v1(54.11,43.82) 51.03,43.82 49.97,44.88 49.97,48.18 v3(49.94,48.2) ; v1(226.03,50.83) 227.49,52.29 227.49,61.23 226.8,61.92 224.26,61.92 v1(220.58,65.6)
  IN2 w1.016: 206.61,100.96 194.34,100.96 193.12,102.18 180.8,102.18 180.13,102.85
  BOTTOM w0.305: RP1.5 196.61,26.12 v1(197.06,25.67) ; 195.23,29 194.89,28.66 RP1.10
  BOTTOM w0.381: v1(197.26,28.95) 197.11,28.95 196.93,29.13 195.36,29.13 195.23,29 ; v1(208.08,60.68) PR101.1 ; PR6279.1 57.89,40.81 58.55,40.16 63.39,40.16 64.04,40.81 v1(64.9,40.81) 65.84,40.81 69.75,44.72
  BOTTOM w0.508: v1(153.98,175.15) 152.28,176.85 152.28,178.73 v1(150.37,180.64) ; v1(76.4,46.12) 76.03,45.75 76.03,39.87 76.03,39.34 76.69,38.68 78.85,38.68 79.31,38.22 89.88,38.22 93.48,38.22 95.69,36.01 96.22,36.01 96.85,36.01 96.85,36.01 107.58,36.01 110.36,33.23 v1(110.36,32.14) 113.22,29.27 R2870.1 ; v1(208.62,102.61) 213.48,102.61 214.38,101.71 214.38,100.88 215.12,100.15 219.49,100.15 219.92,99.71 220.81,99.71 220.94,99.59 226.52,99.59 227.39,100.45 v1(227.39,100.73) ; R695.1 v1(227.77,109.57) ; PR6295.1 v1(75.37,52.47)
  BOTTOM w1.016: PQ19.3 200.84,105.68 v3(206.08,105.68)
  vias: v1(49.56,67.53) v1(50.22,67.56) v1(60.03,57.6) v1(60.73,52.51) v1(73.06,44.98) v1(77.58,44.95) v1(78.06,44.39) v1(78.49,43.89) v1(208.21,101.32) v1(208.21,100.63) v3(50.45,48.76) v3(63.66,55.01) v3(63.66,54.12) v3(63.66,53.23) v3(64.42,55.01) v3(64.42,54.12) v3(64.42,53.23) v3(65.18,55.01) v3(65.18,54.12) v3(65.18,53.23) v3(152.23,51.28) v3(152.23,50.52) v3(162.31,55.14) v3(162.77,54.53) v3(165.59,81.71) v3(165.59,80.94) v3(178.57,103.7) v3(179.28,103.45) v3(203.41,180.36) v3(204.02,179.85) v3(207.27,192.3) v3(207.32,191.41)
+3VPCU_EC: length 4.6
  BOTTOM w0.203: v1(188.55,31.9) 188.05,31.4 U45.26 ; v1(179.98,44.57) U45.114
  BOTTOM w0.508: v1(179.98,44.57) 179.98,44.7 180.14,44.86 C508.1 ; C780.1 v1(188.55,31.9)
  vias: v1(168.06,33.05) v1(170.36,39.75) v1(178.52,25.57) v1(178.62,25.09) v1(179.25,24.94) v1(180.4,39.36) v1(180.7,40.02) v1(181.18,40.51) v1(183.19,44.47) v1(183.85,44.47) v1(187.29,48.33) v1(187.95,48.33)
+3VPCU_ECPLL:
  vias: v1(186.16,44.42)
+5V: length 314.8
  TOP w0.203: 20.91,69.97 21.14,69.75 U13.17
  TOP w0.254: U40.5 14.04,87.51 14.18,87.65 v1(14.56,87.65)
  TOP w0.305: U37.5 11.92,86.67 v1(11.92,86.66)
  TOP w0.508: 20.91,69.97 20.22,70.66 C4749.2 19.61,70.67 19.61,71.04 19.36,71.29 C4753.1 v1(20.28,71.94) ; PR153.1 38.92,36.37 39.17,36.11 v1(39.76,36.11)
  IN1 w1.016: 18.17,57.83 15.47,55.14 15.47,44.06 17.43,42.11 17.43,33.17 19.06,31.54 20.99,31.54 23.04,29.48 23.04,24.56 25.79,21.81 25.79,15.21 29.3,11.7 48.82,11.7 50.07,12.95 52.61,12.95 53.37,12.19 54.72,12.19 ; 65.21,116.2 62.06,116.2 59.96,114.1 47.36,114.1 42.09,108.83 42.09,86.76 40.41,85.07 40.41,83.47 ; 136.4,180.99 136.25,181.15 136.25,183.1 136.79,183.64 138,183.64 138.64,183 141.46,183 143.47,185.01 150.09,185.01 152.96,182.14 152.96,174.75 154.23,173.48 158.5,173.48 159.04,174.02 159.79,174.02 160.34,173.48 180.68,173.48 181.84,174.64 191.35,174.64 192.63,175.92 199.54,175.92 202.47,172.99 203.79,172.99 209.99,166.8 211,166.8 212.83,164.97 212.83,161.01 215.12,158.72 215.12,156.79 221.01,150.9 221.01,145.21 ; 18.75,72.31 15.09,72.31 13.77,73.63 13.77,74.31 12.73,75.36 12.73,81.02 12.53,81.22 12.53,83.98 13.48,84.92 13.48,86.82
  BOTTOM w0.508: v1(39.76,36.11) 41.15,34.72 44.56,34.72 46.15,36.3 48.89,36.3 49.66,35.54 52,35.54 52.02,35.55 52.59,35.55 52.61,35.54 53.31,35.54 54.16,34.69 54.16,21.36 55.71,19.81 55.71,19.25 ; U12.2 67.38,116.46 v1(67.31,116.39) 67.25,116.34 C321.2 ; v1(206.99,44.11) 206.55,44.55 R343.2
  vias: v1(12.17,87.29) v1(19.39,56.99) v1(20.07,56.97) v1(60.89,19.37) v1(119.26,172.82) v1(176.92,11.37) v1(177.3,12.01) v1(177.63,11.4) v1(177.98,12.01) v1(178.29,11.35) v1(178.64,12.01) v1(179,11.37) v1(179.3,12.01) v1(200.89,23.21) v1(201.28,24.48) v1(201.28,23.74) v1(212.27,43.05) v1(212.27,42.34) v1(212.99,43.02) v1(212.96,42.31) v1(221.32,42.72) v1(221.29,42.01) v1(222.03,42.72) v1(222,42.01) v1(225.1,100.27) v3(19.01,61.72) v3(19.03,60.83) v3(26.65,64.51) v3(27.18,65.07) v3(55.86,14.6) v3(56.27,13.94) v3(56.62,14.6) v3(57.03,13.94) v3(57.44,14.57) v3(119.94,172.44) v3(120.43,173.02) v3(221.04,144.16) v3(221.04,143.4) v3(224.57,100.78) v3(224.82,101.54) v3(225.48,100.86) v3(226.37,100.81) v3(230.41,128.34) v3(230.46,127.58) v3(230.82,126.89)
+5V_HDD:
  vias: v1(220.55,47.14)
+5V_KB:
  vias: v1(225.4,141.74)
+5V_ODD:
  vias: v1(223.98,104.03)
+5V_PVDD:
  vias: v1(198.13,37.05)
+5V_S5: length 400.8
  TOP w0.305: v1(144.84,170.02) 145.25,170.44 PR6301.2
  TOP w0.381: PR274.1 49.44,54.65 PR264.2 49.64,54.64 50.26,54.02 v1(50.26,53.41)
  TOP w0.508: PR61.2 124.97,162.86 125.02,162.91 ; 125.02,162.91 125.02,167.43 128.4,170.81 132.75,170.81 v1(133.03,171.09) ; 125.02,162.91 126.2,161.73 PR62.2 127.2,161.73 128.25,162.78 131.12,162.78 131.76,162.15 135.25,162.15 135.72,161.68 PR55.2 137.56,162.76 137.98,162.76 140.24,165.02 v1(142.78,165.02) 147.35,165.02 v1(148.16,164.21) 152.71,164.21 153.37,163.55 154.9,163.55 155.43,163.01 155.43,142.89 v3(156.06,142.26) ; v1(211.16,60.34) 210.88,60.34 209.4,61.82 209.4,63.98 207.85,65.53 v1(207.17,65.53) v1(206.41,65.53) ; PR204.1 132.91,176.67 133.41,176.17 v1(133.53,176.17)
  TOP w2.54: 171.96,10.64 168.23,10.64 165.92,12.95 163.64,12.95 163.54,12.99 159.35,12.99 159.32,12.97 144.99,12.97 144.02,13.94 134.75,13.94 133.94,13.13
  IN1 w0.381: v1(50.26,53.41) 49.59,53.41 47.23,51.05 47.23,35.21 47.71,34.72 v1(48.3,34.72)
  IN1 w0.508: v1(183.85,64.74) 185.12,66.01 189.49,66.01 190.61,64.89 205.77,64.89 v1(206.41,65.53) ; v3(156.06,142.26) 156.29,142.03 156.57,142.03 157.82,140.79 157.82,136.88 155.3,134.36 155.3,124.49 162.92,116.86 162.92,115.87 163.33,115.46 164.77,115.46 166.88,113.35 166.88,112.22 170.34,108.76 170.34,106.9 168.18,104.74 168.18,96.88 166.81,95.51 166.81,92.04 164.92,90.16 164.92,84.47 165.78,83.6 165.81,83.6 166.28,83.13 166.28,83.11 167.57,81.82 167.57,81.69 168.8,80.45 168.8,76.62 168.8,75.65 169.16,75.28 169.16,72.54 169.68,72.02 169.95,71.75 169.95,70.18 173.97,66.16 v1(173.97,65.35) ; v1(133.03,171.09) 133.66,171.72 133.66,176.04 v1(133.53,176.17)
  IN1 w1.524: 216.13,29.33 216.13,12.39 212.6,8.86 204.4,8.86 203.43,9.82 202.62,9.82
  IN2 w0.508: 216.44,31.54 216.44,33.7 219.89,37.15 219.89,40.76 219.14,41.51 219.14,48.01 v1(221.32,50.18)
  IN2 w1.778: 215.96,29.43 215.96,12.49 212.2,8.73 204.37,8.73 202.32,10.79
  BOTTOM w0.305: v1(142.78,165.02) 142.78,165.3 144.84,167.36 v1(144.84,170.02)
  BOTTOM w0.381: v1(48.3,34.72) 48.3,30.8 49.34,29.76 49.77,29.76 52,27.54 52,25.73 v1(51.59,25.32)
  BOTTOM w0.508: v1(148.16,164.21) 148.39,163.98 PR56.2 ; v1(211.16,60.34) 212.47,60.34 213.67,59.14 213.67,54.75 217.98,50.44 221.06,50.44 v1(221.32,50.18) ; v1(183.85,64.74) 183.33,64.22 181.06,64.22 180.29,64.99 174.33,64.99 v1(173.97,65.35)
  vias: v1(18.7,40) v1(18.68,39.34) v1(19.36,39.97) v1(27.84,33.8) v1(27.84,33.13) v1(27.84,32.48) v1(61.83,22.68) v1(173.69,10.59) v1(174.35,10.59) v1(174.7,11.32) v1(175.16,10.61) v1(175.52,11.35) v1(175.82,10.64) v1(200.09,11.1) v1(200.23,10.43) v1(200.23,9.75) v1(200.75,11.1) v1(200.89,10.43) v1(200.89,9.75) v1(214.46,32.43) v1(214.51,31.77) v1(215.07,31.26) v1(215.73,31.26) v3(55.23,22.91) v3(55.51,22.14) v3(55.99,22.91) v3(56.27,22.19) v3(56.85,22.91) v3(131.76,11.12) v3(132.24,11.7) v3(132.72,11.12) v3(133.25,11.68)
+5V_S5_V2: length 9
  TOP w0.508: R11201.2 27.9,100.58 34.22,100.58 34.32,100.48
  vias: v1(36.99,103.17) v1(36.99,102.41) v3(35.06,104.03) v3(35.82,104.03) v3(36.71,104.03)
+5VA: length 2.1
  BOTTOM w0.203: C532.1 206.42,28.15 206.2,28.37 U23.26
  vias: v1(206.38,25.52)
+5VODD:
  vias: v1(227.36,105.13)
+5VPCU: length 469
  TOP w0.203: PU6010.14 50.05,38.33 49.84,38.12 v1(49.84,38.04)
  TOP w0.254: v1(43.45,51.35) 43.37,51.35 43.08,51.06 42.05,51.06 41.66,50.66 40.73,50.66 40.33,51.06 40.31,51.06 40,51.38 PR6290.2
  TOP w0.305: PR6292.1 58.63,54.55 57.79,53.72 55.89,53.72 55.17,54.43 51.34,54.43 v1(50.84,53.93)
  TOP w0.381: PR103.2 218.2,176.31 v1(218.2,176.93) ; PR6281.2 56.33,37.25 56.85,36.72 v1(57.21,36.72) ; PR68.2 44.14,51.42 44.07,51.35 v1(43.45,51.35) ; PR93.2 64.78,69.86 64.77,69.85 64.77,69.77 v1(64.36,69.37)
  TOP w0.508: 35.67,90.67 36.38,89.96 38.54,89.96 39.07,90.49 PR6300.1 ; R356.1 R360.1 15.69,22.11 15.17,22.63 v1(15.17,23.06) ; v1(162.01,53.18) 164.45,53.18 165.03,53.77 167.28,53.77 174.04,60.53 174.04,60.53 174.36,60.85 179.99,60.85 180.42,60.42 v1(180.93,60.42) 181.13,60.22 v1(181.64,60.22) ; PR111.1 217.47,177.15 217.99,177.15 v1(218.2,176.93)
  TOP w0.762: PR88.1 67.61,70.71 v1(66.3,69.41)
  IN1 w0.381: v1(54.72,36.09) 59.51,36.09 60.18,36.76 64.11,36.76 64.75,36.11 v1(68.08,36.11)
  IN1 w0.508: v1(43.45,51.35) 43.91,50.9 43.91,48.38 45.7,46.59 45.7,33.98 45.55,33.83 45.55,30.93 45.24,30.63 45.24,29.7 48.43,26.51 48.54,26.51 v1(49,26.05) ; v1(162.01,53.18) 162.46,52.72 162.46,46.75 159.17,43.46 159.17,42.26 157.56,40.65 156.54,40.65 149.11,33.22 144.46,33.22 142.15,30.91 128.51,30.91 125.34,34.09 112.01,34.09 111.72,34.39 86.2,34.39 86.16,34.34 85.72,34.34 79.44,28.06 76.25,28.06 v1(74.63,26.44) ; v1(181.64,60.22) 182.68,60.22 183.34,59.56 188.83,59.56 189.83,58.55 192.68,58.55 196.5,54.73 196.5,46.5 197.67,45.33 209.1,45.33 211.51,47.75 211.51,48.97 213.14,50.59 213.14,59.2 214.32,60.38 214.32,61.53 216.07,63.28 216.07,64.86 216.99,65.78 216.99,69.77 217.89,70.67 217.89,75.56 218.8,76.47 218.8,87 217.23,88.56 217.23,97.38 219.67,99.82 221.01,99.82 223.41,102.22 223.41,104.02 223.86,104.47 224.8,104.47 227.06,106.73 227.06,111.5 228.69,113.13 228.69,159.35 225.15,162.88 225.15,170.2 221.13,174.23 220.26,174.23 218.2,176.29 v1(218.2,176.93) ; v3(19.67,28.57) 19.41,28.32 17.99,28.32 16.77,27.1 16.77,24.66 v1(15.17,23.06)
  IN2 w0.305: v1(50.84,53.93) 50.82,53.95 50.49,53.95 50.49,53.96 49.5,53.96 48.54,54.92 47,54.92 v1(46.19,54.92)
  BOTTOM w0.381: v1(57.21,36.72) v1(58.55,36.72) 59,37.17 64.36,37.17 64.94,36.6 67.72,36.6 67.92,36.8 ; v1(54.72,36.09) 54.03,36.09 v1(53.75,36.37) 53.19,36.93 52.2,36.93 51.09,38.04 v1(49.84,38.04) ; PR6282.1 67.72,20.62 67.93,20.41
  BOTTOM w0.508: v1(66.3,69.41) 65.81,68.92 64.81,68.92 v1(64.36,69.37) 63.24,69.37 62.81,68.94 61.64,68.94 60.33,70.24 51.36,70.24 46.7,65.58 46.7,65.31 46.23,64.85 46.23,61.59 48.58,59.25 48.58,56.18 47.77,55.37 46.64,55.37 v1(46.19,54.92) 45.74,54.47 45.74,54.16 45.1,53.52 45.1,51.72 44.73,51.35 v1(43.45,51.35) ; PR81.2 159.96,57.31 159.66,57 159.66,56.24 159.46,56.04 159.46,54.28 159.87,53.87 160.46,53.87 161.14,53.18 v1(162.01,53.18)
  vias: v1(51.49,11.02) v1(51.87,11.55) v1(52.2,10.99) v1(52.56,11.55) v1(65.26,22.91) v1(65.36,18.74) v1(68.03,10.71) v1(68.59,11.3) v1(68.74,10.66) v1(69.27,11.27) v1(69.58,27.63) v3(20.02,29.28) v3(20.71,28.9) v3(25.43,27.02) v3(26.24,26.99) v3(26.19,26.23) v3(29.72,36.88) v3(30.13,37.56) v3(30.49,36.85) v3(31.1,37.51) v3(34.52,91.16) v3(34.63,91.94) v3(35.06,90.6) v3(35.82,90.65)
+VCCATS_1P8: length 9.6
  TOP w0.381: v1(142.93,112.68) 142.94,112.67 C250.1 143.56,113.04 143.82,113.3 146.92,113.3 147.55,113.94 v1(147.55,114.02) 147.55,114.34 R180.1
  BOTTOM w0.203: U35.AA1 140.55,112.97 142.64,112.97 v1(142.93,112.68)
+VCCCORE: length 49.7
  TOP w0.127: 113.54,120.29 113.47,120.21 113.47,119.6 ; PR31.2 148.94,177.15 v1(149.08,177.01)
  IN1 w0.203: v1(144.28,149.75) 144.3,149.78 144.41,149.78 145.27,150.64 145.27,163.29 150.25,168.27 150.25,170.71 149.79,171.17 149.79,172.28 150.5,172.99 150.5,175.58 v1(149.08,177.01)
  BOTTOM w0.127: U35.K38 118.95,119.08 ; U35.K38 119.27,118.76 ; U35.K38 118.56,118.76 ; 121.24,119.54 U35.J33 ; U35.J33 120.92,119.23 ; U35.J33 121.24,118.91 ; U35.J33 121.55,119.23 ; 123.38,119.23 U35.J30 ; U35.J30 122.75,119.23 ; U35.J30 123.07,118.91 ; U35.J30 123.07,119.54 ; 122.93,119.69 U35.G32 122.61,119.37 ; 118.95,119.37 U35.G38 ; 118.04,119.37 U35.G40 ; 120.78,120.01 U35.G35 ; U35.G35 120.78,119.37 ; U35.G35 121.1,119.69 ; 120.78,118.44 U35.K35 ; U35.K35 120.39,118.76 ; U35.K35 121.1,118.76 ; U35.K35 120.78,119.08 ; 116.8,118.76 U35.K42 ; U35.K42 117.12,119.08 ; U35.K42 117.44,118.76 ; U35.K42 117.12,118.44 ; 121.69,119.08 U35.K33 121.38,118.76 ; 117.12,119.37 U35.G42 ; 118.35,118.76 U35.K40 ; U35.K40 118.04,119.08 ; U35.K40 117.72,118.76 ; U35.K40 118.04,118.44 ; 116.21,118.44 U35.K43 ; U35.K43 116.53,118.76 ; U35.K43 116.21,119.08 ; 119.73,119.23 U35.J37 ; U35.J37 119.01,119.23 ; U35.J37 119.41,118.91 ; U35.J40 117.9,119.23 ; U35.J40 117.58,119.54 ; U35.J40 117.26,119.23 ; U35.J40 117.58,118.91 ; 119.87,119.37 U35.G37 ; U35.K37 119.47,118.76 ; U35.K37 120.18,118.76 ; U35.K37 119.87,119.08 ; U35.G30 123.21,119.69 ; 121.69,119.37 U35.G33 121.38,119.69
  BOTTOM w0.203: U35.A44 115.66,123.6 115.66,124.47 v1(115.63,124.51)
  vias: v1(118.5,109.42) v1(119.22,110.88) v1(119.41,107.16) v1(119.61,111.48) v1(119.7,114.25) v1(119.7,113.59) v1(119.7,112.91) v1(120.06,110.88) v1(120.3,107.11) v1(120.44,114.3) v1(120.44,113.64) v1(120.44,112.96) v1(120.61,111.48) v1(120.87,110.88) v1(121.21,107.11) v1(121.33,114.3) v1(121.33,113.64) v1(121.33,112.96) v1(121.6,124.84) v1(121.77,109.32) v1(122.08,108.73) v1(122.87,125.9) v1(122.87,125.24) v1(122.87,124.53) v1(131.58,141.6) v1(138.13,145.59) v2(113.13,115.96) v2(113.76,115.96) v2(114.4,115.96) v2(116.73,118.32) v2(117.57,118.32) v2(118.53,118.32) v2(119.22,118.27) v2(119.41,117.62) v2(119.87,118.26) v2(120.05,117.62) v2(120.5,118.23) v2(120.71,117.62) v3(135.34,146.43) v3(135.46,143.94) v3(135.67,147.44) v3(135.82,145.51) v3(136.2,146.5) v3(136.28,144.8) v3(136.3,143.73) v3(136.94,145.54) v3(137.01,144.04) v3(137.42,144.8) v3(137.93,143.91) v3(138.59,144.83) v3(139.1,143.91) v3(139.2,145.54) v3(139.83,144.8) v3(140.32,145.51) v3(140.37,143.96) v3(140.93,143.17) v3(141,144.7) v3(141.64,145.43) v3(141.56,143.86) v3(141.84,143.12) v3(141.89,144.67) v3(142.78,143.86)
+VCCDSW_1P0: length 6.7
  BOTTOM w0.127: U35.AL1 140.67,107.78 141.06,107.78 141.24,107.97 143.24,107.97 143.57,108.3 146.36,108.3 146.55,108.11 C712.1
+VCCEOPIO: length 1.6
  IN1 w0.127: 104.04,107.54 102.8,107.54 ; 107.97,104.38 107.97,104.72
  vias: v1(79.64,101.85) v1(79.64,101.19) v1(79.66,102.48) v1(106.38,110.36) v1(106.41,109.7) v1(107.07,109.49) v3(70.92,97.94) v3(70.92,97.17) v3(71.68,97.96) v3(71.71,97.17)
+VCCGT: length 112.1
  TOP w0.254: v1(130.59,169.21) 130.66,169.29 131.5,169.29 132.44,168.35 v1(133.84,168.35) PR187.2
  IN1 w0.203: v1(110.17,143.99) 110.04,144.11 110.04,147.75 113.62,151.33 113.62,155.21 113.17,155.66 112.91,155.66 112.87,155.7 112.86,155.7 112.62,155.94 112.62,158.35 114.06,159.8 114.06,163.18 117.23,166.34 124.24,166.34 126.88,168.98 130.44,168.98 130.66,169.21 v1(130.59,169.21)
  BOTTOM w0.127: U35.K56 108.58,118.76 ; U35.K56 109.21,118.76 ; U35.K56 108.89,118.44 ; U35.K56 108.89,119.08 ; U35.AK56 109.21,108.39 ; U35.AK56 108.51,108.39 ; U35.AK56 108.89,108.07 ; U35.AK56 108.89,108.77 ; U35.AK50 112.55,108.07 ; U35.AK50 112.87,108.39 ; U35.AK50 112.55,108.71 ; U35.AK50 112.23,108.39 ; U35.AK46 114.38,108.07 ; U35.AK46 114.7,108.39 ; U35.AK46 114.38,108.71 ; U35.AK46 114.06,108.39 ; 111.04,118.76 U35.K53 ; U35.K53 110.72,118.44 ; U35.K53 110.4,118.76 ; U35.AK58 108.36,108.39 ; U35.AK58 107.98,108.77 ; U35.AK58 107.98,108.01 ; U35.AK58 107.6,108.39 ; U35.J55 109.67,119.23 ; U35.J55 109.35,118.91 ; U35.J55 109.35,119.54 ; U35.J55 109.03,119.23 ; U35.L63 105.39,117.25 ; U35.L63 105.39,117.88 ; U35.L63 105.7,117.57 ; U35.L63 105.07,117.57 ; U35.M62 105.86,116.72 ; U35.M62 105.86,117.43 ; U35.M62 106.25,117.11 ; U35.M62 105.54,117.11 ; U35.K58 107.66,118.76 ; U35.K58 107.98,119.08 ; U35.K58 107.98,118.44 ; U35.K58 108.3,118.76 ; U35.AL43 116.35,107.93 ; U35.AL43 116.98,107.93 117.12,108.07 U35.AK42 116.8,108.39 ; U35.AL43 116.67,108.24 ; 110.12,108.39 U35.AK55 ; U35.AK55 109.49,108.39 ; U35.AK55 109.81,108.07 ; U35.AK55 109.81,108.71 ; U35.AL50 113.01,107.61 ; U35.AL50 113.01,108.24 ; U35.AL50 112.69,107.93 ; U35.AL50 113.33,107.93 ; 107.52,108.31 U35.AL60 107.9,107.93 ; U35.K55 110.12,118.76 ; U35.K55 109.81,118.44 ; U35.K55 109.49,118.76 ; U35.K55 109.81,119.08 ; U35.K50 112.23,118.76 ; U35.K50 112.87,118.76 ; U35.K50 112.55,119.08 ; U35.K50 112.55,118.44 ; 105.39,113.31 U35.AA63 ; U35.AA63 105.39,112.68 ; U35.AA63 105.07,113 ; 105.39,113.59 U35.W63 105.07,113.91 ; 110.4,108.39 U35.AK53 ; U35.AK53 111.04,108.39 ; U35.AK53 110.72,108.07 ; U35.AK53 110.72,108.71 ; 113.46,118.44 U35.K48 ; U35.K48 113.78,118.76 ; U35.K48 113.15,118.76 ; U35.J60 106.92,119.23 ; U35.J60 106.61,119.54 ; U35.J60 106.61,118.91 ; U35.J60 106.29,119.23 ; 114.52,107.93 U35.AL46 ; U35.AL46 115.15,107.93 ; U35.AL46 114.84,108.24 ; 111.64,119.08 U35.K52 ; U35.K52 111.95,118.76 ; U35.K52 111.32,118.76 ; U35.K52 111.64,118.44 ; 107.06,119.08 U35.K60 ; U35.K60 107.06,118.44 ; U35.K60 107.38,118.76 ; U35.K60 106.75,118.76 ; 107.06,108.77 U35.AK60 107.45,108.39 ; U35.J56 108.44,118.91 ; U35.J56 108.44,119.54 ; U35.J56 108.75,119.23 ; U35.J56 108.12,119.23 ; U35.AM58 107.98,107.83 ; 105.86,118.34 U35.L62 ; U35.L62 106.17,118.02 ; U35.L62 105.86,117.71 ; U35.L62 105.54,118.02 ; U35.J58 107.52,118.91 ; U35.J58 107.84,119.23 ; U35.J58 107.2,119.23 ; U35.J50 112.09,119.54 ; U35.J50 112.41,119.23 ; U35.J50 111.78,119.23 ; U35.J50 112.09,118.91 ; U35.J43 115.75,118.91 ; U35.N63 105.39,116.26 ; U35.N63 105.78,116.65 ; U35.N63 105.39,117.05 ; 113.92,118.91 U35.J46 ; U35.AK48 113.46,108.71 ; U35.AK48 113.78,108.39 ; U35.AK48 113.15,108.39 ; U35.AK48 113.46,108.07 ; U35.AK52 111.95,108.39 ; U35.AK52 111.64,108.07 ; U35.AK52 111.64,108.71 ; U35.AK52 111.32,108.39 ; 109.35,108.24 U35.AL56 ; U35.AL56 109.03,107.93 ; U35.AL56 109.67,107.93 ; U35.AK43 116.21,108.07 ; U35.AK43 116.21,108.71 ; U35.AK43 116.53,108.39 ; 111.5,107.93 U35.AL53 ; U35.AL53 111.18,107.61 ; U35.AL53 110.86,107.93 ; U35.AL53 111.18,108.24 ; U35.R63 105.07,115.74 ; U35.R63 105.39,115.42 ; U35.R63 105.39,116.06 ; 111.5,119.23 U35.J52 111.18,118.91 ; 114.84,118.91 U35.J45 ; 113.01,118.91 U35.J48 112.69,119.23 ; U35.AM56 108.89,107.83 ; 109.95,119.23 U35.J53 110.26,118.91 ; 115.29,108.07 U35.AK45 ; U35.AK45 115.29,108.71 ; U35.AK45 114.98,108.39
  BOTTOM w0.152: U35.BB66 103.28,101.13 102.27,100.12 101.94,100.12 101.66,99.84 101.05,99.84 v1(100.93,99.95) ; v1(98.91,108.65) 98.99,108.57 U35.AK70 ; U35.A48 113.19,123.49 113.21,123.51 113.21,124.53 v1(113.4,124.72)
  BOTTOM w0.178: U35.A58 108.23,124.21 108.16,124.28 v1(108.16,124.48)
  BOTTOM w0.203: U35.AU63 105.17,104.2 104.8,104.58 v2(104.77,104.58) ; U35.BB57 108.36,101.39 108.36,99.87 108.18,99.69 v1(108.18,99.66) ; U35.A66 103.27,124.34 v1(103.23,124.39) ; U35.AU58 107.91,104.2 v2(107.56,104.55) ; U35.A62 105.75,124.78 v1(105.59,124.94) ; U35.A53 110.46,123.64 110.46,123.93 110.1,124.29 v1(110.1,124.57)
  BOTTOM w0.254: U35.J43 U35.J45 U35.J46 U35.J48 ; 105.54,113.45 U35.Y62 ; U35.J53 U35.J52 ; 105.54,115.28 U35.T62
  BOTTOM w0.381: R155.1 v1(94.16,121.18)
  vias: v1(92.25,116.9) v1(92.27,115.28) v1(92.91,116.9) v1(92.93,115.28) v1(93.5,121.18) v1(93.57,116.9) v1(93.59,115.28) v1(94.23,116.9) v1(94.25,115.28) v1(94.89,116.9) v1(95.54,115.29) v1(95.56,116.89) v1(96.22,116.89) v1(96.2,115.29) v1(100.5,113.45) v1(101.21,113.45) v1(108.11,108.94) v1(108.19,109.6) v1(108.83,109.61) v1(108.76,108.92) v1(108.93,113.92) v1(108.96,114.58) v1(109.44,109.38) v1(109.39,108.74) v1(109.62,114.56) v1(109.59,113.9) v1(109.59,113.24) v1(110.28,114.56) v1(110.26,113.9) v1(110.26,113.24) v1(110.28,109.35) v1(110.28,108.72) v1(110.92,115.3) v1(110.94,114.58) v1(110.92,113.92) v1(110.94,113.26) v1(111.2,109.35) v1(111.2,108.72) v1(111.56,126.03) v1(111.61,114.6) v1(111.59,113.94) v1(111.61,113.28) v1(112.11,108.72) v1(112.47,109.33) v1(113,108.69) v1(113.15,109.33) v1(113.91,109.33) v1(113.91,108.69) v1(114.52,109.15) v2(94.9,115.29) v2(103.13,116.22) v2(103.1,112.58) v2(104.43,115.31) v2(104.45,116.2) v2(107.47,117.85) v2(107.64,116.03) v2(107.64,115.35) v2(107.64,114.61) v2(108.11,117.85) v2(108.3,115.35) v2(108.3,114.66) v2(108.27,114) v2(108.35,116.01) v2(108.74,117.85) v2(108.99,116.01) v2(108.99,115.32) v2(109.38,117.88) v2(109.65,115.98) v2(109.65,115.3) v2(110.01,117.88) v2(110.28,116.01) v2(110.28,115.3) v2(110.65,117.88) v2(110.92,116.01) v2(111.28,117.85) v2(111.56,115.97) v2(111.56,115.31) v3(80.85,131.13) v3(81.62,131.46) v3(82.43,131.8) v3(83.11,132.15) v3(83.83,132.56) v3(110.88,146.88) v3(110.88,145.56) v3(110.88,144.24) v3(110.85,142.87) v3(111.23,143.56) v3(111.26,147.54) v3(111.26,146.22) v3(111.26,144.9) v3(111.28,142.21) v3(111.64,146.88) v3(111.64,145.56) v3(111.64,144.24) v3(111.61,142.89) v3(111.66,141.55) v3(112.02,147.54) v3(112.02,146.22) v3(112.02,144.9) v3(112.02,143.56) v3(112.05,142.21) v3(112.4,146.88) v3(112.4,145.56) v3(112.4,144.24) v3(112.4,142.87) v3(112.78,147.54) v3(112.78,146.22) v3(112.78,144.9) v3(113.16,146.88) v3(113.16,145.56) v3(113.54,147.54) v3(113.54,146.22) v3(113.54,144.9) v3(113.92,146.88) v3(113.92,145.56) v3(114.31,144.88) v3(114.38,146.22) v3(114.71,145.51) v3(115.42,140.1)
