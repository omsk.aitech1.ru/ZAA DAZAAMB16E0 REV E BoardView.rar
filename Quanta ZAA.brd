# Allegro board Quanta ZAA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVDD: length 29.3
  TOP w0.508: v1(197.51,39.23) 198.6,40.32 210.99,40.32 v1(212.81,38.5) 213.01,38.3 v1(213.01,37.74)
  BOTTOM w0.508: v1(213.01,37.74) 213.01,38.83 215.04,40.86 215.04,43.99 214.49,44.54 R338.1 213.92,45.08 213.65,45.36 212.22,45.36 ; L13.1 v1(197.51,39.23)
V0P85A_VID0: length 6.9
  TOP w0.127: v2(134.95,106.48) 135.42,106.01 135.42,104.33 135.79,103.96 135.79,101.21 TP31.1
  BOTTOM w0.127: U35.AN11 v2(134.95,106.48)
VCCGT_PHASE1: length 8.3
  TOP w0.762: PR57.1 v1(121.64,153.61) 121.64,152.87 v3(121.24,152.47)
  IN2 w0.508: v3(121.72,155.93) 122,156.2 122,161.08 v3(121.47,161.61)
VCCGT_PHASE2: length 8.7
  TOP w0.762: PR58.1 130.31,154.15 v1(130.33,154.12) v3(131.1,153.36)
  IN2 w0.508: v3(131.1,161.69) 131.86,160.93 131.86,158.08 131.22,157.45 v3(131.22,155.67)
VCCGT_SENSE: length 86.9
  TOP w0.127: PR191.1 134.29,166.97 129.98,166.97 v1(129.93,167.02)
  IN2 w0.14: v1(129.93,167.02) 129.84,166.94 125.33,166.94 122.13,163.74 120.16,163.74 117.68,161.26 117.68,161.06 116.59,159.96 116.59,156.51 116.29,156.2 115.83,156.2 v1(115.8,156.23)
  BOTTOM w0.079: 98.99,118.64 99.62,118.64 99.75,118.51 100.41,118.51 100.74,118.83 U35.J70
  BOTTOM w0.127: v1(115.8,156.23) 115.35,156.23 114.74,155.62 112.69,155.62 111.97,156.33 107.97,156.33 106.21,154.57 106.21,153.73 103.08,150.6 103.08,149.54 100.02,146.49 100.02,145.35 95.19,140.52 94.61,140.52 91.17,137.08 91.01,137.08 90.1,136.16 90.1,132.37 91.8,130.67 91.8,125.92 91.99,125.74 91.99,123.27 93.27,122 95.2,122 95.57,121.63 R155.2 96.2,120.54 96.83,120.54 98.74,118.64 98.99,118.64
VCCGT_VBST1:
  vias: v1(120.99,162.3)
VCCGT_VBST2:
  vias: v1(129.9,161.89)
VCCGT_VCC1: length 1.1
  TOP w0.508: PR61.1 v1(118.57,162.86)
VCCGT_VCC2:
  vias: v1(125.54,161.07) v1(127.31,160.57)
VCCK_V12: length 15.6
  TOP w0.203: U13.25 22.28,65.55 ; U13.4 26.57,68.15 27,67.71 C4748.2
  TOP w0.254: C4748.2 27.61,67.88 27.06,68.43 v1(26.97,68.43) ; C4751.2 21.52,64.79 v1(21.9,65.17) 22.28,65.55
  TOP w0.508: C4751.2 21.17,64.29 20.85,63.97 C4754.2 20.28,64.52 v1(20.57,64.81)
  IN2 w0.508: v1(20.57,64.81) 22.17,66.41 24.94,66.41 v1(26.97,68.43)
VCCOPC_VID0: length 2.2
  TOP w0.305: R708.1 49.21,82.06 v1(49.4,82.06)
  BOTTOM w0.305: PR287.2 49.43,82.06 v1(49.4,82.06) 49.19,82.06 R707.2
VCCOPC_VID0_C: length 1.8
  BOTTOM w0.254: PU14.4 51.45,82.37 v1(51.44,82.37) 51.24,82.57 PR287.1
VCCOPC_VID1: length 2.2
  TOP w0.305: v1(49.35,81.06) 49.33,81.06 R705.1
  BOTTOM w0.305: PR286.2 49.44,81.06 v1(49.35,81.06) 49.3,81.06 R706.2
VCCOPC_VID1_C: length 3.3
  BOTTOM w0.254: PU14.3 51.98,81.87 51.62,81.51 51.62,80.84 51.43,80.66 v1(51.21,80.66) 50.92,80.66 50.69,80.88 PR286.1
VCCRTC_2: length 3.3
  TOP w0.635: R308.1 70.92,51.72 BT1.1
VCCSA_SW: length 10.4
  TOP w0.762: PR59.1 149.91,152.28 v1(149.82,152.37) 149.76,152.43 v3(149.76,153.33)
  IN1 w0.762: v3(153.14,161.84) 153.4,161.59 153.4,154.81 v3(152.69,154.1)
VCCSA_VBST:
  vias: v1(152.23,162.02)
VCCSA_VCC:
  vias: v1(147.48,160.43)
VCCST_PWRGD: length 11.7
  BOTTOM w0.076: 103.68,124.23 103.68,123.34 U35.B65
  BOTTOM w0.114: 97.1,126.29 98.29,125.1 101.19,125.1 101.26,125.18
  BOTTOM w0.127: R89.1 95.44,126.13 96.2,126.13 96.7,126.64 C136.2 96.75,126.64 97.1,126.29 ; 101.26,125.18 103.12,125.18 103.68,124.62 103.68,124.23
VCCST_PWRGD_EN: length 10.7
  BOTTOM w0.127: R103.1 R102.1 R777.2 v1(89.72,125.06) 89.72,126.26 88.7,127.27 87.18,127.27 86.91,127 U47.1
VCCST_PWRGD_EN_L: length 9
  BOTTOM w0.127: R777.1 88.94,122.33 C823.2 C824.2 87.69,122.83 88.21,123.35 U47.4 88.21,124.46 88.04,124.63 85.38,124.63 84.89,125.11 U6.2
VCCST_PWRGD_R: length 13.8
  IN2 w0.14: v1(84.82,122.78) 84.82,123.46 85.73,124.38 87.92,124.38 89.8,126.26 v1(93.35,126.26)
  BOTTOM w0.127: v1(84.82,122.78) 84.84,122.75 84.84,122.5 85.01,122.33 R85.1 85.54,122.34 U6.4 ; v1(93.35,126.26) 93.73,126.64 R89.2
VDD10: length 4
  TOP w0.203: U15.3 39.3,77.11 v1(39.3,77.11) C757.1 ; C355.1 37.27,77.14 v1(37.3,77.11) U15.8
  vias: v1(35.16,75.94) v1(38.89,68.35) v1(42.07,74.34) v1(42.47,76.47) v3(44.63,69.11) v3(44.89,69.82)
VDD_DAC_33: length 3.7
  TOP w0.203: v1(20.25,68.22) 20.58,68.55 U13.20
  BOTTOM w0.508: v1(20.25,68.22) 20.38,68.35 C4750.2 21.01,68.35 L4208.2
VDDREG:
  vias: v1(40.32,67.86)
VIN: length 164.5
  TOP w0.381: v1(46.21,52.06) 45.65,52.06 45.25,52.46 PR261.2 ; PR141.1 68.13,106.01 67.49,105.38 PR142.1
  TOP w0.508: v1(46.8,103.52) 51.15,103.52 ; 51.15,103.52 52.66,105.02 64.52,105.02 66.03,103.52 PR142.1 ; 51.15,103.52 51.62,103.05 51.62,94.58 50.47,93.43 50.47,90.48 50.98,89.96 v1(50.98,88.54) ; v1(212.46,63.14) 216.34,67.01 216.34,75.81 ; 50.4,32.2 49.07,33.53 49.07,35.61 48.11,36.57 47,36.57 46.73,36.31 PR148.1 PR151.1 ; v3(54.64,74.42) 55.21,73.85 PR159.1 ; PD4.2 43.62,107.06 v1(43.97,106.7) ; PR6130.1 48.82,42.44 v1(48.57,42.69)
  IN1 w0.381: v3(56.95,66.21) 56.08,65.34 53.69,65.34 49.1,60.75 v1(48.95,60.75)
  IN1 w0.508: v1(50.98,88.54) 51.36,88.16 51.36,84.42 54.64,81.15 v3(54.64,77.03) ; v1(212.46,63.14) 212.46,62.31 211.16,61.01 210.88,61.01 210.5,60.62 210.5,60.07 211,59.56 v1(211,54.17)
  IN2 w0.508: v1(208.72,46.15) 211,48.43 v1(211,54.17)
  BOTTOM w0.127: PR209.1 208.59,184.41 210.12,184.41 PR213.2
  BOTTOM w0.381: 223.02,175.12 223.02,175.75 222.38,176.39 222.38,177.69 PR116.1 222.42,177.73 223.36,177.73 PC292.1 ; v1(48.95,60.75) 49.35,60.34 49.35,60.34 49.42,60.28 49.42,55.66 48.07,54.31 48.07,53.35 46.78,52.06 v1(46.21,52.06) ; PR97.1 61.85,70.47 61.54,70.78 PC271.1 61.54,71.68 61.78,71.92 61.78,73.82 61.5,74.11 61.12,74.11
  BOTTOM w0.508: PR212.2 132.63,174.78 131.37,173.53 131.37,170.97 PC138.1 ; R345.1 208.58,46.29 v1(208.72,46.15) ; v1(211,54.17) 210.56,53.73 PR260.1 ; v1(43.97,106.7) 43.97,106.34 v1(46.8,103.52)
  vias: v1(52.33,79.65) v1(54.57,33.83) v1(55.73,68.37) v1(59.08,77.28) v1(141.46,159.74) v1(153.98,161.08) v1(210.09,78.76) v1(224.14,175.63) v3(51.69,31.48) v3(51.77,66.29) v3(52.05,67.05) v3(52.38,31.85) v3(52.44,30.89) v3(52.51,67.76) v3(52.81,67.05) v3(53.04,79.17) v3(53.27,75.08) v3(53.27,74.19) v3(54.54,75.2) v3(54.64,76.09) v3(56.32,67.79) v3(56.43,66.83) v3(56.52,32.94) v3(56.6,44.67) v3(56.6,32.18) v3(56.95,67.37) v3(57.08,43.96) v3(57.31,32.79) v3(57.36,31.62) v3(57.59,44.6) v3(58.1,43.96) v3(58.6,44.6) v3(59.87,76.58) v3(60.74,75.97) v3(116.87,162.55) v3(116.87,161.79) v3(132.87,163.8) v3(133.05,167.56) v3(133.62,163.8) v3(133.94,167.56) v3(134.38,163.8) v3(135.13,163.8) v3(135.88,163.8) v3(138.64,159.33) v3(139.05,159.96) v3(139.48,159.3) v3(139.93,159.99) v3(140.38,159.27) v3(140.73,159.95) v3(142.53,161.01) v3(143.19,161.36) v3(145.88,166.01) v3(146.11,166.85) v3(146.72,166.34) v3(147.48,168.19) v3(148.01,167.61) v3(148.06,168.78) v3(148.65,169.29) v3(148.62,168.12) v3(157.51,165.65) v3(157.66,164.74) v3(158.27,165.65) v3(161.58,178.89) v3(161.58,178.02) v3(162.34,178.84) v3(162.34,178.05) v3(164.22,180.61) v3(178.22,78.66) v3(178.17,77.72) v3(178.17,76.83) v3(178.17,75.89) v3(178.29,79.5) v3(179.15,80.47) v3(180.12,80.45) v3(181.11,80.47) v3(209.53,82.06) v3(209.51,81.27) v3(209.48,80.51) v3(209.82,182.07) v3(209.98,181.34) v3(210.01,180.59) v3(210.29,82.11) v3(210.29,81.27) v3(210.27,80.49) v3(210.8,181.34) v3(210.82,180.59) v3(211.58,180.57) v3(215.42,98.32) v3(215.42,97.56) v3(215.42,96.79) v3(215.42,96.03) v3(215.42,95.27) v3(215.4,94.51) v3(217.58,76.75) v3(223.45,173.63) v3(223.83,172.87) v3(224.21,173.63) v3(224.59,172.87) v3(224.97,173.63) v3(227.08,173.42) v3(227.08,172.65) v3(228.35,174.59) v3(229.11,174.59)
VSSGT_SENSE: length 86.2
  TOP w0.127: v1(129.93,166.36) 130.16,166.59 134.44,166.59 PR181.1
  IN2 w0.14: v1(115.77,155.58) 116.22,155.58 116.99,156.35 116.99,159.8 118.08,160.89 118.08,161.1 120.32,163.34 122.29,163.34 125.49,166.54 129.75,166.54 v1(129.93,166.36)
  BOTTOM w0.079: U35.J69 101.32,118.83 101.01,119.15 99.9,119.15 99.65,118.9 99.02,118.9 98.99,118.92
  BOTTOM w0.127: 98.99,118.92 96.74,121.17 R161.1 95.49,122.38 93.42,122.38 92.37,123.43 92.37,125.89 92.19,126.08 92.19,130.83 90.48,132.53 90.48,136.01 91.17,136.7 91.33,136.7 94.77,140.14 95.35,140.14 100.41,145.19 100.41,146.33 103.46,149.39 103.46,150.44 106.59,153.57 106.59,154.41 108.13,155.95 111.82,155.95 112.53,155.24 114.9,155.24 115.24,155.58 v1(115.77,155.58)
1P35V_BOOT:
  vias: v1(44.56,60.22)
1P35V_CS: length 2.6
  TOP w0.203: PR250.2 48.47,56.63 47.97,56.13 47.6,56.13 46.97,56.76 PU21.13
1P35V_FB: length 4.3
  TOP w0.203: PU21.6 43.45,55.16 43.38,55.23 41.37,55.23 40.94,54.8 PR258.1
  TOP w0.305: PR266.1 40.23,54.8 PR258.1
1P35V_LGATE: length 11.7
  IN2 w1.016: v3(57.55,61.42) 53.37,57.24 49.14,57.24 48.68,57.69 v3(47.73,57.69)
1P35V_PGOOD: length 1.9
  TOP w0.203: PR267.1 46.22,53.57 45.81,53.97 45.81,54.16 45.54,54.43 PU21.10
1P35V_PHASE: length 17.7
  TOP w0.762: PR90.1 62.36,59.56 63.18,59.56 v3(63.79,60.17)
  IN2 w0.762: v3(46.24,58.74) 50.32,58.74 54.82,63.24 v3(60.4,63.24)
  vias: v1(61.37,63.24)
1P35V_S3: length 14.3
  TOP w0.127: PR6302.1 44.61,62.25 44.22,61.85 44.22,61.52 44.15,61.46 v1(44.15,61.45)
  TOP w0.203: v1(42.88,54.11) 43.83,54.11 44.34,54.62 PU21.7
  TOP w0.305: PR6303.2 41.79,54.53 41.42,54.16 41.42,53.63 PR257.1 41.45,53.61 PC196.1 42.4,53.63 v1(42.88,54.11)
  BOTTOM w0.305: v1(42.88,54.11) 42.88,54.64 42.61,54.91 42.61,56.39 43.58,57.35 43.58,57.63 43.58,57.63 43.58,60.35 44.15,60.92 v1(44.15,61.45)
1P35V_S5: length 5
  TOP w0.203: PU21.8 44.74,54.32 v1(44.63,54.21) 44.31,53.88 44.31,53.6
  TOP w0.305: PR6303.1 42.6,54.7 43.34,54.7 v1(43.42,54.62)
  TOP w0.381: PR263.1 44.29,53.61 PC203.1
  IN2 w0.305: v1(43.42,54.62) 44.22,54.62 v1(44.63,54.21)
1P35V_TON: length 1.6
  TOP w0.203: PR261.1 45.25,54.2 45.14,54.31 PU21.9
1P35V_UGATE: length 14.7
  IN2 w1.016: v3(45.41,59.46) 45.67,59.72 45.76,59.72 45.83,59.79 49.39,59.79 49.46,59.85 49.57,59.85 54.18,64.46 v3(58.08,64.46)
1P35V_VDD: length 4
  TOP w0.203: PU21.12 46.9,56.36 47.64,55.62 PR274.2
  TOP w0.305: PR274.2 48.66,55.9 49.38,56.62 PC217.1
1P35V_VDDQ: length 29.3
  TOP w0.203: PR258.2 41.75,55.58 v1(41.95,55.77) 42.14,55.96 PU21.5
  TOP w0.381: PR254.1 65.7,58.51 v1(65.45,58.76)
  IN2 w0.381: v1(41.95,55.77) 42.54,55.77 42.73,55.58 44.79,55.58 44.8,55.57 45.28,55.57 45.29,55.58 49.05,55.58 49.69,54.93 49.69,54.92 50.07,54.55 50.08,54.55 50.1,54.53 52.35,54.53 56.09,58.27 64.38,58.27 64.87,58.76 v1(65.45,58.76)
1P35V_VID: length 3.1
  TOP w0.203: PU21.11 46.34,55.63 v1(46.81,55.15) 46.87,55.1 PR265.1
  TOP w0.381: PR265.1 47.91,55.1 48.38,54.64 PR264.1
2ND_MBCLK: length 140.3
  TOP w0.127: v1(184.79,109.54) 184.04,108.8 184.04,104.7 182.85,103.5 182.55,103.5 182.02,102.97 181.21,102.97 178.54,100.3 178.54,92.48 176.49,90.42 173.58,90.42 172.59,89.43 171.6,89.43 170,87.83 167.4,87.83 v1(166.13,86.56) ; v1(180.63,44.47) 180.7,44.55 180.7,44.9 180.57,45.03 179.56,45.03 179.37,45.22 178.01,45.22 177.63,45.6 175.08,45.6 174.31,46.36 174.31,47.41 173.85,47.87 170.49,47.87 v1(170.24,47.62)
  IN2 w0.14: v1(154.69,115.73) 154.87,115.55 154.87,114.85 156.03,113.69 157.69,113.69 162.12,109.27 162.36,109.27 162.74,108.88 162.74,107.87 165.87,104.74 165.87,103.96 166.36,103.46 166.36,91.44 166.1,91.17 166.1,87.57 166.26,87.4 166.26,86.69 v1(166.13,86.56) 165.3,85.73 165.3,84.72 164.74,84.17 164.74,75.49 165.21,75.01 165.21,70.07 165.51,69.78 165.51,66.96 171.38,61.09 171.38,60.1 171.86,59.62 171.86,55.2 171.55,54.89 171.55,51.13 169.64,49.21 169.64,48.22 v1(170.24,47.62)
  BOTTOM w0.127: U45.115 180.38,44.22 v1(180.63,44.47) 181.16,45 R733.1 ; Q4302.3 184.53,109 184.79,109.27 v1(184.79,109.54) ; v1(154.69,115.73) 154.84,115.88 154.84,116.11 154.63,116.33 151.54,116.33 150.65,115.43 149.58,115.43 148.7,114.55 147.06,114.55 R171.1
2ND_MBDATA: length 140.3
  TOP w0.127: v1(184.84,106.98) 184.84,107.06 184.74,107.16 184.42,107.16 184.32,107.06 184.32,104.58 182.96,103.22 182.67,103.22 182.13,102.69 181.32,102.69 178.83,100.2 178.83,93.78 178.82,93.77 178.82,92.36 176.6,90.14 173.7,90.14 172.71,89.15 171.72,89.15 170.11,87.55 167.8,87.55 166.15,85.9 v1(166.13,85.9) ; v1(181.28,44.5) 181.06,44.72 181.06,45 180.75,45.31 179.67,45.31 179.48,45.5 178.12,45.5 177.74,45.88 175.19,45.88 174.59,46.48 174.59,47.53 173.97,48.15 170.44,48.15 v1(170.24,48.36)
  IN2 w0.14: 166.15,85.9 165.59,85.33 165.59,84.6 165.03,84.04 165.03,75.61 165.51,75.14 165.51,70.19 165.8,69.9 165.8,67.09 171.67,61.21 171.67,60.22 172.15,59.74 172.15,55.08 171.84,54.77 171.84,51 169.93,49.09 169.93,48.66 v1(170.24,48.36) ; 166.15,85.9 v1(166.13,85.9) ; 166.15,85.9 166.55,86.3 166.55,87.52 166.39,87.69 166.39,91.05 166.66,91.32 166.66,103.59 166.16,104.08 166.16,104.87 163.04,107.99 163.04,109 162.48,109.56 162.24,109.56 157.82,113.98 156.15,113.98 155.16,114.97 155.16,115.51 v1(155.38,115.73)
  BOTTOM w0.127: U45.116 180.78,44 v1(181.28,44.5) 181.28,44.67 181.59,44.98 181.59,45.16 181.74,45.31 182.09,45.31 R734.1 ; R175.1 146.75,114.92 146.84,114.83 148.58,114.83 149.47,115.71 150.53,115.71 151.43,116.61 154.74,116.61 155.12,116.22 155.12,115.98 v1(155.38,115.73) ; Q4302.6 184.93,107.7 184.84,107.61 v1(184.84,106.98)
554EN_0.95V: length 3.2
  BOTTOM w0.127: v1(205.02,171.69) PR321.1
  BOTTOM w0.305: PR321.1 205.04,172.43 205.04,173.22 PC300.2 205.35,173.63 206.22,173.63 PU18.5
554FB_0.95V: length 3.4
  BOTTOM w0.254: PR309.1 205.04,176.5 PR310.2 PC301.1
  BOTTOM w0.305: PU18.6 205.59,176.65 205.47,176.52 PR309.1
554FB_0.95V_S: length 2.9
  BOTTOM w0.127: PR311.1 v1(203.16,175.28)
  BOTTOM w0.254: PR310.1 PC301.2
  BOTTOM w0.381: PR311.1 204.2,174.58 PC301.2
554LX_0.95V:
  vias: v1(208.07,171.92)
554NC_0.95V: length 2.5
  BOTTOM w0.305: PC247.2 v1(205.86,177.54) 206.61,177.54 206.9,177.25 PU18.7
554PG_0.95V: length 3.7
  TOP w0.508: v1(206.41,171.67) v1(205.95,172.13) 205.67,172.41 PR317.2
  BOTTOM w0.305: v1(206.41,171.67) 206.9,172.16 PU18.4
554SVIN_0.95V:
  vias: v1(205.84,178.85)
681_AGND: length 60.5
  TOP w0.508: v1(56.47,82.72) 56.89,82.3 56.89,81.74 56.36,81.21 v1(56.36,81.15) PR294.2
  IN2 w0.508: v1(56.47,82.72) 56.47,83.23 52.46,87.24 52.46,89.33 50.25,91.54 50.25,97.12 55.56,102.43 69.73,102.43 72.24,99.92 75.67,99.92 76.49,100.73 76.49,101.87 77.22,102.61 77.22,104.79 76.74,105.28 v1(76.74,107.16)
  BOTTOM w0.254: PU14.11 56.32,82.87 v1(56.47,82.72)
  BOTTOM w0.381: R632.1 R636.1
  BOTTOM w0.508: PC230.1 56.68,82.51 v1(56.47,82.72) ; R636.1 76.9,107 v1(76.74,107.16)
1658R-BOOT1:
  vias: v1(201.96,61.67)
1658R-BOOT2:
  vias: v1(197.74,61.85)
1658R-COMP: length 5
  BOTTOM w0.203: PC221.1 196.35,59.51 196.42,59.43 197.03,59.43 197.35,59.74 PU19.12
  BOTTOM w0.381: TP4362.1 196.31,58.82 PC221.1 PC199.1
1658R-EN: length 6.2
  BOTTOM w0.203: PU19.3 203.05,60.14 203.97,61.06 204.72,61.06 v1(205.2,61.53) PR276.2
  BOTTOM w0.305: PR345.2 PR276.2
1658R-FB: length 7.5
  BOTTOM w0.203: PC110.1 195.14,56.43 195.89,56.43 197.39,57.93 197.39,59.13 197.61,59.34 PU19.11
  BOTTOM w0.305: TP4363.1 194.88,57.65 PR277.2
  BOTTOM w0.381: PC110.1 PR277.2
1658R-FBRTN: length 5.7
  BOTTOM w0.203: PR279.2 195.09,56.1 196.03,56.1 197.55,57.63 v1(198.15,57.63) 198.74,57.63 199.05,57.94 PU19.10
1658R-LGATE1: length 17.4
  IN2 w1.016: v3(200.59,63.09) 200.59,65.81 197.24,69.15 v3(197.24,72.99) v3(197.24,79.14)
1658R-LGATE2: length 16.6
  IN2 w1.016: v3(199.19,63.04) 199.19,63.24 194.62,67.81 192.06,67.81 v3(191.57,68.3) 191.57,74.09 v3(192.23,74.75)
  vias: v1(192.39,68.47)
1658R-OCS/CB: length 6.2
  BOTTOM w0.203: PU19.9 199.45,57.74 PR275.2
  BOTTOM w0.305: v1(196.35,55.7) 197.02,56.37 PR268.1 PR275.2
  BOTTOM w0.381: PR270.2 199.02,55.59 198.24,56.37 PR275.2
1658R-PG: length 10.1
  IN2 w0.254: v1(196.68,59.91) 194.06,59.91 v1(191.65,62.32)
  BOTTOM w0.203: PU19.13 197.11,60.14 196.88,59.91 v1(196.68,59.91)
  BOTTOM w0.254: v1(191.07,63.59) PR252.1 191.17,62.81 v1(191.65,62.32) PR259.1
1658R-PHASE1: length 15.1
  TOP w0.762: PR89.1 198.61,78.18 v1(198.94,78.51) 199.47,79.04 199.47,79.75 v3(199.42,79.8)
  IN2 w1.016: v3(200.49,73.3) 200.49,70.1 202.49,68.09 202.49,63.32 v3(201.61,62.43)
1658R-PHASE2: length 20
  TOP w0.762: PR91.1 v1(187.31,71.6) 186.21,71.6 v3(186.19,71.57)
  IN2 w1.016: v3(188.68,74.42) 188.68,68.3 191.01,65.96 193.53,65.96 196.96,62.53 v3(198.05,62.53)
1658R-PSI: length 3.2
  BOTTOM w0.203: v1(203.92,60.32) 203.76,60.16 PR255.2 203.13,59.58 202.97,59.74 PU19.4
1658R-PVCC:
  vias: v1(201.3,64.61)
1658R-REFADJ: length 4
  BOTTOM w0.203: PU19.6 200.65,57.82 200.84,57.63 202.39,57.63 202.47,57.55 v1(202.89,57.55) PR106.1
1658R-REFIN: length 5.3
  BOTTOM w0.203: PU19.7 200.25,57.63 200.67,57.22 201.28,57.22 v1(201.37,57.14) PR115.2
  BOTTOM w0.381: PR115.2 PC178.2 PR114.1
1658R-UGATE1: length 20.6
  IN2 w1.016: v3(205.85,80.06) 205.8,80 v3(205.8,73.35) 204.25,71.8 204.25,62.94 202.67,61.36 v3(202.67,60.8)
1658R-UGATE2: length 21.7
  IN2 w1.016: v3(184.69,74.73) 184.69,68.76 184.99,68.47 v3(184.99,68.49) 185.04,68.44 185.86,68.44 190.35,63.95 192.59,63.95 195.69,60.85 196.98,60.85 v3(197.06,60.78)
  vias: v1(184.23,68.42)
1658R-VID: length 2.7
  BOTTOM w0.203: PR256.2 203.76,58.57 203.18,58.57 v1(202.77,58.97) 202.41,59.34 PU19.5
1658R-VREF: length 4
  BOTTOM w0.203: PU19.8 v1(199.85,57.12) 199.85,56.52 PR113.1
  BOTTOM w0.305: PC206.2 PR113.1 PR270.1
24780_ACDET: length 3.1
  TOP w0.178: PR3.2 155.69,184.8 v1(155.78,184.7) 155.92,184.56 PU5.6
  TOP w0.381: PR3.2 155.69,186.26 PR168.2
24780_ACDRV: length 3.2
  TOP w0.178: PU5.4 156.72,185.44 157.61,186.33 PR165.2
24780_ACN: length 73
  TOP w0.178: PU5.1 157.92,184.33 v1(158.35,184.75)
  TOP w0.203: v1(158.35,184.75) 158.35,184.93 159.87,186.46 160.11,186.46 PC5.2
  TOP w0.305: PC2.1 161.59,186.35 160.6,186.35 PC5.2
  IN2 w0.203: v1(158.35,184.75) 158.17,184.58 156.72,184.58 155.15,183 155.15,178.81 158.65,175.31 176.74,175.31 179.79,178.35 189.88,178.35 193.08,181.55 195.94,181.55 200.11,185.72 205.37,185.72 v1(206.23,184.86)
  BOTTOM w0.254: v1(206.23,184.86) 206.23,184.63 206.74,184.12 207.52,184.12 PR209.2
24780_ACP: length 74.5
  TOP w0.178: v1(157.79,185.11) 157.52,184.84 PU5.2
  TOP w0.203: v1(157.79,185.11) 157.94,185.11 159.7,186.86 159.91,186.86 PC5.1
  TOP w0.305: PC115.2 161.92,187.41 161.78,187.27 160.5,187.27 PC5.1
  IN2 w0.203: v1(157.79,185.11) 157.64,184.96 156.57,184.96 154.79,183.18 154.79,178.58 158.5,174.87 176.84,174.87 179.94,177.97 189.99,177.97 193.22,181.2 196.15,181.2 200.29,185.34 205.03,185.34 206.03,184.35 206.48,184.35 206.89,184.75 v1(206.89,184.8)
  BOTTOM w0.254: PR210.2 207.17,185.16 206.89,184.88 v1(206.89,184.8)
24780_BATDRV: length 11.8
  TOP w0.178: 156.44,178.43 156.72,178.72 PU5.18
  TOP w0.203: PR185.2 156.57,170.22 156.57,171.34 v1(156.38,171.53) 155.96,171.95 155.96,172.16 155.3,172.82 155.3,174.52 155.96,175.18 155.96,177.96 156.44,178.43
24780_BATSRC: length 3.4
  TOP w0.178: PR186.2 155.5,177.07 155.5,178.2 v1(155.94,178.63) 156.32,179.02 PU5.17
24780_BM#: length 3.6
  TOP w0.178: PR16.1 154.29,177.02 154.9,177.62 v1(154.9,177.9) 154.9,178.26 155.74,179.1 155.82,179.1 155.92,179.2 PU5.16
24780_CMPIN: length 3.5
  TOP w0.178: PR11.2 151.84,181.15 152.53,180.46 v1(152.61,180.46) 153.57,180.46 154.02,180.91 PU5.13
24780_CMPOUT: length 8
  TOP w0.178: PR179.1 152.08,180.31 152.51,179.88 153.5,179.88 154.13,180.51 PU5.14
  TOP w0.203: PR179.1 151.86,179.33 v1(151.85,179.32) 151.85,178.86 151.91,178.8 151.91,178.04 152.58,177.36 PQ40.2
24780_CMSRC: length 3.5
  TOP w0.178: PU5.3 157.12,185.11 157.6,185.58 157.63,185.58 v1(157.85,185.79) PR166.2
24780_DH: length 8.8
  IN1 w0.889: v3(167.95,184.25) 167.37,183.66 162.19,183.66 160.76,182.24 v3(160.03,182.24)
24780_DL: length 9.9
  IN1 w0.889: v3(159.92,180.66) 161.63,180.66 162.59,179.7 166.91,179.7 168.18,178.43 v3(168.92,178.43)
24780_ILIM: length 4.7
  TOP w0.178: PU5.21 157.92,178.96 v1(158.5,178.38) 158.6,178.28 159.22,178.28 PC123.2
  TOP w0.381: PC123.2 159.24,177.77 159.37,177.64 159.37,177.04 PR14.1 160.36,176.97 PR15.2
24780_LX: length 14
  IN2 w0.889: v3(173.21,181.48) 171.08,181.48 170.29,182.26 162.24,182.26 161.27,183.23 v3(159.9,183.23)
  vias: v1(173.31,179.62) v3(169.42,183.26) v3(170.29,183.23) v3(173.51,180.51) v3(174.28,181.48) v3(174.63,180.56) v3(175.19,181.45)
24780_SRN: length 13.6
  TOP w0.203: PC132.2 155.82,174.06 156.5,174.06 156.67,173.88 PC131.1 ; v1(157.05,175.43) 157.05,175.8 PR184.2
  TOP w0.381: PC132.2 155.81,174.34 v1(156.34,174.87) 156.9,175.43 v1(157.05,175.43)
  BOTTOM w0.203: PR175.1 165.33,176.98 165.03,176.98 164.73,176.68 157.94,176.68 157.05,175.79 v1(157.05,175.43)
24780_SRP: length 15.9
  TOP w0.203: v1(157.18,174.77) 157.28,174.77 157.54,175.03 157.54,175.8 PR183.2
  TOP w0.381: PC130.2 158.72,174.28 v1(158.32,173.88) PC131.2 157.6,174.14 157.18,174.56 v1(157.18,174.77)
  BOTTOM w0.203: v1(157.18,174.77) 156.93,174.77 156.55,175.15 156.55,175.84 157.74,177.03 164.5,177.03 164.85,177.39 165.33,177.39 PR176.1
24780_VCC: length 41.6
  TOP w0.178: v1(159.87,184.22) 159.26,183.61 159.26,183.05 159.12,182.91 PU5.28
  TOP w0.305: PC116.2 160.25,184.6 v1(159.87,184.22)
  TOP w0.381: v1(187.92,179.85) 189.41,181.35 v1(191.88,181.35) PR5.1
  IN2 w0.305: v1(159.87,184.22) 159.87,184.98 161.19,186.3 166.4,186.3 167.86,184.84 176.02,184.84 176.68,184.19 176.68,183.01 179.26,180.42 184.11,180.42 184.86,179.67 187.74,179.67 v1(187.92,179.85)
25810_AUO#: length 2.7
  TOP w0.127: U28.17 31.31,106.4 31.06,106.14 v1(30.38,106.14) 30.38,104.96 R11197.2
25810_CC1: length 29.4
  TOP w0.254: v1(17.63,114.9) 17.87,114.66 20.49,114.66 21.27,115.44 23.65,115.44 27.84,111.25 v1(28.28,111.25) 29.55,111.25 30.03,110.76 30.03,110.13 ; v1(10.34,119.22) 10.34,118.85 11.14,118.06 12.13,118.06 13.43,116.76 13.43,115.77 14.19,115.01 v1(14.64,115.01) 14.94,114.7 15.46,114.7 U4513.5
  IN2 w0.254: v1(17.63,114.9) 17.53,115.01 v1(14.64,115.01)
  BOTTOM w0.254: v1(10.34,119.22) 10.22,119.1 8.12,119.1 8.06,119.15 CN2021.A5
25810_CC2: length 33.9
  TOP w0.254: 29.42,109.09 29.65,108.86 ; v1(13.72,114.6) 13.72,114.55 13.99,114.28 14.71,114.29 15.8,114.28 16.02,114.5 16.02,114.99 16.13,115.1 U4513.6 16.8,115.1 17.07,114.83 v1(17.07,114.28) 20.65,114.28 21.4,115.03 23.51,115.03 27.81,110.74 29.05,110.74 29.42,110.36 29.42,109.39
  IN2 w0.127: 6.82,120.78 6.82,120.78 5.33,120.78 CN2021.B5
  IN2 w0.254: 6.82,120.78 7.96,120.78 8.39,120.34 8.74,120.34 8.86,120.23 10.03,120.23 10.39,119.86 12.1,119.86 13.49,118.46 13.49,114.83 v1(13.72,114.6)
25810_DBG#: length 3.9
  TOP w0.127: R11194.2 29.11,105.34 v1(29.11,106.34) 29.11,106.57 29.9,107.35 U28.16
25810_FAULT#: length 5.3
  TOP w0.127: 34.09,104.8 34.56,104.34 34.56,103.36 R11281.2 ; 34.09,104.8 R11206.2 ; 34.09,104.8 v1(34.09,106.65) 34.09,107.08 33.82,107.35 U28.1
25810_LD_DET#: length 2.1
  TOP w0.127: U28.20 32.81,105.82 v1(33.03,105.61) 33.2,105.43 R11208.2
25810_POL#: length 2.1
  TOP w0.127: U28.18 31.81,106.7 31.81,106.37 31.55,106.12 v1(31.55,105.53) 31.55,104.93 R11203.2
25810_REF: length 1.3
  TOP w0.127: R11204.1 31.31,111.53 U28.10
25810_REF_RTN: length 1.2
  TOP w0.127: R11204.2 31.81,111.6 U28.9
25810_UFP#: length 12
  TOP w0.127: R11193.2 v1(32.31,105.43) 32.31,105.43 U28.19 ; R11252.2 v1(28.78,101.61) 28.51,101.61 v1(27.23,102.89) Q15.2
  BOTTOM w0.127: v1(32.31,105.43) 29.77,102.89 v1(27.23,102.89)
25810_UFP#_G1: length 5.1
  TOP w0.381: Q17.2 v1(24.06,105.18) 24.31,104.92 Q15.3 25.2,102.5 R11201.1
25810_UFP#_G2: length 5.8
  TOP w0.508: Q6062.4 20.25,110.3 20.07,110.12 R11195.1 20.38,109.23 v1(20.38,108.99) 20.38,107.97 20.88,107.46 Q17.3
51225_CS1: length 2.7
  TOP w0.203: PR6124.1 55.15,36.34 v1(54.77,36.77) 54.77,37.51 54.35,37.93 PU6010.1
51225_CS2: length 2.8
  TOP w0.203: PU6010.5 54.15,39.53 54.29,39.67 54.29,40.28 53.83,40.74 v1(53.83,41.07) 54.43,41.07 PR6122.2
51225_DH1: length 7.3
  IN1 w1.016: v3(51.11,36.44) 52.46,36.44 54.01,34.89 56.6,34.89 57.36,34.13 v3(57.36,34.18)
51225_DH2: length 12.6
  TOP w0.203: PU6010.10 51.61,40.6 51.21,40.99 v3(51.21,41.07)
  IN1 w1.016: v3(62.58,41.69) 61.96,41.07 v3(51.21,41.07)
51225_DL1: length 15.9
  IN1 w1.016: v3(50.17,37.15) 49.5,36.48 49.5,33.72 50.58,32.64 50.58,30.38 53.86,27.1 v3(57.66,27.1)
51225_DL2: length 18.1
  TOP w0.203: v3(50.25,40.33) 50.55,40.33 50.91,39.98 PU6010.11
  IN1 w1.016: v3(50.25,40.33) 49.74,40.84 49.74,46.25 53.6,50.11 58.48,50.11 v3(58.76,49.83)
51225_EN1: length 1.7
  TOP w0.203: PU6010.20 v1(53.21,36.24) 53.21,35.55 PR6278.1
51225_FB1: length 2.7
  TOP w0.203: PR6281.1 55.55,38 55.52,38.03 PR6120.1 55.17,38.37 55.05,38.25 54.5,38.25 54.42,38.33 PU6010.2
51225_FB2: length 3.9
  TOP w0.203: v1(54.77,39.92) 54.77,39.49 54.41,39.13 PU6010.4
  TOP w0.381: v1(54.77,39.92) 55.15,39.92 55.52,39.55 PR6121.1
  BOTTOM w0.381: PR6279.2 55.15,40.81 54.74,40.41 54.74,39.95 v1(54.77,39.92)
51225_SW1: length 13.6
  IN1 w1.016: v3(52.3,34.87) 52.28,34.84 52.28,33.45 55.43,30.3 62.36,30.3 v3(62.92,29.74)
  vias: v1(66.05,27.6)
51225_SW2: length 14.4
  TOP w0.762: PR6289.1 65.13,49.07 v3(65.82,49.75)
  IN1 w1.016: v3(52.53,42.41) 52.53,44.06 54.51,46.04 v3(62.46,46.04)
  vias: v1(65.5,42.5)
51225_VBST1:
  vias: v1(51.85,35.96)
51225_VIN: length 3.3
  TOP w0.203: PU6010.12 50.43,39.13 50.23,39.33 v1(49.92,39.33) PC6100.2
  TOP w0.508: PC6100.2 49.19,39.78 48.82,40.15 PR6130.2
+AZA_VDD: length 14.4
  TOP w0.508: v1(201.94,27.86) 201.53,28.26 v1(201.53,28.65) 201.58,28.65 203.46,30.53 203.46,34.82 202.72,35.55 v1(202.14,35.55) 201.76,35.55 v1(201.45,35.86)
  BOTTOM w0.203: v1(201.53,28.65) 201.76,28.87 202.06,28.87 202.2,29.01 U23.36
  BOTTOM w0.508: C527.1 201.4,27.32 v1(201.94,27.86) ; R372.1 199.28,40.42 199.77,39.93 R367.1
+G_SEN_PW: length 44.2
  BOTTOM w0.203: U19.1 219.02,61.56 C412.1 R318.2
  BOTTOM w0.254: 226.9,58.95 226.9,55.32 226.6,55.01 224.82,55.01 v1(224.54,55.29) 224.54,56.02 C428.1 224.02,56.54 U19.8 ; 226.9,58.95 226.9,61.64 225.86,62.68 223.6,62.68 223.39,62.89 R333.2 222.18,63.14 221.67,63.65 220.66,63.65 220.02,63.01 R318.2 218.82,63.94 218.38,64.38 216.38,64.38 214.56,62.55 214.56,57.04 215.25,56.36 217.76,56.36 217.95,56.54 U19.14 ; 226.9,58.95 R334.2
+TPVDD: length 10.3
  BOTTOM w0.381: R409.2 141.77,13.76 141.57,13.56 138.11,13.56 v1(136.84,12.29) ; 134.7,13.63 134.96,13.89 134.96,15.97 134.69,16.24 C783.1 R410.2
  vias: v1(135.29,11.25)
+TYPEC_VBUS:
  vias: v1(8.34,121.25) v1(8.67,118.43) v1(8.72,115.97) v1(9.11,115.36) v1(9.3,114.4) v1(9.45,116.4) v3(16.88,111.53) v3(17.41,112.24) v3(17.41,110.81) v3(17.66,111.53)
+TYPEC_VBUS_C:
  vias: v1(29.04,108.38)
+VGPU_CORE:
  vias: v1(175.54,116.65) v1(175.64,128.52) v1(175.6,119.94) v1(175.6,119.14) v1(175.6,118.34) v1(176.41,119.14) v1(176.41,118.34) v1(177.25,126.58) v1(177.23,120.74) v1(177.23,119.94) v1(177.23,119.14) v1(177.23,118.34) v1(177.27,137.31) v1(178.1,121.54) v1(178.1,120.74) v1(178.1,119.94) v1(178.1,119.14) v1(178.1,118.34) v1(178.21,136.49) v1(178.24,133.55) v1(178.15,129.48) v1(178.26,132.58) v1(178.92,124.04) v1(178.92,121.54) v1(178.92,120.74) v1(178.92,119.14) v1(178.92,118.34) v1(179.73,124.04) v1(179.73,123.24) v1(179.73,122.39) v1(179.73,121.54) v1(179.73,120.74) v1(179.73,119.94) v1(179.73,119.14) v1(179.73,118.34) v1(180.13,136.49) v1(180.22,132.61) v1(180.26,134.36) v1(180.55,124.04) v1(180.55,123.28) v1(180.55,122.39) v1(180.55,121.5) v1(180.55,120.74) v1(180.55,119.94) v1(180.55,119.14) v1(180.55,118.34) v1(180.73,124.97) v1(180.8,126.33) v1(180.8,125.62) v1(181.15,130.49) v1(181.15,128.43) v1(181.24,133.27) v1(181.2,132.4) v1(181.32,135.5) v1(181.39,124.95) v1(181.41,123.99) v1(181.43,123.24) v1(181.43,122.39) v1(181.43,121.54) v1(181.43,120.74) v1(181.43,119.94) v1(181.43,119.14) v1(181.43,118.34) v1(181.47,126.34) v1(181.49,125.68) v1(182.05,125.06) v1(182.18,126.34) v1(182.2,125.69) v1(182.23,123.24) v1(182.23,122.39) v1(182.23,121.54) v1(182.23,120.74) v1(182.23,119.94) v1(182.23,119.14) v1(182.23,118.34) v1(182.81,125.03) v1(182.86,125.69) v1(183.18,134.51) v1(183.19,130.4) v1(183.19,129.41) v1(184.22,134.45) v1(184.3,132.35) v1(185.21,134.49) v1(185.21,130.42) v1(185.27,137.48) v1(185.26,136.39) v1(185.3,128.38) v1(186.23,130.47) v1(186.15,126.51) v1(186.28,132.53) v1(187.24,136.39) v1(187.24,135.48) v1(187.2,132.58) v1(187.37,134.43) v1(202.62,97.25) v1(205.11,91.08) v3(185.1,94.51) v3(186.19,95.88) v3(186.72,98.98) v3(188.09,98.93) v3(189.39,92.96) v3(189.41,91.46) v3(189.41,90.06) v3(189.79,100.22) v3(189.79,98.9) v3(190.94,92.81) v3(190.91,91.49) v3(190.86,90.01) v3(190.99,99.74) v3(190.99,98.52) v3(190.99,97.07) v3(190.99,95.7) v3(190.96,94.18) v3(192.64,99.16) v3(192.64,96.49) v3(192.64,95.12) v3(192.61,93.59) v3(192.59,92.22) v3(192.56,90.9) v3(192.67,100.45) v3(192.67,97.86) v3(194.24,98.11) v3(194.24,95.45) v3(194.24,94.08) v3(194.21,92.55) v3(194.19,91.18) v3(194.16,89.86) v3(194.27,96.82) v3(195.38,93.11) v3(195.51,90.95) v3(195.84,94.25) v3(195.87,97.15) v3(195.87,95.78) v3(197.31,96.16) v3(197.31,94.79) v3(197.29,93.75) v3(198.71,96.16) v3(198.71,94.79) v3(198.81,93.75) v3(200.34,90.09) v3(200.44,95.6) v3(200.41,94.08) v3(200.39,92.7) v3(200.36,91.38) v3(201.2,90.9) v3(202.04,93.03) v3(202.01,91.66) v3(201.99,90.06) v3(202.06,95.93) v3(202.06,94.56) v3(203.03,91.18) v3(203.05,93.01) v3(203.26,90.06) v3(203.74,92.45) v3(203.79,99.38) v3(203.82,98.09) v3(203.79,96.72) v3(203.79,95.35) v3(203.76,93.82) v3(204.65,102) v3(204.91,98.06) v3(204.86,97.1) v3(204.91,96.11) v3(204.93,94.33) v3(204.93,92.96) v3(205.01,99.38)
+VREF_CA_CPU: length 138.8
  TOP w0.508: R10878.1 128.19,38.12 C1252.1 128.96,38.11 v1(129.08,37.99)
  IN1 w0.508: v2(102.95,103.26) 102.48,102.79 99.75,102.79 97.92,100.96 96.42,100.96 v1(95.69,100.22)
  IN2 w0.508: v1(118.95,38.73) v1(121.72,38.73)
  BOTTOM w0.254: U35.AY67 102.6,102.58 102.95,102.93 v2(102.95,103.26)
  BOTTOM w0.508: v1(121.72,38.73) 128.34,38.73 v1(129.08,37.99) ; v1(118.95,38.73) 96.7,38.73 94.67,40.76 89.62,40.76 89.13,41.24 81.64,41.24 79.41,43.48 79.41,47.42 78.54,48.28 78.54,59.07 81.11,61.64 81.11,66.11 76.71,70.5 76.71,73.32 80.32,76.93 80.32,85.26 77.98,89 77.98,91.84 78.04,91.9 78.04,91.91 78.27,92.13 78.27,92.37 80.32,94.42 80.56,94.42 85.59,99.46 94.92,99.46 v1(95.69,100.22)
+VREFDQ_SA_M3: length 7.3
  TOP w0.508: v2(101.28,102.18) 100.97,101.87 99.29,101.87 98.28,100.86 96.96,100.86 96.54,100.44 v1(96.54,100.11)
  BOTTOM w0.254: U35.AY68 101.33,102.13 v2(101.28,102.18)
  BOTTOM w0.508: v1(96.54,100.11) 96.35,100.3 TP4344.1
+VREFDQ_SB_M3: length 82.6
  TOP w0.508: v1(115.45,68.73) 115.7,68.73 116.34,68.09 v1(116.34,67.15) 116.34,65.58 116.63,65.28 C1329.1 116.63,64.43 116.42,64.22 R10932.1
  IN1 w0.508: v2(102,101.62) 101.83,101.62 100.82,100.6 99.29,100.6 98.8,100.11 v1(97.28,100.11)
  BOTTOM w0.305: v2(102,101.62) 102.12,101.74 U35.BA67
  BOTTOM w0.508: v1(115.45,68.73) v1(114.89,69.29) 102.62,81.55 85.01,81.55 81.08,85.48 78.62,89.27 v1(78.62,89.81) 78.62,91.59 78.93,91.9 78.93,92.13 80.59,93.79 80.82,93.79 85.85,98.82 96.5,98.82 97.28,99.6 v1(97.28,100.11)
+WL_VDD: length 23.6
  TOP w0.508: 178.62,176.42 v1(178.62,175.41) 181.03,175.41 181.54,175.91 196.88,175.91 197.29,175.51 v3(197.29,174.95) ; 178.62,176.42 R241.2 ; 178.62,176.42 R242.2
  BOTTOM w0.254: Q23.2 v1(178.62,175.41)
  BOTTOM w0.508: R714.2 201.78,182.14 202.04,181.88 v1(202.24,181.88)
  vias: v1(199.88,190.6) v3(197.29,174.01) v3(199.88,192.35) v3(199.85,191.59)
A_DE0: length 2.2
  TOP w0.127: U9.29 30.01,115.55 v1(29.95,115.49) 29.95,115.42 R11213.2
A_DE1: length 3.2
  TOP w0.127: R254.2 29.55,114.58 28.66,115.48 v1(28.66,115.51) 28.66,115.67 28.91,115.92 29.44,115.92 29.61,116.09 U9.28
A_EQ0: length 4.4
  TOP w0.127: U9.32 31.21,116.11 31.32,116 32.88,116 33.46,115.41 R258.2 34.16,114.58 v1(34.17,114.57)
A_EQ1: length 3.3
  TOP w0.127: U9.31 30.81,115.95 31.02,115.74 32.34,115.74 32.52,115.56 v1(32.52,115.31) 32.52,114.63 R11211.2
ACCEL_INT2: length 2.4
  BOTTOM w0.127: D35.1 224.32,52.78 224.59,53.05 R326.1 224.99,53.48 225.32,53.15 v1(225.32,53.13)
ACCEL_INT2_R: length 3.8
  BOTTOM w0.203: U19.9 v1(221.02,54.35) 221.02,53.17 221.7,52.5 D35.2
ACCEL_INTA: length 155
  TOP w0.127: v1(190.71,52.4) 190.71,52.14 191.19,51.66 191.19,51.3 191.12,51.23 191.12,50.92 191.42,50.62 192.49,50.62 194.34,48.76 194.34,48.74 196.94,46.13 207.67,46.13 208.32,46.78 v1(210.37,46.78) 211.16,46.78 214.94,50.57 v1(214.94,51.96)
  IN1 w0.14: v1(190.71,52.4) 190.36,52.4 188.96,51 183.62,51 182.99,50.37 178.82,50.37 177.73,51.45 177.73,53.11 177.7,53.14 177.7,53.15 176.59,54.25 176.59,54.25 176.16,54.69 176.15,54.69 175.21,55.63 175.21,55.83 174.62,56.42 174.62,60.82 174.22,61.22 174.22,64.05 173.66,64.61 173.66,64.61 173.23,65.04 173.23,65.86 169.21,69.87 169.21,70.38 169.21,70.38 169.21,71.44 168.42,72.23 168.42,74.98 168.06,75.34 168.06,76.92 168.06,80.15 166.81,81.4 166.81,81.53 165.8,82.53 165.8,82.56 165.5,82.86 165.47,82.86 164.18,84.16 164.18,90.47 166.01,92.3 166.01,95.76 167.32,97.07 167.32,108.8 163.52,112.59 160.86,112.59 160.46,112.19 160.46,107.13 160.16,106.83 158.62,106.83 157.69,107.77 157.69,110.13 156.67,111.14 153.22,111.14 151.8,109.72 148.61,109.72 147.67,110.66 144.18,110.66 143.73,111.1 142.79,111.1 v1(142.08,111.82)
  BOTTOM w0.076: v1(142.08,111.82) 141.65,112.25 U35.AB1
  BOTTOM w0.127: v1(214.94,51.96) 215.83,51.96 218.25,49.55 D8.1 219.84,48.97 219.61,48.74 C425.2
ACCEL_INTA_R: length 3.4
  BOTTOM w0.203: D8.2 219.84,52.7 220.02,52.88 U19.11
ACIN: length 320.1
  TOP w0.305: PR1.2 162.11,180.61 162.41,180.92 162.46,180.92 v1(162.52,180.97) ; v1(156.88,187.9) 156.72,187.9 156.39,187.57 PR167.1
  IN2 w0.14: v1(176.65,29.93) 176.72,29.93 176.99,30.2 180.52,30.2 180.99,29.73 184.67,29.73 185.08,30.14 185.08,31.45 185.4,31.77 185.93,31.77 188.08,33.92 190.26,33.92 194.38,38.05 200.56,38.05 200.7,37.9 205.55,37.9 205.83,38.19 207.29,38.19 209.15,40.05 214.01,40.05 216.08,42.12 216.08,50.85 216.24,51 216.24,52.5 215.51,53.23 215.51,55.48 214.64,56.35 214.64,58.02 215.27,58.64 215.27,59.64 218.7,63.07 218.7,67.1 221.05,69.45 221.05,86.82 218.59,89.28 218.59,95.24 222.81,99.46 227.41,99.46 229.22,101.26 229.22,105.15 230.46,106.39 230.46,111.68 228.46,113.67 228.46,159.17 225.52,162.11 225.52,166.58 232.53,173.59 232.53,188.8 229.41,191.92 211.31,191.92 209.89,190.49 206.8,190.49 206,191.29 202.67,191.29 194.4,183.03 192.47,183.03 190.1,180.66 187.46,180.66 187.18,180.39 185.17,180.39 184.49,181.06 179.54,181.06 177.32,183.28 177.32,184.51 176.31,185.52 168.2,185.52 165.03,188.69 157.66,188.69 v1(156.88,187.9) ; v1(162.52,180.97) 161.88,180.97 161.42,181.43 159.59,181.43 158.69,182.33 158.69,183.81 159.26,184.38 159.26,186.04 160.06,186.85 160.06,187.41 159.65,187.83 v1(159.24,187.83)
  BOTTOM w0.127: v1(159.24,187.83) v1(158.04,187.83) 156.95,187.83 v1(156.88,187.9) ; U45.72 173.11,31.8 175.21,29.7 176.43,29.7 v1(176.65,29.93)
  BOTTOM w0.305: v1(162.52,180.97) 163.48,181.93 PR4.1
ACZ_SDIN: length 2.5
  BOTTOM w0.114: U23.8 205,36.19 204.94,36.26 204.94,37.12 R359.1
ADOGND: length 30
  TOP w0.508: v1(211.11,34.06) 211.12,34.04 R394.1 ; R400.1 207.23,29.98 207.09,29.84 v1(207.09,28.54) ; C538.1 v1(207.2,34.01) 207.27,34.01 207.85,34.59 v1(207.85,35.12) ; R375.1 v1(208.51,35.07)
  BOTTOM w0.178: CN2020.26 211.81,10.15 212.01,10.35 212.01,10.95 211.82,11.15 CN2020.24
  BOTTOM w0.203: v1(200.59,29.15) 200.4,29.34 200.4,30.26 200.75,30.6 U23.38 ; v1(207.09,28.54) 207.07,28.52 206.71,28.52 206.6,28.63 U23.25
  BOTTOM w0.305: C553.2 208.38,11.75 208.84,12.21 209.94,12.21 210,12.15 CN2020.22 ; v1(209.4,15.79) 209.55,15.65 CN2020.15 ; v1(209.78,11.12) 209.81,11.15 CN2020.24
  BOTTOM w0.381: C550.2 209.69,11.12 v1(209.78,11.12) ; C553.2 208.31,11.7 207.91,12.11 v1(207.91,12.21) ; C547.2 209.36,15.75 v1(209.4,15.79) ; v1(209.96,13.76) 209.81,13.61 C554.2 ; R417.2 204.98,10.64 v1(204.52,11.09) ; C535.1 v1(205.54,25.95)
  BOTTOM w0.508: R390.1 209.29,20.99 v1(209.29,20.41) ; v1(211.11,34.06) 211.11,33.31 C537.1 ; R423.2 v1(204.27,11.7) ; R401.2 v1(209.93,29.47) ; C529.1 199.26,27.18 v1(198.81,27.63) 198.66,27.78 C524.2 C520.2 ; C519.2 210.9,32.13 v1(211,32.02) ; R375.1 v1(208.51,35.07)
  vias: v1(207.8,25.78) v1(208.18,26.41) v1(208.26,25.24) v1(208.29,24.58) v1(208.26,23.92)
AMP_MUTE#: length 25
  TOP w0.127: v1(179.05,47.59) 179.16,47.71 180,47.71 180.01,47.69 180.29,47.96 181.43,47.96 181.91,48.44 182.43,48.44 182.7,48.71 182.7,49.64 183.34,50.29 187.94,50.29 188.68,49.55 189.19,49.55 189.44,49.3 190.28,49.3 v1(190.51,49.07) v1(191.04,48.53)
  BOTTOM w0.127: v1(191.04,48.53) 191.04,47.67 193.3,45.41 D16.1 ; v1(179.05,47.59) 178.85,47.59 177.64,46.39 177.64,44.71 177.63,44.7 177.63,44.14 177.58,44.09 U45.108
APS1: length 6
  TOP w0.305: R289.2 167.22,100.59 166.93,100.3 R291.2 167.35,99.55 167.82,99.08 167.82,97.81 167.13,97.12 CN2.1
APS3: length 5.2
  TOP w0.305: CN2.3 168.13,97.23 168.62,97.72 R272.2 R278.1 168.62,100.22 168.42,100.41 R289.1
APS7: length 4.6
  TOP w0.305: CN2.7 170.13,97.18 169.82,97.49 R272.1 171.34,98.19 R271.1 v1(172.28,98.23)
AUX_CH_N: length 3.1
  TOP w0.114: U13.3 26.43,67.75 26.5,67.67 26.64,67.67 26.98,67.33 26.98,66.49 27.2,66.28 27.45,66.28 27.45,66.27 27.61,66.43 C343.2
AUX_CH_P: length 3.2
  TOP w0.114: C341.2 27.61,65.81 27.36,66.06 27.11,66.06 26.76,66.4 26.76,67.24 26.55,67.46 26.46,67.46 26.35,67.35 U13.2
B_DE0: length 1.9
  TOP w0.127: U9.15 30.01,123.15 29.9,123.26 v1(29.9,123.49) R11214.2
B_DE1: length 3.2
  TOP w0.127: R203.2 28.35,123.56 28.35,123.11 28.5,122.96 v1(28.66,122.96) 29.55,122.96 29.61,122.89 U9.16
B_EQ0: length 4.1
  TOP w0.127: U9.13 30.81,122.75 31.06,122.99 32.38,122.99 32.62,123.24 v1(32.62,123.59) 32.62,123.95 32.35,124.22 R206.2
B_EQ1: length 2.3
  TOP w0.127: U9.14 30.41,122.75 30.97,123.31 31.04,123.31 v1(31.17,123.44) 31.17,123.84 R11212.2
BAT-V: length 7.9
  TOP w0.508: PC126.1 159.01,172.64 159.39,173.02 159.39,173.1 v1(159.42,173.12) v1(160.04,173.74) 160.48,174.19 PC125.2
  BOTTOM w0.152: PR169.2 167.9,174.21 168.15,174.47 168.15,176.5 167.62,177.03 166.72,177.03 PR175.2
BATLED0#: length 156.5
  TOP w0.127: R428.1 R430.1 58.32,19.22 58.07,18.97 58.07,15.87 59.01,14.93 59.26,14.93 v1(61.7,12.49) v1(62.67,11.53)
  IN2 w0.14: v1(62.67,11.53) 63.23,10.97 66.41,10.97 71.58,16.14 71.58,17.73 73.71,19.85 77.4,19.85 78.84,21.29 82.11,21.29 89.62,28.8 102.66,28.8 112.94,18.51 120.48,18.51 121.38,19.41 124.89,19.41 126.93,21.46 134.93,21.46 135.62,22.14 139.22,22.14 141.46,19.91 157.94,19.91 163.35,25.32 169.27,25.32 175.52,31.57 181.73,31.57 182.36,30.93 183.47,30.93 184,30.4 v1(184.61,30.4)
  BOTTOM w0.127: v1(184.61,30.4) 184.81,30.2 U45.29
BATLED1#: length 153.7
  TOP w0.127: v1(65.28,11.93) 65.28,12.53 61.25,16.57 v1(61.25,18.18) 61.25,19.76 60.66,20.34 R429.1 R431.1
  IN2 w0.14: v1(65.28,11.93) 66.58,11.93 71.02,16.37 71.02,17.96 73.48,20.41 77.17,20.41 78.61,21.85 81.88,21.85 89.39,29.36 102.89,29.36 112.06,20.19 124.78,20.19 126.61,22.02 134.68,22.02 135.36,22.7 139.6,22.7 141.74,20.57 151.78,20.57 152.72,21.51 153.2,21.51 158.75,21.51 163.12,25.88 169.04,25.88 175.29,32.13 181.96,32.13 182.54,31.54 184.56,31.54 185.27,32.25 v1(185.38,32.25)
  BOTTOM w0.127: U45.25 185.83,31.8 v1(185.38,32.25)
BEEP_1: length 3.8
  BOTTOM w0.102: 206.69,38.51 C476.2 206.64,39.11 206.69,39.16
  BOTTOM w0.127: 206.69,39.16 v1(206.79,39.26) ; R352.1 C477.1 R354.2 206.69,38.51
BI: length 192.7
  TOP w0.127: PR10.2 157.18,170.92 v1(157.18,171.52)
  IN2 w0.14: v1(157.18,171.52) 157.18,171.98 159.4,174.2 179.2,174.2 181.04,176.04 188.89,176.04 193.44,180.59 196.64,180.59 200.68,184.63 203.21,184.63 203.79,184.04 205.31,184.04 205.8,183.56 207.02,183.56 209.76,186.3 209.76,186.33 212.58,189.15 228.38,189.15 231.35,186.18 231.35,182.28 231.36,182.27 231.36,181.85 231.35,181.84 231.35,173.99 224.19,166.83 224.19,161.62 227.25,158.56 227.25,113.3 228.4,112.14 228.4,109.32 227.68,108.59 227.68,108.32 223.91,104.54 223.91,102.36 220.22,98.67 v1(219.49,98.67)
  BOTTOM w0.127: R11282.1 218.15,90.29 SW4.1 SW4.2 218.15,94.69 219.49,96.03 v1(219.49,98.67) ; PJ1.6 156.55,172.91 157.18,172.28 v1(157.18,171.52)
BI_GATE: length 73.6
  TOP w0.127: v1(218.57,66.77) 218.79,66.98 C765.1 219.12,68.17 R719.2 218.27,69.11 v1(218.22,69.16)
  IN1 w0.14: v1(230.77,118.8) 229.77,117.8 229.77,113.71 229.39,113.33 229.39,105.91 228.25,104.77 228.25,100.76 227.11,99.61 222.41,99.61 218.32,95.52 218.32,88.97 219.82,87.47 219.82,70.76 v1(218.22,69.16)
  BOTTOM w0.127: v1(230.77,118.8) SW1.4 229.67,119.32 229.67,123.46 229.15,123.99 SW1.3 ; Q40.2 217.91,68.85 v1(218.22,69.16) 218.22,69.54 218.75,70.07 Q56.5
BL#: length 4.1
  TOP w0.127: Q3.2 114.36,152.05 R52.1 114.91,151.91 v1(115.31,152.31) 115.31,152.55 115.01,152.85 Q3.3
BL_ON: length 27.2
  TOP w0.127: Q4.3 111.92,157.78 v1(111.77,157.63) 111.77,156.46 111.66,156.36 R58.1 111.18,156.35 D1.2 111.69,154.88 v1(112.4,155.6) 112.4,156.28 112.76,156.64 113.37,156.64 113.71,156.3 Q3.6
  IN1 w0.14: v1(120.15,171.47) 120.15,170.68 113.19,163.72 113.19,160.07 111.74,158.62 111.74,157.65 v1(111.77,157.63)
  BOTTOM w0.127: CN5.26 120.51,171.5 120.17,171.5 v1(120.15,171.47)
BOARD_ID0: length 13
  TOP w0.127: v2(144.84,105.73) 145.55,106.45 146.01,106.45 v1(146.23,106.22) 146.56,106.22 147.86,104.92 R595.2 148.77,104.41 149.92,104.41 150.29,104.79 R600.1
  BOTTOM w0.076: 143.44,106.01 141.76,106.01 141.29,106.49 140.74,106.49 140.65,106.52 140.59,106.55 140.39,106.55 140.3,106.51 140.03,106.51 139.95,106.55 139.73,106.55 139.6,106.49 139.4,106.28 U35.AN3
  BOTTOM w0.079: v2(144.84,105.73) 144.2,105.73 143.92,106.01 143.44,106.01
BOARD_ID1: length 12.3
  TOP w0.127: v2(144.49,105.21) 144.41,105.3 144.41,106.01 145.09,106.7 146.74,106.7 v1(147.5,105.94) R598.2 148.32,105.94 148.82,106.45 149.92,106.45 150.29,106.07 R599.1
  BOTTOM w0.076: 143.36,105.82 141.72,105.82 141.26,106.29 140.5,106.29 U35.AN1
  BOTTOM w0.079: 144.15,105.56 143.88,105.82 143.36,105.82
  BOTTOM w0.127: v2(144.49,105.21) 144.15,105.56
BOARD_ID2: length 13.6
  BOTTOM w0.076: 143.44,105.63 141.59,105.63 141.15,106.07 140.72,106.07 140.6,106.01 140.38,106.01 140.3,106.05 140.07,106.05 U35.AN2
  BOTTOM w0.079: 143.77,105.33 143.47,105.63 143.44,105.63
  BOTTOM w0.127: R608.1 R605.2 151.01,105.05 150.55,105.51 149.66,105.51 149,104.85 145.9,104.85 145.77,104.71 144.39,104.71 143.77,105.33
BOARD_ID3: length 10.7
  BOTTOM w0.076: U35.AM4 139.18,106.62 139.51,106.62 139.69,106.71 139.98,106.71 140.06,106.68 140.27,106.68 140.36,106.71 140.62,106.71 140.71,106.68 140.77,106.65 141.06,106.65 141.15,106.74 141.44,106.74 141.98,106.2 143.44,106.2
  BOTTOM w0.079: 143.44,106.2 143.84,106.2 143.87,106.24 144.1,106.24 144.13,106.22
  BOTTOM w0.127: 144.13,106.22 145.07,106.22 145.27,106.01 145.27,105.51 145.68,105.1 146.67,105.1 147.12,105.56 R592.2 R590.1
BOARD_ID4: length 146.3
  TOP w0.127: v1(151.57,108) 151.59,107.97 R593.1
  IN1 w0.14: v1(131.58,177.79) 131.88,177.79 132.26,177.41 132.26,176.83 132.01,176.58 130.94,176.58 128.58,174.21 128.58,173.86 129.27,173.17 130.64,173.17 131.34,172.47 131.34,171.53 132.52,170.35 132.52,168.88 131.15,167.51 127.56,167.51 124.47,164.41 118.64,164.41 117.79,163.56 117.78,163.56 117.73,163.51 116.18,163.51 115.4,162.73 115.4,159.44 115.68,159.17 115.68,158.27 116.52,157.44 116.52,155.29 115.47,154.25 115.47,148.64 118.85,145.26 123.17,145.26 126.4,142.03 126.4,140.23 127.54,139.08 137.62,139.08 137.9,139.36 149.87,139.36 150.42,138.81 v1(150.42,137.64)
  BOTTOM w0.076: 141.3,106.94 U35.AM1
  BOTTOM w0.079: 141.61,107.26 141.3,106.94
  BOTTOM w0.127: v1(131.58,177.79) 131.58,178.14 R441.1 132.32,178.89 C803.2 133.27,179.39 v1(133.51,179.62) ; 141.61,107.26 143.17,107.26 143.35,107.08 146.61,107.08 147,107.46 147,107.97 147.25,108.22 147.76,108.22 148.22,107.77 151.36,107.77 151.57,107.97 v1(151.57,108) 151.59,107.97 152.3,107.97 153.09,108.76 158.02,108.76 159.81,110.55 159.81,119.31 154.44,124.68 154.44,130.4 150.3,134.54 150.3,137.51 v1(150.42,137.64)
BOARD_ID4_TOUCH_S: length 2.3
  BOTTOM w0.127: CN5.2 130.27,178.71 v1(130.79,178.71) 131.37,178.71 R441.2
BOARD_ID5: length 11.3
  TOP w0.127: v1(144.48,107.84) 144.94,107.39 146.67,107.39 v1(146.79,107.51) 147.76,108.48 148.65,108.48 149.04,108.09 R606.2 R607.1
  BOTTOM w0.076: U35.AM2 140.39,107.17 140.63,107.17 140.71,107.21 141.25,107.21 141.42,107.39
  BOTTOM w0.079: 141.46,107.42 141.42,107.39
  BOTTOM w0.127: v1(144.48,107.84) 144.06,107.42 143.45,107.42 143.34,107.54 141.57,107.54 141.46,107.42
BOARD_ID6: length 11.9
  TOP w0.127: v1(143.82,107.84) v1(144.51,107.16) 144.71,106.95 147.33,106.95 147.83,106.45 148.45,106.45 148.96,106.95 R764.2 R765.1
  BOTTOM w0.076: 141.16,107.58 140.98,107.4 140.72,107.4 140.6,107.34 140.18,107.34 140.05,107.21 139.78,107.21 U35.AM3
  BOTTOM w0.079: 141.16,107.58 141.37,107.79 143.31,107.79 143.37,107.84 v1(143.82,107.84)
BOARD_ID7: length 15
  BOTTOM w0.076: 143.38,105.37 143.27,105.47 141.52,105.47 141.1,105.89 140.71,105.89 140.63,105.85 140.35,105.85 140.26,105.88 140.06,105.88 140.01,105.86 139.95,105.83 139.73,105.83 139.62,105.88 139.13,105.88 U35.AP4
  BOTTOM w0.079: 143.62,105.13 143.38,105.37
  BOTTOM w0.127: 143.62,105.13 144.29,104.45 145.89,104.45 146.03,104.59 147.33,104.59 147.5,104.41 149.49,104.41 149.79,104.11 149.79,103.91 150.04,103.65 150.81,103.65 151.07,103.91 R766.2 R767.1
BT_EN: length 226.5
  IN2 w0.14: v1(202.24,178.45) 202.11,178.45 201.48,179.09 201.48,180.94 201.94,181.4 204.45,181.4 204.99,180.86 204.99,174.86 205.58,174.28 205.58,170.22 206.03,169.77 206.03,166.7 207,165.73 207,164.34 207.44,163.9 207.44,162.79 208.97,161.26 215.02,161.26 215.97,160.3 220.47,160.3 225.35,155.42 225.35,142.03 224.92,141.6 224.92,119.3 225.35,118.87 225.35,112.36 225.66,112.06 225.66,109.32 224.91,108.57 222.74,108.57 217.99,103.82 217.99,103.5 215.12,100.63 215.02,100.63 213.52,99.13 213.52,90.01 218.29,85.24 218.29,75.93 217.91,75.55 217.91,71.62 216.39,70.1 216.39,68.7 215.73,68.04 215.73,66.54 214.31,65.13 214.31,62.51 212.56,60.76 212.56,59.76 211.94,59.14 211.94,55.22 212.8,54.37 212.8,47.46 208.39,43.05 207.91,43.05 206.1,41.24 203.71,41.24 202.95,42.01 202.07,42.01 200.75,43.33 194.19,43.33 190,47.52 189.26,47.52 188.9,47.16 188.24,47.16 187.33,46.25 187.33,39.11 184.91,36.69 182.05,36.69 181.35,37.4 178.89,37.4 177.25,35.76 v1(176.54,35.76)
  BOTTOM w0.127: v1(176.54,35.76) 176.5,35.8 U45.82 ; v1(202.24,178.45) 202.11,178.58 200.08,178.58 199.91,178.75 CN10.54
C_PEG_TX0: length 12.6
  BOTTOM w0.076: U35.A17 131.34,123.84 131.34,124.83 131.34,124.83 131.34,124.97 131.43,125.06 ; 135.63,127.74 135.63,127.7 135.52,127.59 135.52,127.08 135.39,126.95
  BOTTOM w0.079: 135.39,126.95 134.49,126.05 132.42,126.05 131.43,125.06
  BOTTOM w0.114: C652.2 138.7,130.78 138.94,130.78 139.02,130.7 139.02,130.39 138.89,130.26 138.89,130.14 138.75,130 137.9,130 135.63,127.74
C_PEG_TX1: length 15.2
  BOTTOM w0.076: 136.07,127.31 135.96,127.2 135.96,127 134.58,125.62 132.77,125.62 131.73,124.58 131.73,123.11 131.9,122.94 131.9,122.87 U35.C16
  BOTTOM w0.114: C655.2 140.98,130.78 141.26,130.78 141.35,130.68 141.35,130.44 141.27,130.36 141.27,130.14 140.33,129.19 137.95,129.19 136.07,127.31
C_PEG_TX2: length 13.2
  BOTTOM w0.076: 132.3,126.35 130.94,124.98 130.94,123.6 130.96,123.53 130.96,123.24 130.94,123.19 130.93,123.16 130.93,122.98 130.98,122.86 130.99,122.82 130.99,122.63 U35.C17 ; 135.17,126.98 135.17,127.82 135.36,128.01 135.36,128.03 135.37,128.04
  BOTTOM w0.079: 135.17,126.98 134.54,126.35 132.3,126.35
  BOTTOM w0.114: 135.37,128.04 135.85,128.52 135.87,128.52 136.54,129.19 136.54,129.24 v1(137.17,129.86) 136.81,129.86 136.71,129.97 136.71,130.6 136.86,130.75 137.03,130.75 C662.2
C_PEG_TX3: length 10.9
  BOTTOM w0.076: 130.49,128.67 130.49,128.65 130.47,128.63 130.47,127.41 129.74,126.68 129.74,124.45 129.53,124.25 129.53,123.49 129.66,123.37 129.78,123.37 129.86,123.45 U35.A19
  BOTTOM w0.114: 130.49,128.67 130.49,129.41 132.37,131.29 132.37,132.04 C660.2
C_PEG_TX#0: length 12.7
  BOTTOM w0.076: 131.59,124.99 131.59,124.99 131.5,124.9 131.5,124.9 131.5,123.36 U35.B17 ; 135.79,127.59 135.78,127.59 135.75,127.59 135.68,127.52 135.68,127.01
  BOTTOM w0.079: 131.59,124.99 132.49,125.89 134.56,125.89 135.68,127.01
  BOTTOM w0.114: C653.1 139.5,130.57 139.1,130.17 139.1,130.05 138.84,129.79 137.99,129.79 135.79,127.59
C_PEG_TX#1: length 15.2
  BOTTOM w0.076: 136.22,127.15 136.12,127.06 136.12,126.93 134.65,125.46 132.84,125.46 131.9,124.51 131.9,123.18 132.07,123 132.07,122.61 131.77,122.31 U35.D16
  BOTTOM w0.114: C656.2 141.49,130.27 141.49,130.05 140.42,128.98 138.04,128.98 136.22,127.15
C_PEG_TX#2: length 13.3
  BOTTOM w0.076: 135.19,128.14 135.01,127.96 135.01,127.05 135.01,127.05 ; U35.D17 130.92,122.06 130.92,122.37 130.83,122.46 130.83,122.79 130.81,122.84 130.76,122.95 130.76,123.2 130.8,123.28 130.8,123.5 130.77,123.56 130.77,123.57 130.77,125.08 130.87,125.19
  BOTTOM w0.079: 130.87,125.19 132.2,126.51 134.47,126.51 135.01,127.05
  BOTTOM w0.114: C661.2 136.38,130.57 136.43,130.52 136.43,130.22 136.07,129.86 v1(135.9,129.86) 136.28,129.48 136.28,129.23 135.19,128.14
C_PEG_TX#3: length 10.9
  BOTTOM w0.076: 130.28,128.67 130.28,128.65 130.3,128.63 130.3,127.48 129.57,126.75 129.57,124.52 129.37,124.32 129.37,123.42 129.59,123.21 129.71,123.21 U35.B19
  BOTTOM w0.114: C654.2 132.15,132.13 132.15,131.38 130.28,129.5 130.28,128.67
CATERR#: length 12.3
  BOTTOM w0.076: U35.D63 105.37,122.06 105.37,122.63 105.53,122.97 105.53,123.1 105.46,123.33 105.46,123.47 105.52,123.64 105.52,124.3 105.19,124.63 105.19,125.14
  BOTTOM w0.127: R788.2 100.26,130.96 100.77,130.45 100.77,129.18 102.39,127.55 TP65.1 102.77,127.55 105.19,125.14
CCD_PWR:
  vias: v1(117.02,169.31) v1(117.71,169.31)
CFG4: length 7
  BOTTOM w0.127: R548.1 95.73,123.03 v1(96.42,123.03) 96.43,123.03 99.15,123.03 99.91,122.27 100.38,122.27 100.84,121.81 U35.E70
CFG_RCOMP: length 13.9
  TOP w0.508: v1(99,123.88) 98.53,124.35 R156.2
  IN1 w0.508: v1(99,123.88) 100.18,125.06 104.18,125.06 106.69,122.55 v2(106.69,120.02)
  BOTTOM w0.305: U35.E60 106.57,120.5 106.57,120.13 106.69,120.01 v2(106.69,120.02)
CHA_SA0: length 7.1
  BOTTOM w0.127: JDIM1.256 148.47,41.66 147.99,41.17 v1(146.95,41.17) 146.28,40.51 146.28,39.88 146.29,39.87 146.29,39.23 146.28,39.22 146.28,39.2 R10872.2 R10882.1
