# Allegro board Quanta ZAA.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 38.45,98.29 38.45,97.53 38.62,97.37 39.6,97.37 39.7,97.26 39.7,96.58 39.61,96.49 37.16,96.49 37.07,96.4 36.32,96.4 36.19,96.53 36.19,97.46 36.33,97.6 36.89,97.6 37.12,97.37 38.1,97.37 38.26,97.53 38.26,98.29 38.3,98.32 38.42,98.32
GND on TOP (solid shape): 150.8,110.64 150.81,110.64 151.44,110 151.44,109.62 151.57,109.49 155.94,109.49 155.97,109.52 155.98,109.53 156.07,109.58 156.13,109.67 156.13,109.69 156.57,110.13 157.36,110.13 157.54,109.95 157.54,109.19 157.21,108.86 151.31,108.86 150.1,110.07 150.1,110.79 150.2,110.89 150.56,110.89
GND on TOP (solid shape): 169.14,181.5 169.14,179.93 169.02,179.8 168.33,179.8 168.2,179.67 168.2,177.95 167.96,177.71 164.46,177.71 164.37,177.79 164.37,178.53 165.08,179.24 165.69,179.24 165.69,179.27 165.71,179.3 165.74,179.32 165.89,179.32 165.94,179.37 165.94,179.38 166.17,179.61 166.17,180.79 166.99,181.6 169.04,181.6
GND on TOP (solid shape): 122.84,123.9 122.84,122.7 122.71,122.57 122.68,122.56 122.65,122.57 122.25,122.71 121.85,122.59 121.72,122.72 121.72,123.94 121.79,124.01 122.74,124.01
GND on TOP (solid shape): 48.16,42.77 48.16,40.02 48.7,39.49 48.7,39.06 48.11,38.48 48.11,37.13 47.96,36.98 44.23,36.98 43.67,36.42 43.65,36.41 43.62,36.41 43.44,36.44 43.27,36.39 41.51,36.39 41.09,36.81 41.09,37.6 41.08,37.61 41.08,43.2 42.42,44.55 46.39,44.55
GND on TOP (solid shape): 19.6,15.18 20.35,15.18 20.46,15.07 20.46,14.61 20.37,14.52 19.47,14.52 19.28,14.33 19.16,14.33 18.8,13.97 17.46,13.97 17.42,14.01 16.83,14.01 16.76,14.08 16.45,14.08 16.33,14.2 16.33,14.52 16.44,14.63 17.01,14.63 17.11,14.72 17.11,15.25 17.14,15.28 17.96,15.28 18.06,15.18 18.86,15.18 19.2,15.52 19.25,15.52
GND on TOP (solid shape): 118.42,159.96 118.42,157.58 117.58,156.74 115.68,156.74 115.55,156.86 115.55,157.53 115.22,157.86 114.66,157.86 114.59,157.93 114.59,158.31 114.69,158.41 114.73,158.41 114.73,158.41 114.86,158.39 114.99,158.41 115,158.41 115.27,158.41 115.83,158.97 116.97,158.97 117.3,159.3 117.3,159.51 117.29,159.52 117.29,159.62 117.51,159.84 117.51,159.84 117.74,160.07 118.32,160.07
GND on TOP (solid shape): 18.52,33.07 19.58,33.07 19.6,33.09 20.58,33.09 20.68,32.99 20.68,32.58 20.5,32.4 19.84,32.4 19.46,32.02 17.58,32.02 17.48,32.13 15.3,32.13 15.09,32.33 15.09,32.42 15.16,32.56 15.19,32.71 15.29,32.81 16.74,32.81 16.97,33.04 17.33,33.04 17.46,33.18 17.52,33.18 17.52,33.23 17.56,33.27 17.56,33.4 17.66,33.5 18.09,33.5
GND on TOP (solid shape): 121.4,109.52 121.4,109.4 121.39,109.32 121.4,109.23 121.4,107.85 121.3,107.75 120.91,107.75 120.48,108.18 119.66,108.18 119.45,108.4 119.18,108.4 119.17,108.41 118.61,108.41 118.6,108.41 118.3,108.41 117.89,108 117.89,107.88 117.8,107.78 117.42,107.78 117.38,107.83 117.38,108.73 117.64,108.99 118.71,108.99 118.93,109.21 118.93,109.68 118.98,109.73 121.19,109.73
GND on TOP (solid shape): 124.05,119.83 124.05,119.27 124.46,118.86 124.46,118.16 124.95,117.67 124.95,116.78 125.06,116.67 125.06,110.88 125.32,110.62 125.7,110.62 125.95,110.37 125.95,110.1 125.81,109.96 124.31,109.96 124.15,109.79 124.15,109.58 123.51,108.94 123.23,108.94 123.18,108.99 123.16,109.08 123.12,109.16 123.12,109.21 122.9,109.43 122.9,112.18 122.93,112.21 122.9,112.27 122.9,118.73 123.34,119.17 123.34,119.94 123.39,119.98 123.89,119.98
GND on TOP (solid shape): 202.88,192.3 202.88,190.9 202.85,190.87 202.84,190.87 202.55,190.49 202.84,190.12 202.85,190.12 202.88,190.09 202.88,186.84 202.75,186.71 202.24,186.71 201.99,186.46 201.73,186.46 201.61,186.58 201.61,192.3 201.73,192.42 202.75,192.42
GND on TOP (solid shape): 43.68,62.43 43.68,62.43 43.71,62.4 43.71,60.7 43.63,60.62 43.04,60.62 43.03,60.63 42.75,60.63 42.56,60.44 42.57,60.43 42.57,59.76 42.4,59.6 40.72,59.6 40.12,59 40.12,58.87 40.06,58.87 40.06,58.12 40.12,58.12 40.12,57.98 40.13,57.98 40.13,57.24 40,57.12 39.9,57.12 39.9,57.12 39.63,57.12 39.3,56.79 39.3,56.02 39.47,55.85 39.47,54.26 39.43,54.21 38.88,54.21 38.46,54.63 38.46,61.72 38.87,62.12 39.99,62.12 40.39,62.53 43.58,62.53
GND on TOP (solid shape): 127.93,114.79 127.93,114.42 128.24,114.11 128.24,114.05 128.75,113.54 128.75,112.18 128.12,111.56 128.12,111.52 128.11,111.51 128.11,110.75 128.12,110.74 128.12,110.72 128.49,110.35 128.49,109.4 128.43,109.34 128.38,109.34 128.13,109.35 127.93,109.2 127.75,109.2 127.44,109.52 127.44,113.33 127.35,113.42 127.35,113.92 127.35,113.93 127.35,114.03 127.03,114.35 127.03,114.76 127.18,114.91 127.8,114.91
GND on TOP (solid shape): 232.85,185.01 232.85,180.49 232.37,180 228.28,180 228.03,180.26 227.95,180.26 227.64,180.56 227.64,180.59 228.32,182.74 227.65,184.9 227.64,184.91 227.64,185.19 227.97,185.52 232.34,185.52
GND on TOP (solid shape): 145.34,119.15 145.34,118.64 145.6,118.38 145.98,118.38 146.11,118.26 146.11,117.93 146.09,117.89 146.06,117.88 145.47,117.88 145.34,118 145.31,118 145.25,118.07 140.41,118.07 140.18,118.14 139.95,118.07 139.68,118.07 139.47,117.86 139.01,117.86 138.99,117.88 138.99,118.23 139.63,118.87 141.47,118.87 141.52,118.82 141.53,118.82 141.64,118.71 144.48,118.71 144.71,118.94 144.71,119.15 144.84,119.27 145.22,119.27
GND on TOP (solid shape): 170.92,137.97 170.92,137.13 171.18,136.88 171.76,136.88 172.24,136.39 172.24,132.05 172.14,131.95 172.12,131.95 171.98,131.92 171.85,131.82 171.83,131.82 171.62,131.82 171.6,131.82 171.58,131.84 171.32,131.95 171.05,131.84 171.04,131.82 171.02,131.82 169.3,131.82 169.07,132.05 169.07,137.79 169.4,138.12 170.77,138.12
GND on TOP (solid shape): 132.21,158.57 137.04,158.57 137.17,158.44 137.17,154.43 136.45,153.72 134.36,153.72 134.18,153.77 133.99,153.72 133.98,153.72 133.86,153.72 133.23,153.08 133.23,151.43 132.95,151.15 132.29,151.15 132.04,151.4 132.04,155.77 131.53,156.28 130.46,156.28 130,155.82 127.49,155.82 126.55,154.88 124.09,154.88 123.88,154.68 123.88,154.32 123.53,153.97 122.94,153.97 122.79,154.12 122.79,156.05 122.31,156.53 121.09,156.53 120.86,156.31 119.72,156.31 119.36,156.66 119.36,158.62 119.49,158.74 129.06,158.74 129.09,158.77 132.01,158.77
GND on TOP (solid shape): 205.16,80.77 205.16,68.73 204.96,68.52 200.89,68.52 200.49,68.92 196.32,68.92 196.09,68.7 196.09,60.8 195.92,60.62 192.46,60.62 192.18,60.9 192.18,69.49 191.77,69.9 191.77,70.27 191.76,70.28 191.76,72.27 192.11,72.61 192.65,72.61 193.01,72.97 193.01,75.61 191.89,76.73 191.89,77.77 191.92,77.8 191.92,79.11 192.13,79.32 196.09,79.32 196.54,78.87 196.54,76.51 197.73,75.32 197.73,74.07 197.26,73.6 196.88,73.6 196.51,73.24 196.51,72.36 197.28,71.6 200.46,71.6 201.05,72.18 201.05,80.82 201.28,81.05 204.88,81.05
GND on TOP (solid shape): 174.53,115.16 174.53,110.13 174.43,110.03 173.62,110.03 173.32,110.33 173.31,110.34 173.31,110.38 173.26,110.43 173.23,110.47 173.18,110.51 172.65,111.04 172.65,112.16 173.11,112.62 173.12,112.62 173.4,112.87 173.33,113.24 173.32,113.27 173.33,113.31 173.73,113.7 173.73,114.86 173.6,114.99 173.6,115.34 173.62,115.37 173.65,115.39 174.3,115.39
GND on TOP (solid shape): 117.84,117.76 117.84,109.91 117.46,109.53 116.88,109.53 116.78,109.63 116.8,109.76 116.77,109.88 116.77,110.39 116.46,110.71 115.72,110.71 115.49,110.47 113.88,110.47 113.88,110.47 112.06,110.47 112.04,110.48 111.56,110.48 111.35,110.7 111.35,111.59 111.47,111.71 114.5,111.71 114.7,111.92 114.7,113.59 114.7,113.59 114.7,114.16 114.86,114.33 114.86,115.89 115.11,116.13 115.11,116.36 115.12,116.39 115.12,116.43 115.12,116.73 115.06,116.89 114.89,116.96 114.87,116.96 114.79,117.04 114.79,117.42 115.29,117.92 115.69,117.92 115.69,117.93 117.66,117.93
GND on TOP (solid shape): 18.19,39.75 18.19,39.21 18.5,38.91 20,38.91 20.07,38.83 20.07,38.65 20.38,38.35 21.57,38.35 21.79,38.12 21.81,38.09 21.8,38.06 21.81,37.65 22.19,37.49 22.27,37.47 22.31,37.39 22.31,35.43 22.1,35.22 21.67,35.22 21.47,35.43 21.47,37.38 21.43,37.42 21.42,37.43 21.37,37.48 20.38,37.48 19.82,36.93 18.47,36.93 17.89,37.51 15.63,37.51 15.55,37.59 15.55,39.62 15.88,39.95 17.99,39.95
GND on TOP (solid shape): 229.47,110.43 229.47,104.64 229.14,104.64 228.86,104.92 228.86,105.2 228.61,105.46 227.72,105.46 227.56,105.3 227.56,104.92 227.34,104.69 227.01,104.69 226.8,104.9 226.8,105.66 225.96,106.5 225.41,106.5 225.33,106.57 225.33,107.26 225.94,107.87 225.94,109.56 227.39,109.56 227.39,109.5 227.41,109.45 227.43,109.4 227.46,109.35 227.49,109.3 227.53,109.27 227.58,109.24 227.63,109.21 227.68,109.2 227.74,109.19 227.8,109.19 227.85,109.2 227.9,109.21 227.95,109.24 228,109.27 228.04,109.3 228.08,109.35 228.11,109.4 228.13,109.45 228.14,109.5 228.15,109.56 228.15,109.61 228.14,109.67 228.12,109.72 228.09,109.77 228.06,109.81 228.02,109.85 227.98,109.89 227.93,109.92 227.88,109.94 227.82,109.95 227.77,109.95 227.71,109.95 227.66,109.94 227.61,109.92 227.56,109.89 227.51,109.85 227.47,109.81 227.44,109.77 227.42,109.72 227.4,109.67 227.39,109.61 227.39,109.56 225.94,109.56 225.94,109.57 227.54,111.17 228.73,111.17
GND on TOP (solid shape): 59.28,28.48 60.57,28.48 62.76,26.3 62.76,25.2 62.21,24.66 55.17,24.66 52.76,27.07 52.76,27.1 57.14,27.1 57.14,27.03 57.16,26.97 57.18,26.91 57.2,26.85 57.24,26.79 57.28,26.74 57.32,26.7 57.37,26.66 57.43,26.63 57.49,26.6 57.55,26.58 57.62,26.57 57.68,26.57 57.74,26.58 57.81,26.59 57.87,26.61 57.93,26.64 57.98,26.68 58.03,26.72 58.07,26.77 58.11,26.82 58.14,26.88 58.16,26.94 58.18,27 58.19,27.06 58.19,27.13 58.18,27.19 58.16,27.26 58.14,27.32 58.11,27.37 58.07,27.42 58.03,27.47 57.98,27.51 57.93,27.55 57.87,27.58 57.81,27.6 57.74,27.61 57.68,27.62 57.62,27.62 57.55,27.61 57.49,27.59 57.43,27.57 57.37,27.53 57.32,27.49 57.28,27.45 57.24,27.4 57.2,27.34 57.18,27.29 57.16,27.22 57.14,27.16 57.14,27.1 52.76,27.1 52.76,28.09 52.99,28.32 54.82,28.32 55.2,28.7 55.2,29.66 55.61,30.07 57.69,30.07
GND on TOP (solid shape): 77.28,90.55 77.3,90.54 77.31,90.53 80.35,87.5 80.36,87.48 80.36,87.46 80.36,81.83 81.02,81.18 81.84,81.18 81.86,81.16 81.88,81.16 88.13,81.16 88.17,81.15 88.18,81.11 88.18,66.59 88.17,66.55 88.13,66.53 80.27,66.53 80.25,66.54 80.24,66.55 78.56,68.23 78.55,68.25 78.54,68.27 78.54,71.25 78.54,71.27 78.53,71.28 77.72,72.09 77.7,72.1 77.68,72.11 75.9,72.11 75.88,72.11 75.86,72.12 75.36,72.62 75.35,72.64 75.34,72.66 75.34,77.11 75.34,77.13 75.33,77.15 74.27,78.21 74.25,78.22 74.23,78.23 69.93,78.23 69.91,78.23 69.89,78.24 68.8,79.33 68.79,79.35 68.79,79.37 68.79,89.97 68.79,89.99 68.8,90 69.33,90.53 69.35,90.54 69.37,90.55
GND on TOP (solid shape): 9.12,113.12 11.6,113.12 12.26,112.99 12.82,112.62 13.19,112.06 13.32,111.4 13.32,109.27 12.31,109.27 12.31,111.4 12.1,111.9 11.6,112.11 7.71,112.11 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.11 1.41,112.11 1.41,113.46 1.4,113.46 0.92,113.94 0.59,113.94 0.49,114.04 0.49,114.83 0.56,114.9 3.21,114.9 3.69,114.42 4.53,114.42 5.54,115.44 6.81,115.44
GND on TOP (solid shape): 153.9,160.57 153.9,155.67 153.5,155.26 150.83,155.26 150.48,154.91 150.48,154.32 150.37,154.22 149.28,154.22 148.93,154.58 146.51,154.58 145.88,153.94 145.88,150.87 145.32,150.31 142.7,150.31 142.02,151 142.02,154.58 141.66,154.93 141.66,156.23 141.23,156.66 138.11,156.66 138.06,156.71 138.06,157.55 138.13,157.63 139.1,157.63 139.38,157.91 139.38,158.54 139.53,158.69 145.4,158.69 146.83,160.13 146.94,160.15 147,160.06 149.32,158.18 150.92,160.7 150.94,160.79 151.02,160.83 153.65,160.83
GND on TOP (solid shape): 9.46,45.54 9.52,45.64 9.63,45.61 9.95,45.47 10.3,45.56 10.33,45.58 10.94,44.98 12.25,44.98 13.14,44.09 13.14,39.95 14.81,38.27 14.81,37.54 14.23,36.95 12.88,36.95 12.88,36.58 12.84,36.57 12.68,36.54 12.53,36.47 12.43,36.47 12.38,36.56 12.38,38.6 11.58,39.63 10.39,39.11 9.78,39.11 2.31,39.11 2.31,42.29 8.75,42.29 9.45,42.69 9.46,43.49
GND on TOP (solid shape): 13.52,27.26 13.59,27.23 14.56,26.26 14.56,20.87 14.13,20.44 14.11,20.44 13.44,19.77 13,19.97 12.53,19.87 12.43,19.87 12.38,19.96 12.38,22 11.58,23.03 10.39,22.51 9.84,22.51 2.31,22.51 2.31,24.49 10.39,24.49 11.58,23.98 12.38,25 12.38,27.04 12.43,27.13 12.53,27.13 13,27.03 13.45,27.23
GND on TOP (solid shape): outline of 129 points within 172.29,78.61 179.45,87.85
GND on TOP (solid shape): 5.43,74.06 5.67,73.99 5.93,74.03 5.96,74.04 6.64,73.36 7.92,73.36 11.87,69.41 12.91,69.41 16.31,66.01 16.31,61.39 13.16,58.24 13.16,57.42 12.2,56.46 10.95,56.46 10.03,55.53 10.01,55.53 9.8,55.5 9.63,55.39 9.52,55.37 9.46,55.46 9.46,57.51 9.56,57.89 9.47,58.27 9.46,58.28 9.17,58.59 8.75,58.71 2.31,58.71 2.31,60.66 3.78,61.89 6.1,61.89 6.67,62.01 7.16,62.33 7.49,63.97 6.1,64.91 3.73,64.91 3.53,65.11 3.53,67.41 3.53,67.84 4.12,67.84 4.19,67.84 4.42,67.84 5.13,68.14 5.43,68.85
GND on TOP (solid shape): 13.32,97.4 13.07,96.5 12.38,95.86 12.38,95.56 7.73,90.9 7.73,86.15 6.14,84.57 6.14,82.05 6.09,81.96 5.99,81.96 5.71,82.02 5.43,81.95 5.43,89.45 5.13,90.16 4.42,90.46 4.19,90.46 4.12,90.46 4.05,90.46 3.53,90.46 3.53,93.75 3.46,94.11 3.27,94.42 2.93,94.67 2.52,94.76 2.4,94.76 1.7,95.05 1.41,95.75 1.41,96.69 4.89,96.69 4.89,96.5 5.1,96 5.6,95.79 7,95.79 7.19,95.82 7.37,95.89 7.62,96.15 7.71,96.5 7.71,96.69 9.87,96.69 11.6,96.69 12.1,96.9 12.31,97.4 12.31,99.66 13.32,99.66
GND on TOP (solid shape): outline of 179 points within 144.79,51.71 146.44,61.11
GND on TOP (solid shape): outline of 628 points within 84.54,107.18 98.08,122.07
GND on TOP (solid shape): outline of 774 points within 169.6,123.65 190.07,139.16
GND on TOP (solid shape): outline of 4249 points within 0.51,0.51 244.39,198.19
GND on BOTTOM (solid shape): 33.48,95.07 33.48,91.76 33.15,91.43 31.2,91.43 30.92,91.71 30.92,95.3 31.1,95.47 33.08,95.47
GND on BOTTOM (solid shape): 45.55,57.37 45.55,56.33 45.11,55.89 44.11,55.89 43.85,56.14 43.85,57.52 43.91,57.57 45.35,57.57
GND on BOTTOM (solid shape): 53.88,38.17 53.88,37.61 53.68,37.41 53.32,37.41 52.66,38.07 52.66,38.27 52.86,38.48 53.57,38.48
GND on BOTTOM (solid shape): 74.53,43.63 74.53,40.38 74.25,40.1 70.03,40.1 69.55,40.58 69.55,43.78 69.78,44.01 74.15,44.01
GND on BOTTOM (solid shape): 130,170.4 130,168.04 129.85,167.89 126.35,167.89 126.27,167.96 126.27,170.33 126.6,170.66 129.75,170.66
GND on BOTTOM (solid shape): 148.27,116.35 148.27,116.1 148.14,115.97 146.36,115.97 146.23,116.1 146.23,116.35 146.36,116.48 148.14,116.48
GND on BOTTOM (solid shape): 160.12,147.98 160.12,144.01 159.72,143.61 157.11,143.61 156.72,143.99 156.72,148.2 156.89,148.37 159.73,148.37
GND on BOTTOM (solid shape): 166.33,171.19 166.33,170.36 164.44,168.47 161.22,168.47 160.99,168.7 160.99,171.19 161.17,171.37 166.15,171.37
GND on BOTTOM (solid shape): 180.75,114.12 180.75,112.64 180.65,112.54 174.94,112.54 174.28,113.2 174.28,114.17 174.4,114.29 180.57,114.29
GND on BOTTOM (solid shape): 196.55,119.23 196.55,118.62 196.4,118.46 195.23,118.46 195.03,118.67 195.03,118.87 195.79,119.63 196.15,119.63
GND on BOTTOM (solid shape): 238.23,195.73 238.23,190.82 238.05,190.65 234.55,190.65 232.26,192.93 232.26,195.9 232.59,196.23 237.72,196.23
GND on BOTTOM (solid shape): 58.68,48.91 60,48.91 60.05,48.86 60.05,46.63 59.92,46.5 56.22,46.5 56.09,46.63 56.09,49.22 56.32,49.45 58.15,49.45
GND on BOTTOM (solid shape): 61.43,73.47 61.43,72.1 61.04,71.7 61.04,70.85 58.05,70.85 57.82,71.07 57.82,73.16 58.22,73.56 61.35,73.56
GND on BOTTOM (solid shape): 74.83,75.83 74.83,71.24 74.1,70.51 71.58,70.51 71.06,71.03 71.06,72.09 69.93,73.22 69.93,75.73 70.5,76.3 74.36,76.3
GND on BOTTOM (solid shape): 100.01,101.77 100.26,101.77 100.81,101.22 100.81,100.97 100.68,100.84 99.54,100.84 99.28,101.1 99.28,101.38 99.68,101.77 100,101.77
GND on BOTTOM (solid shape): 109.71,145.23 109.71,143.68 110.09,143.3 110.09,136.95 109.78,136.65 106.91,136.65 106.58,136.98 106.58,143.81 108.29,145.51 109.43,145.51
GND on BOTTOM (solid shape): 158.22,182.95 158.22,180.59 158.96,179.85 158.96,179.6 158.86,179.5 155.45,179.5 154.84,180.11 154.84,182.82 155.33,183.31 157.87,183.31
GND on BOTTOM (solid shape): 176.46,73.91 176.46,67.99 176.28,67.81 174.96,67.81 174.78,67.99 174.78,73.6 175.22,74.04 176.33,74.04
GND on BOTTOM (solid shape): 222.99,44.37 225.94,44.37 226.07,44.24 226.07,43.17 226.02,43.12 221.54,43.12 221.34,43.33 221.34,45 221.47,45.13 222.23,45.13
GND on BOTTOM (solid shape): 196.77,25.21 196.77,24.26 196.62,24.11 194.37,24.11 194.22,24.26 194.22,25.06 194.23,25.12 194.23,25.18 194.38,25.33 196.65,25.33
GND on BOTTOM (solid shape): 52.08,96.82 52.08,93.16 51.89,92.96 50.45,92.96 50.2,93.22 50.2,96.69 50.55,97.05 51.85,97.05
GND on BOTTOM (solid shape): 76.51,120.39 76.51,115.27 76.08,114.84 73.33,114.84 73.17,115 73.17,117.96 71.29,119.85 71.29,120.44 71.54,120.69 76.22,120.69
GND on BOTTOM (solid shape): 95.92,119.84 96.54,119.84 97.21,119.17 97.21,118.94 97.06,118.79 88.7,118.79 88.58,118.92 88.58,119.53 88.98,119.93 90.91,119.93 91.42,120.44 95.32,120.44
GND on BOTTOM (solid shape): 224.21,140.48 224.85,140.48 224.97,140.35 224.97,139.59 226.12,138.45 226.12,137.38 225.71,136.98 222.76,136.98 222.43,137.31 222.43,140.23 223.07,140.86 223.83,140.86
GND on BOTTOM (solid shape): 59.44,57.3 59.44,56.23 59.24,56.03 59.24,51.48 59.04,51.28 58.3,51.28 57.82,51.76 57.82,52.52 58.32,53.03 58.32,56 57.99,56.33 57.99,57.32 58.12,57.45 59.29,57.45
GND on BOTTOM (solid shape): 65.87,120.21 65.87,119.7 66.02,119.55 66.83,119.55 67.24,119.15 67.24,118.43 67.04,118.23 64.95,118.23 64.6,118.59 64.6,119.3 65.16,119.86 65.16,120.26 65.26,120.37 65.72,120.37
GND on BOTTOM (solid shape): 88.73,89.73 88.73,87.75 88.48,87.5 88.11,87.5 88.11,87.5 86.96,87.5 86.96,87.5 86.59,87.5 86.58,87.5 82.12,87.5 81.92,87.7 81.92,90.04 82.28,90.39 88.07,90.39
GND on BOTTOM (solid shape): 206.13,175.86 210.4,175.86 211.51,174.75 211.51,173.93 211.46,173.88 210.85,173.88 210.5,174.24 205.75,174.24 205.64,174.34 205.64,174.84 205.51,174.98 205.51,175.91 205.69,176.09 205.9,176.09
GND on BOTTOM (solid shape): 63.72,96.66 63.72,92.9 63.64,92.82 62.67,92.82 62.32,93.16 59.72,93.16 59.49,93.39 59.49,94.13 58.73,94.89 58.73,96.06 58.96,96.29 58.96,96.34 59.39,96.77 63.61,96.77
GND on BOTTOM (solid shape): 74.68,58.84 74.68,55.95 74.38,55.65 70.88,55.65 70.77,55.53 67.86,55.53 67.37,56.03 67.37,57.17 67.5,57.31 69.46,57.31 72.02,59.86 73.66,59.86
GND on BOTTOM (solid shape): 184.77,102.64 184.77,99 183.93,98.17 183.93,91.61 183.7,91.38 181.41,91.38 181.03,91.76 181.03,99.89 180.75,100.17 177.96,100.17 177.73,100.4 177.73,102.53 177.96,102.76 184.64,102.76
GND on BOTTOM (solid shape): 53.52,82.77 53.52,81.12 52.94,80.54 52.74,80.54 52.42,80.22 52.01,80.22 51.87,80.36 51.87,81.4 52.05,81.58 52.86,81.58 53.04,81.76 53.04,82.72 53.14,82.82 53.47,82.82
GND on BOTTOM (solid shape): 57.62,63.51 57.62,62.87 56.83,62.07 56.83,61.11 56.95,60.98 58.65,60.98 58.78,60.85 58.78,58.26 58.45,57.93 54.64,57.93 54.62,57.91 54.26,57.91 53.84,58.33 53.84,63.19 54.26,63.62 57.51,63.62
GND on BOTTOM (solid shape): 67.46,68.93 67.46,68.35 66.77,67.66 66.77,65.92 66.57,65.73 65.7,65.73 65.5,65.93 64.7,65.93 64.54,66.1 64.54,67.4 65.4,68.27 66.09,68.27 66.82,69 67.38,69
GND on BOTTOM (solid shape): 79.69,130.55 79.69,123.21 79.38,122.91 77.17,122.91 76.76,123.31 76.76,130.03 77.03,130.3 77.33,130.3 77.64,130.61 77.92,130.69 78.2,130.78 79.46,130.78
GND on BOTTOM (solid shape): 215.53,74.11 215.53,72.69 215.5,72.66 215.5,67.66 215.19,67.36 213.72,67.36 213.52,67.56 213.52,68.6 213.62,68.7 213.62,69.95 213.92,70.25 213.92,73.98 214.18,74.24 215.4,74.24
GND on BOTTOM (solid shape): 232.14,102.33 232.14,100.73 231.97,100.57 227.97,100.57 227.96,100.56 227.93,100.54 227.89,100.56 227.84,100.6 227.84,102.2 228,102.36 230.56,102.36 230.71,102.51 231.96,102.51
GND on BOTTOM (solid shape): 89.4,135.55 89.4,132.08 90.76,130.72 90.76,128.57 90.51,128.32 88.32,128.32 88.14,128.49 88.14,134.13 87.92,134.36 87.92,134.97 88.53,135.59 88.8,135.76 89.2,135.76
GND on BOTTOM (solid shape): 46.46,76.07 46.46,76.06 46.55,75.92 46.69,75.84 46.7,75.83 47.07,75.46 47.07,72.59 46.44,71.95 44.2,71.95 44.1,72.05 44.1,75.71 44.68,76.3 46.23,76.3
GND on BOTTOM (solid shape): 213.61,101.58 213.61,100.5 214.33,99.78 214.33,95.58 213.25,94.5 213.25,90.04 213.78,89.51 217.52,89.51 218.04,88.99 218.04,85.01 217.76,84.73 209.1,84.73 207.83,86 207.83,99.66 209.78,101.62 213.57,101.62
GND on BOTTOM (solid shape): 214.25,178.78 215.15,178.78 215.51,178.42 215.51,176.74 215.1,176.33 215.1,175.47 215.39,175.17 215.39,174.37 215.25,174.23 212.29,174.23 210.57,175.95 210.57,178.71 210.65,178.79 214.24,178.79
GND on BOTTOM (solid shape): 218.95,104.63 218.99,104.61 219,104.58 219,100.86 218.75,100.6 215.45,100.6 215.07,100.98 215.07,103.99 215.08,104.03 215.12,104.05 215.47,104.05 216.06,104.63
GND on BOTTOM (solid shape): 228.73,122.37 228.73,120.62 228.02,119.91 228.02,118.13 228.05,118.1 228.05,117.49 227.76,117.2 226.7,117.2 226.53,117.04 223.27,117.04 222.31,118 222.31,121.18 222.43,121.3 226.22,121.3 226.23,121.32 226.38,121.32 227.69,122.63 228.48,122.63
GND on BOTTOM (solid shape): 137.45,159.15 138.13,159.15 138.16,159.13 138.16,158.95 138.14,158.91 138.11,158.9 137.61,158.9 137.58,158.87 137.57,158.87 137.32,158.62 137.32,158.29 137.19,158.16 136.45,158.16 135.92,158.69 135.92,159.51 135.97,159.56 137.04,159.56
GND on BOTTOM (solid shape): 222.81,35.16 222.81,29.22 222.81,29.21 222.78,28.86 222.81,28.5 222.81,28.49 222.81,27.9 222.57,27.66 220.84,27.66 220.47,28.03 220.47,35.37 220.71,35.61 220.72,35.61 220.95,35.84 222.12,35.84
GND on BOTTOM (solid shape): 171.01,86.48 171.02,86.48 171.25,86.25 171.42,86.25 171.43,86.25 171.56,86.23 171.69,86.25 171.7,86.25 172.4,86.25 172.65,86 172.65,85.11 172.52,84.98 169.98,84.98 169.6,85.36 169.6,86.63 169.64,86.67 170.82,86.67
GND on BOTTOM (solid shape): 63.89,24.58 63.89,22.7 64.12,22.47 64.12,19.45 63.91,19.25 63.91,16.05 63.79,15.92 60.97,15.92 60.76,16.12 60.76,17.16 60.92,17.32 61.8,17.32 62.39,17.9 63.02,17.9 63.2,18.08 63.2,23.59 62.82,23.97 62.44,23.97 62.36,24.05 62.36,24.51 62.49,24.63 63.84,24.63
GND on BOTTOM (solid shape): 147.22,174.42 148.6,174.42 148.82,174.19 148.82,173.25 148.88,173.2 148.98,173.2 149,173.17 149,171 147.45,169.44 147.45,169.43 146.82,168.8 146.31,168.8 146.21,168.9 146.21,173.45 145.78,173.88 145.78,174.52 145.79,174.55 145.83,174.57 147.07,174.57
GND on BOTTOM (solid shape): 224.96,164.68 224.96,156.42 223.96,155.41 221.2,155.41 221.08,155.53 221.08,156.75 221.08,156.76 221.08,160.54 221.14,160.6 223.12,160.6 223.4,160.88 223.4,162.25 223.5,162.35 223.5,164.74 223.73,164.97 224.67,164.97
GND on BOTTOM (solid shape): 127.67,159.38 127.71,159.38 127.73,159.36 128.25,159.36 128.29,159.34 128.3,159.31 128.3,159.15 128.29,159.12 128.25,159.1 127.73,159.1 127.7,159.07 127.69,159.07 127.54,158.92 126.12,158.92 126.04,159 126.04,159.76 126.09,159.81 127.23,159.81
GND on BOTTOM (solid shape): 189.92,175.53 189.92,174.14 189.79,174.01 183.47,174.01 183.11,173.65 183.11,172.26 182.84,171.98 178.62,171.98 178.36,172.23 178.36,173.12 179.51,174.27 179.73,174.27 179.89,174.33 179.96,174.49 179.96,174.72 180.9,175.66 189.79,175.66
GND on BOTTOM (solid shape): 145.04,178.73 145.04,177.77 144.66,177.39 142.65,177.39 142.45,177.59 141.33,177.59 141.05,177.31 141.05,175.33 140.82,175.1 138,175.1 137.6,174.7 136.33,174.7 136.2,174.82 136.2,175.2 136.57,175.57 136.57,177.35 136.71,177.49 136.91,177.49 137.37,177.95 137.37,178.79 137.62,179.04 141.48,179.04 141.5,179.03 141.64,179.17 142.14,179.17 142.63,179.65 144.13,179.65
GND on BOTTOM (solid shape): 214.51,160.07 214.51,158.35 214.3,158.13 212.67,158.13 212.59,158.17 212.57,158.26 212.5,158.6 212.19,158.77 212.15,158.78 212.15,160.27 212.25,160.37 214.2,160.37
GND on BOTTOM (solid shape): 214.54,31.13 214.56,31.13 214.57,31.12 214.73,30.96 214.73,30.96 215.44,30.25 216.44,30.25 216.72,29.97 216.72,23.03 216.71,23.01 216.7,22.99 216.23,22.51 216.21,22.5 216.19,22.5 213.52,22.5 213.23,22.79 213.23,24.98 214.26,26 214.26,30.25 214.15,30.35 214.15,31.03 214.26,31.13
GND on BOTTOM (solid shape): 57.56,30.12 57.56,28.28 57.03,27.74 57.03,26.89 57.44,26.49 57.97,26.49 58.76,27.27 58.76,28.32 58.91,28.47 62.16,28.47 62.59,28.04 62.59,26.87 62.64,26.82 62.64,25.14 61.93,24.43 59.62,24.43 59.37,24.18 55.02,24.18 54.9,24.3 54.9,30.17 55.05,30.32 57.36,30.32
GND on BOTTOM (solid shape): 166.43,183.46 166.43,182.9 166.64,182.69 166.64,182.65 166.68,182.65 168.41,180.92 168.41,178.07 168.28,177.95 166.96,177.95 166.81,178.1 164.78,178.1 164.32,177.64 164.32,177.39 164.24,177.31 163.05,177.31 163,177.36 163,179.55 163.12,179.67 166.05,179.67 166.25,179.88 166.25,181.3 165.89,181.66 165.44,181.66 165.23,181.86 165.23,182.34 164.85,182.72 164.85,183.64 164.95,183.74 166.15,183.74
GND on BOTTOM (solid shape): 193.38,25.34 193.46,25.3 193.48,25.22 193.54,24.91 193.8,24.75 193.84,24.75 193.84,24.22 193.76,24.14 190.54,24.14 190.43,24.25 190.43,24.69 190.65,24.91 190.65,25.16 190.82,25.34
GND on BOTTOM (solid shape): 88.42,117.32 89.01,117.32 89.13,117.19 89.13,116.99 89.11,116.97 89.09,116.94 88.85,116.71 86.24,116.71 85.17,115.64 84.51,115.64 84.1,115.24 84.1,114.65 84.31,114.45 88.88,114.45 89.21,114.12 89.21,113.18 89.26,113.13 97.08,113.13 97.34,112.87 97.34,112.36 97.11,112.14 94.11,112.14 92.97,110.99 82.12,110.99 81.97,111.14 81.97,117.93 82.3,118.26 87.48,118.26
GND on BOTTOM (solid shape): 152.79,37.03 152.79,32.96 152.66,32.84 146.77,32.84 146.46,33.14 146.46,34.92 146.49,34.94 146.49,34.99 146.5,35 146.57,35.13 146.6,35.28 146.6,35.68 146.57,35.83 146.5,35.96 146.32,36.14 145.57,36.14 145.22,36.49 145.22,37.03 145.5,37.31 147.2,37.31 147.63,37.74 152.08,37.74
GND on BOTTOM (solid shape): 65.15,78.22 65.15,76.71 65.11,76.67 64.97,76.67 64.9,76.74 64.9,77.51 64.88,77.53 64.66,77.53 64.64,77.51 64.64,76.74 64.57,76.67 64.48,76.67 64.42,76.73 64.42,77.51 64.4,77.53 64.14,77.53 64.13,77.51 64.13,76.75 64.05,76.67 63.97,76.67 63.9,76.74 63.9,77.5 63.88,77.52 63.66,77.52 63.64,77.5 63.64,76.74 63.57,76.67 63.43,76.67 61.5,78.61 61.5,79.83 61.86,80.18 63.18,80.18
GND on BOTTOM (solid shape): 125.95,158.73 127.4,158.73 127.51,158.62 127.51,156.31 127.11,155.9 125.51,155.9 125.15,155.54 125.15,154.91 124.95,154.71 124.67,154.71 124.47,154.5 124.06,154.5 123.5,153.94 123.02,153.94 122.79,154.17 122.79,156 121.72,157.07 118.57,157.07 118.57,156.61 118.56,156.57 118.52,156.56 117.48,156.56 117.3,156.74 117.3,157.45 117.56,157.7 118.7,157.7 119.03,158.03 119.03,158.67 119.31,158.95 125.74,158.95
GND on BOTTOM (solid shape): 232.52,183.79 232.52,177.44 231.3,176.22 226.08,176.22 225.61,175.75 223.47,175.75 223.24,175.98 223.24,176.87 223.86,177.49 223.86,178.11 224.61,178.86 226.13,178.86 227.72,180.45 227.72,180.7 228.25,182 228.26,183.41 228.26,184.16 228.53,184.42 231.88,184.42
GND on BOTTOM (solid shape): 163.05,159 163.05,157.35 162.79,157.09 159.29,157.09 158.15,155.95 154.39,155.95 153.3,157.04 150.2,157.04 150.2,156.61 150.18,156.57 150.15,156.56 149.71,156.56 149.68,156.57 149.66,156.61 149.66,157.63 149.68,157.66 149.71,157.68 150.32,157.68 150.63,157.98 150.63,158.49 151.06,158.92 153.75,158.92 153.85,158.82 160.58,158.82 161.25,159.48 162.57,159.48
GND on BOTTOM (solid shape): 133.89,143 133.89,140.63 134.37,140.15 134.37,139.57 133.13,138.32 124.54,138.32 120.87,134.65 120.87,126.88 120.74,126.74 120.28,126.74 120.09,126.93 120.09,129.25 120.24,129.4 120.24,131.07 119.72,131.59 119.72,131.59 119.51,131.8 119.51,134.84 116.64,137.71 116.64,141.09 118.9,143.35 122.21,143.35 123.81,141.75 130.61,141.75 130.92,142.06 130.92,143.07 131.4,143.56 133.33,143.56
GND on BOTTOM (solid shape): 220.06,171.65 220.08,171.62 220.29,171.62 220.31,171.65 220.31,172.43 220.55,172.43 220.55,171.63 220.57,171.62 220.8,171.62 220.82,171.65 220.82,172.43 221.05,172.43 221.05,171.63 221.06,171.62 221.3,171.62 221.32,171.63 221.32,172.43 223.07,172.43 223.52,171.98 224.72,171.98 226.14,170.56 226.14,169.56 225.04,168.46 222.65,168.46 222.65,168.49 222.48,168.66 222.48,169.4 222.32,169.56 221.16,169.56 219.83,170.9 219.81,170.92 219.81,171.12 219.81,171.13 219.81,172.41 219.83,172.43 220.06,172.43
GND on BOTTOM (solid shape): 229.67,111.02 229.67,107.46 229.14,106.93 229.14,106.17 229.01,106.04 228.2,106.04 228.12,106.12 228.02,106.12 227.79,106.34 226.27,106.34 226.24,106.32 225.53,106.32 225.23,106.62 225.23,107.61 225.41,107.79 227.43,107.79 227.45,107.79 227.54,107.74 227.62,107.72 227.92,107.72 228,107.74 228.09,107.79 228.1,107.79 228.3,107.79 228.4,107.89 228.4,110.64 228.91,111.14 229.55,111.14
GND on BOTTOM (solid shape): 156.35,104.24 156.39,104.22 156.4,104.19 156.4,102.65 156.6,102.65 156.6,104.19 156.61,104.22 156.65,104.24 156.85,104.24 156.89,104.22 156.9,104.19 156.9,102.65 157.1,102.65 157.1,104.19 157.11,104.22 157.15,104.24 157.36,104.24 157.4,104.19 157.4,102.65 157.41,102.65 157.41,102.51 157.79,102.13 157.79,102.06 156.85,101.11 154.41,101.11 154.36,101.16 154.36,103.96 154.51,104.11 155.89,104.11 156.01,104.24
GND on BOTTOM (solid shape): 147.96,143.15 147.96,141.45 147.93,141.41 147.82,141.39 147.76,141.47 147.32,141.8 147,141.36 146.98,141.27 146.9,141.24 146.34,141.24 146.21,141.37 146.21,143.1 146.49,143.38 147.73,143.38
GND on BOTTOM (solid shape): 194.09,79.52 196.02,79.52 196.3,79.24 196.3,77.77 196.65,77.41 197.75,77.41 197.82,77.34 197.82,74.11 197.69,73.98 196.65,73.98 196.42,73.76 196.42,71.6 196.75,71.27 197.75,71.27 197.87,71.14 197.87,67.86 197.69,67.69 193.33,67.69 193.1,67.91 193.1,70.02 192.77,70.35 191.7,70.35 191.6,70.45 191.6,73.65 191.75,73.81 192.74,73.81 193.05,74.11 193.05,76.32 192.82,76.55 191.75,76.55 191.57,76.73 191.57,79.88 191.67,79.98 193.63,79.98
GND on BOTTOM (solid shape): 161.4,72.13 161.4,70.63 161.73,70.3 162.19,70.3 162.31,70.17 162.31,66.72 161.55,65.96 161.17,65.96 157.28,65.96 157.25,65.97 157.23,66.01 157.05,66.34 156.57,66.35 156.52,66.43 156.52,67.71 156.55,67.74 156.55,68.7 156.67,68.83 160.31,68.83 160.61,69.13 160.61,71.37 160.59,71.39 160.59,72.14 160.76,72.31 161.22,72.31
GND on BOTTOM (solid shape): 86.23,37.42 90.43,37.42 90.92,36.94 90.92,28.11 90.71,27.91 82.02,27.91 80.57,29.36 81.69,29.36 81.69,29.33 81.7,29.27 81.72,29.22 81.74,29.17 81.77,29.12 81.81,29.08 81.85,29.05 81.9,29.02 81.95,29 82,28.98 82.06,28.97 82.12,28.98 82.17,28.99 82.22,29 82.27,29.03 82.32,29.06 82.36,29.1 82.39,29.15 82.42,29.19 82.44,29.25 82.45,29.3 82.46,29.36 82.45,29.41 82.44,29.47 82.42,29.52 82.39,29.57 82.36,29.61 82.32,29.65 82.27,29.68 82.22,29.71 82.17,29.73 82.12,29.74 82.06,29.74 82,29.73 81.95,29.72 81.9,29.7 81.85,29.67 81.81,29.63 81.77,29.59 81.74,29.54 81.72,29.49 81.7,29.44 81.69,29.38 81.69,29.36 80.57,29.36 79.44,30.49 79.44,37.47 86.18,37.47
GND on BOTTOM (solid shape): 117.93,107 117.97,107 118.02,106.97 118.04,106.97 118.12,106.94 118.18,106.89 118.18,106.56 118.05,106.43 117.84,106.43 117.68,106.27 117.67,106.26 117.65,106.26 117.47,106.26 117.19,105.97 117.03,105.97 116.93,106.08 116.93,106.34 117.01,106.53 116.97,106.73 116.96,106.74 116.96,106.89 117.03,106.96 117.26,106.96 117.29,106.95 117.3,106.94 117.53,106.82 117.78,106.87 117.84,106.92 117.9,106.98
GND on BOTTOM (solid shape): 126.85,134.31 126.85,133.34 126.68,133.17 126.68,127.48 126.09,126.89 126.07,126.89 125.76,126.66 125.85,126.28 125.86,126.26 125.86,126.24 125.86,126.15 125.86,126.13 125.84,126.11 125.66,125.84 125.78,125.54 125.81,125.46 125.78,125.39 125.58,125.19 125.41,125.19 125.3,125.29 125.3,134.08 125.76,134.54 126.63,134.54
GND on BOTTOM (solid shape): 11.49,121.05 11.49,120.54 11.72,120.31 11.72,119.76 11.71,119.73 11.68,119.72 11.41,119.45 11.44,119.08 11.45,119.06 11.44,119.03 11.35,118.94 11.26,118.8 11.23,118.63 11.23,118.61 11.26,118.45 11.34,118.31 11.37,118.24 11.34,118.17 11.32,118.15 10.57,118.15 10.54,118.16 10.52,118.2 10.52,118.74 10.83,119.04 10.83,119.68 10.5,120.01 10.5,121.08 10.65,121.23 11.31,121.23
GND on BOTTOM (solid shape): 132.24,158.57 135.26,158.57 135.27,158.55 135.58,158.55 136.18,157.96 136.81,157.96 137.14,157.63 137.14,156.38 136.96,156.2 135.29,156.2 134.68,155.59 134.68,154.2 134.26,153.78 134.24,153.77 134.22,153.76 134.02,153.73 133.86,153.61 133.84,153.59 133.82,153.59 133.74,153.59 133.46,153.31 133.46,151.2 133.46,151.2 133.46,151.15 133.46,151.15 133.46,151.02 133.41,150.97 132.57,150.97 132.3,151.24 132.3,153.68 132.29,153.69 132.29,156.36 131.63,157.02 128.43,157.02 128.28,156.86 128.28,156.59 128.26,156.55 128.23,156.53 127.77,156.53 127.69,156.61 127.69,157.6 127.74,157.65 128.28,157.65 128.76,158.13 128.76,158.54 129.11,158.9 131.91,158.9
GND on BOTTOM (solid shape): 148.81,159.54 149.4,159.54 149.56,159.38 149.66,159.38 149.66,159.37 150.17,159.37 150.21,159.36 150.22,159.32 150.22,159.18 150.21,159.14 150.17,159.13 149.59,159.13 148.96,158.5 148.96,155.72 149.04,155.63 149.04,154.67 148.8,154.43 147.01,154.43 147,154.43 146.87,154.45 146.74,154.43 146.73,154.43 146.39,154.43 146.39,150.59 146.16,150.36 142.58,150.36 142.4,150.54 142.4,155.82 141.41,156.81 138.16,156.81 138.16,156.33 138.14,156.3 138.11,156.28 137.62,156.28 137.5,156.41 137.5,157.42 137.57,157.5 137.65,157.5 137.67,157.47 138.08,157.47 138.59,157.98 138.59,158.52 138.77,158.69 145.12,158.69 145.34,158.92 145.37,158.92 146.01,159.56 148.8,159.56
GND on BOTTOM (solid shape): 152.94,74.65 152.94,69.46 152.46,68.98 152.03,68.98 152,69.02 148.56,69.02 147.81,69.77 147.81,73.45 148.14,73.78 151.21,73.78 151.44,74.01 151.9,74.01 151.9,73.98 151.91,73.93 151.92,73.87 151.95,73.82 151.98,73.78 152.01,73.73 152.06,73.7 152.1,73.67 152.16,73.65 152.21,73.63 152.27,73.63 152.32,73.63 152.38,73.64 152.43,73.66 152.48,73.68 152.52,73.72 152.56,73.76 152.6,73.8 152.62,73.85 152.64,73.9 152.66,73.95 152.66,74.01 152.66,74.07 152.64,74.12 152.62,74.17 152.6,74.22 152.56,74.26 152.52,74.3 152.48,74.34 152.43,74.36 152.38,74.38 152.32,74.39 152.27,74.39 152.21,74.39 152.16,74.37 152.1,74.35 152.06,74.32 152.01,74.29 151.98,74.24 151.95,74.2 151.92,74.15 151.91,74.09 151.9,74.04 151.9,74.01 151.44,74.01 151.49,74.06 151.49,74.44 152.03,74.98 152.61,74.98
GND on BOTTOM (solid shape): 119.84,166.17 119.86,166.16 119.88,166.15 120.01,166.02 120.02,166.01 120.02,165.99 120.02,165.12 120.02,165.1 120.01,165.08 119.43,164.5 119.41,164.48 119.41,164.45 119.08,164.12 119.07,164.11 119.05,164.11 118.97,164.11 118.94,164.09 118.92,164.06 118.92,163.53 118.92,163.51 118.91,163.5 118.84,163.43 118.83,163.42 118.81,163.42 118.57,163.42 118.55,163.41 118.53,163.4 118.11,162.98 118.09,162.97 118.07,162.96 117.35,162.96 117.33,162.97 117.31,162.98 117.28,163.01 117.27,163.03 117.26,163.05 117.26,163.8 117.27,163.82 117.3,163.84 117.96,163.84 117.98,163.85 118.01,163.86 118.89,164.75 118.9,164.76 118.9,164.78 118.9,166.11 118.92,166.15 118.95,166.17
GND on BOTTOM (solid shape): 9.48,113.12 11.6,113.12 12.26,112.99 12.82,112.62 13.19,112.06 13.32,111.4 13.32,109.27 12.31,109.27 12.31,111.4 12.1,111.9 11.6,112.11 7.71,112.11 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.11 1.41,112.11 1.41,113.3 1.4,113.31 1.4,113.46 0.92,113.94 0.54,113.94 0.49,113.99 0.49,114.88 0.51,114.9 3.18,114.9 3.64,114.45 4.53,114.45 5.44,115.36 7.25,115.36
GND on BOTTOM (solid shape): 180.89,25.12 180.91,25.11 180.93,25.09 181.24,24.94 181.54,25.09 181.56,25.11 181.58,25.12 181.9,25.12 181.92,25.11 181.93,25.1 182.23,24.96 182.52,25.1 182.53,25.11 182.56,25.12 182.86,25.12 182.88,25.11 182.9,25.1 183.19,24.96 183.48,25.1 183.5,25.11 183.52,25.12 183.85,25.12 183.87,25.11 183.89,25.1 184.18,24.96 184.47,25.1 184.49,25.11 184.51,25.12 189.11,25.12 189.29,24.94 189.29,23.88 174.12,23.88 174.03,23.8 174.03,22.8 173.92,22.69 173.11,22.69 172.97,22.83 172.97,24.39 173.06,24.42 173.14,24.48 180.04,24.48 180.38,24.82 180.4,24.83 180.42,24.84 180.65,24.9 180.8,25.08 180.82,25.11 180.85,25.12
GND on BOTTOM (solid shape): outline of 111 points within 108.37,156.85 117.1,167.08
GND on BOTTOM (solid shape): 13.75,99.24 13.75,95.6 8.01,89.86 8.01,86.46 6.15,84.6 6.14,84.6 6.14,82.23 5.93,82.01 5.9,82.02 5.66,82.05 5.43,81.97 5.43,89.45 5.13,90.16 4.42,90.46 4.19,90.46 4.12,90.46 3.53,90.46 3.53,91.09 3.53,93.75 3.41,94.22 3.1,94.58 2.82,94.71 2.52,94.76 2.4,94.76 1.7,95.05 1.41,95.75 1.41,96.69 4.89,96.69 4.89,96.5 5.1,96 5.6,95.79 7,95.79 7.19,95.82 7.37,95.89 7.62,96.15 7.71,96.5 7.71,96.69 9.87,96.69 11.6,96.69 12.1,96.9 12.31,97.4 12.31,99.66 13.32,99.66
GND on BOTTOM (solid shape): outline of 300 points within 2.31,53.36 16.24,76.28
GND on BOTTOM (solid shape): outline of 514 points within 193.55,83.33 244.39,198.19
GND on BOTTOM (solid shape): outline of 816 points within 79.3,64.82 149.96,76.44
GND on BOTTOM (solid shape): outline of 1366 points within 0.51,105.46 189.72,190.29
GND on BOTTOM (solid shape): outline of 2078 points within 2.31,0.51 232.79,81.55
GND on SVCC (solid shape): 139.63,121.71 139.63,121.39 138.28,120.04 137.83,120.04 137.6,120.27 137.6,121.63 138.03,122.07 139.27,122.07
GND on SVCC (solid shape): 168.24,88.67 168.43,88.61 168.62,88.67 171.84,88.67 172.22,88.31 172.6,88.67 173.18,88.67 173.41,88.59 173.64,88.67 180.57,88.67 181.06,88.18 181.06,86.49 170.95,76.38 170.5,76.31 170.43,75.86 168.25,73.68 167.17,73.68 166.73,74.12 166.73,82.01 166.71,82.11 166.66,82.19 166.17,82.67 166.09,82.73 165.99,82.75 165.79,82.75 165.79,82.8 165.79,87.69 166.76,88.67
GND on SVCC (solid shape): 207.19,35.68 207.19,35.53 207.22,35.42 207.28,35.34 206.73,34.78 206.7,34.74 206.69,34.69 206.69,30.27 206.53,30.12 203.38,30.12 203.33,30.11 203.29,30.08 203.12,29.9 203.09,29.87 203.08,29.81 203.08,28.61 202.6,28.13 202.58,28.1 202.57,28.06 202.57,26.12 202.17,25.72 201.57,25.72 201.17,26.13 201.13,26.15 201.09,26.16 200.33,26.16 200.18,26.3 200.18,27.36 200.94,28.12 200.96,28.15 200.97,28.19 200.97,29.48 200.96,29.52 200.94,29.56 200.69,29.81 200.69,30.15 200.84,30.3 201.75,30.3 201.79,30.3 201.83,30.33 202.06,30.55 202.08,30.59 202.09,30.63 202.09,31.43 202.08,31.48 202.06,31.51 201.91,31.66 201.87,31.69 201.83,31.69 200.57,31.69 200.53,31.69 200.49,31.66 199.79,30.96 199.28,30.96 199.29,30.99 199.29,31.03 199.29,31.18 199.49,31.38 199.91,31.46 199.99,31.88 204.02,35.91 206.96,35.91
GND on SVCC (solid shape): 52.25,52.01 52.25,50.78 50.63,49.15 50.16,49.08 50.04,48.62 49.54,48.37 49.71,47.84 49.71,45.24 49.75,45.04 49.86,44.87 50.88,43.86 51.05,43.75 51.24,43.71 53.74,43.71 54.11,43.44 54.47,43.71 55.35,43.71 55.75,43.3 55.82,42.85 56.27,42.79 56.72,42.34 56.68,42.07 56.83,41.85 56.83,37.69 56.77,37.48 56.83,37.28 56.83,35.03 56.36,34.56 49.16,34.56 48.49,35.24 48.57,35.51 48.44,35.76 48.44,43.33 48.45,43.4 48.44,43.47 48.44,48.83 51.45,51.84 51.7,51.96 51.82,52.2 51.83,52.22 52.04,52.22
GND on SVCC (solid shape): 219.92,152.44 219.92,117.45 210.44,107.97 209.76,107.97 209.4,108.23 209.04,107.97 208.34,107.97 207.96,108.35 207.57,107.97 201.44,107.97 196.63,112.78 196.54,113.19 196.13,113.28 195.36,114.05 195.25,114.36 194.94,114.47 192,117.41 191.89,117.76 191.54,117.87 188.63,120.78 188.58,120.82 188.53,120.86 188.53,129.39 188.56,129.56 188.53,129.73 188.53,138.32 188.51,138.42 188.45,138.5 188.01,138.94 187.9,139.27 187.57,139.38 187.56,139.39 187.48,139.45 187.38,139.47 177.09,139.47 176.72,139.77 176.34,139.47 175.63,139.47 175.44,139.65 175.19,139.72 174.51,139.72 174.2,140.03 174.1,140.21 173.92,140.31 173.26,140.97 173.1,141.08 172.9,141.12 169.96,141.12 169.73,141.19 169.5,141.12 165.88,141.12 165.74,141.14 165.6,141.12 161.05,141.12 160.2,141.96 160.2,162.37 162.67,164.83 162.76,164.9 162.83,164.99 168.54,170.71 201.65,170.71
GND on SVCC (solid shape): outline of 4932 points within 0.51,0.51 244.39,198.19
GND on IN1 (solid shape): 119.16,134.69 119.16,132.53 118.78,132.15 114.76,132.15 114.18,132.73 114.18,135.12 114.55,135.49 118.36,135.49
GND on IN1 (solid shape): 195.43,114.07 195.43,110.61 195.31,110.48 193.99,110.48 193.63,110.13 192.31,110.13 191.83,110.61 191.83,113.66 192.49,114.32 195.18,114.32
GND on IN1 (solid shape): 156.93,108.25 156.93,106.01 156.93,105.83 156.92,105.83 156.92,104.86 156.85,104.79 155.17,104.79 155.02,104.95 155.02,108.2 155.15,108.33 156.85,108.33
GND on IN1 (solid shape): 46.42,76.24 46.42,76.21 46.43,76.12 46.46,76.03 46.46,76.02 46.46,75.97 47.05,75.38 47.05,72.26 46.82,72.03 43.67,72.03 43.47,72.23 43.47,75.36 44.46,76.35 46.31,76.35
GND on IN1 (solid shape): 8.79,113.12 11.6,113.12 12.26,112.99 12.82,112.62 13.19,112.06 13.32,111.4 13.32,109.27 12.31,109.27 12.31,111.4 12.1,111.9 11.6,112.11 7.71,112.11 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.11 1.41,112.11 1.41,113.51 1.4,113.51 0.97,113.94 0.56,113.94 0.49,114.02 0.49,114.85 0.54,114.9 3.16,114.9 3.64,114.42 4.5,114.42 5.34,115.26 6.66,115.26
GND on IN1 (solid shape): outline of 5061 points within 0.51,0.51 244.39,198.19
GND on IN2 (solid shape): 156.93,108.25 156.93,104.87 156.85,104.79 155.17,104.79 155.02,104.95 155.02,108.2 155.15,108.33 156.85,108.33
GND on IN2 (solid shape): 195.51,114.02 195.51,110.56 195.18,110.23 192.56,110.23 191.9,110.89 191.9,113.71 192.49,114.29 195.23,114.29
GND on IN2 (solid shape): 118.68,134.72 119.02,134.72 119.28,134.46 119.28,132.92 119.27,132.88 119.23,132.87 114.38,132.87 114.35,132.88 114.33,132.92 114.33,135.17 114.34,135.18 118.23,135.18
GND on IN2 (solid shape): 46.42,76.26 46.43,76.24 46.43,76.23 46.43,76.13 46.46,76.03 46.46,76.02 46.46,75.89 46.64,75.71 46.89,75.71 46.95,75.66 46.95,75.66 46.95,72.38 46.57,72 43.52,72 43.29,72.23 43.29,75.08 44.61,76.4 46.28,76.4
GND on IN2 (solid shape): 8.12,113.61 8.34,113.39 8.51,113.12 11.6,113.12 12.26,112.99 12.82,112.62 13.19,112.06 13.32,111.4 13.32,109.27 12.31,109.27 12.31,111.4 12.1,111.9 11.6,112.11 7.71,112.11 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.11 1.41,112.11 1.41,113.48 1.28,113.61 1.28,113.63 0.97,113.94 0.54,113.94 0.49,113.99 0.49,114.8 0.56,114.88 3.18,114.88 3.64,114.42 4.45,114.42 5.19,115.16 6.57,115.16
GND on IN2 (solid shape): outline of 619 points within 2.31,19.77 16.42,45.63
GND on IN2 (solid shape): outline of 656 points within 1.41,55.37 16.31,99.66
GND on IN2 (solid shape): outline of 4032 points within 0.51,0.51 244.39,198.19
GND on SGND (solid shape): outline of 4109 points within 0.51,0.51 244.39,198.19
VCCGT_PHASE1 on BOTTOM (solid shape): 123.42,163.42 123.42,162.3 122.92,161.79 122.03,161.79 121.04,160.8 120.82,160.8 120.78,160.82 120.77,160.85 120.77,161.42 121.76,162.41 122.01,162.41 122.33,162.73 122.33,163.42 122.41,163.49 123.35,163.49
VCCGT_PHASE1 on BOTTOM (solid shape): 122.54,155.72 122.54,151.96 122.41,151.84 120.75,151.84 119.92,152.66 119.92,154.39 119.36,154.39 119.36,152.66 119.36,152.55 118.83,152.01 116.8,152.01 116.34,152.47 116.34,155.17 116.43,155.34 116.47,155.53 116.47,155.55 117,156.08 118.75,156.08 118.95,156.28 118.95,156.74 119.08,156.86 121.39,156.86
VCCGT_PHASE2 on BOTTOM (solid shape): 131.53,163.49 131.53,161.59 130.69,160.75 130.51,160.75 130.47,160.77 130.46,160.8 130.46,161.33 130.44,161.36 130.44,163.47 130.54,163.57 131.45,163.57
VCCGT_PHASE2 on BOTTOM (solid shape): 132.01,155.91 132.01,151.43 131.78,151.2 129.37,151.2 129.01,151.56 129.01,152.59 129.01,152.59 129.01,154.31 128.45,154.31 128.45,152.59 128.45,152.32 127.97,151.84 125.53,151.84 125.36,152.01 125.36,155.29 125.71,155.65 128.43,155.65 128.73,155.95 128.73,156.74 128.8,156.8 131.12,156.8
VCCGT_VBST1 on BOTTOM (solid shape): 121.98,163.47 121.98,162.68 121.88,162.58 121.57,162.58 120.68,161.69 120.33,161.69 120.02,161.39 120.02,161.32 120.02,160.88 120.01,160.84 119.97,160.83 119.82,160.83 119.78,160.84 119.77,160.88 119.77,161.37 119.77,161.51 120.91,162.66 120.91,163.44 120.96,163.49 121.95,163.49
VCCGT_VBST2 on BOTTOM (solid shape): 130.07,163.51 130.09,163.51 130.1,163.49 130.1,161.81 130.1,161.79 130.09,161.78 129.74,161.43 129.73,161.41 129.72,161.39 129.72,161.33 129.71,161.33 129.71,160.8 129.7,160.77 129.66,160.75 129.51,160.75 129.47,160.77 129.46,160.8 129.46,161.33 129.44,161.33 129.44,162 129.44,162.02 129.43,162.04 129.1,162.36 129.09,162.38 129.09,162.4 129.09,163.46 129.1,163.5 129.14,163.51
VCCGT_VCC1 on BOTTOM (solid shape): 118.7,163.14 118.72,163.13 118.74,163.12 118.91,162.96 118.92,162.94 118.92,162.92 118.92,162.6 118.93,162.6 118.93,162.39 118.92,162.37 118.91,162.36 118.81,162.27 118.76,162.2 118.62,162.06 118.61,162.04 118.6,162.03 118.6,160.69 118.55,160.64 118.45,160.64 118.44,160.65 118.04,160.65 117.99,160.6 117.99,160.45 118.04,160.4 118.6,160.4 118.6,160.17 118.59,160.15 117.79,160.15 117.68,160.25 117.67,160.27 117.67,160.29 117.67,161.3 117.66,161.32 117.65,161.34 117.37,161.62 117.36,161.64 117.35,161.66 117.35,162.58 117.36,162.6 117.37,162.62 117.44,162.69 117.46,162.7 117.48,162.71 118.02,162.71 118.04,162.71 118.06,162.72 118.22,162.88 118.23,162.9 118.27,162.9 118.3,162.91 118.32,162.95 118.32,162.99 118.33,163 118.46,163.12 118.47,163.13 118.49,163.14
VCCGT_VCC2 on BOTTOM (solid shape): 126.99,161.03 128.15,161.03 128.3,160.88 128.3,160.65 128.29,160.62 128.25,160.6 127.74,160.6 127.74,160.36 128.25,160.36 128.29,160.34 128.3,160.31 128.3,160.15 128.29,160.12 128.25,160.1 127.73,160.1 127.73,160.09 126.17,160.09 125.3,160.95 125.3,161.21 125.43,161.34 126.68,161.34
VCCSA_SW on BOTTOM (solid shape): 154.03,163.32 154.03,162.15 152.66,160.78 152.41,160.78 152.39,160.79 152.39,161.63 152.66,161.9 152.66,161.97 152.91,162.22 152.91,163.29 152.99,163.37 153.98,163.37
VCCSA_SW on BOTTOM (solid shape): 153.88,155.95 153.88,149.12 153.55,148.79 151.36,148.79 151.06,149.09 151.06,151.43 151.04,151.45 151.04,151.65 150.48,151.65 150.48,151.43 150.45,151.4 150.45,149.8 150.02,149.37 148.19,149.37 147.96,149.6 147.96,152.9 149.46,154.4 149.46,155.49 150.53,156.56 150.53,156.64 150.7,156.81 153.02,156.81
VCCSA_VBST on BOTTOM (solid shape): 152.45,163.36 152.46,163.35 152.48,163.34 152.52,163.31 152.53,163.29 152.53,163.27 152.53,161.95 152.36,161.78 152.07,161.78 151.66,161.38 151.65,161.36 151.64,161.34 151.64,160.83 151.63,160.79 151.59,160.78 151.44,160.78 151.41,160.79 151.39,160.83 151.39,161.28 151.42,161.31 151.42,161.36 151.36,161.41 151.36,163.24 151.37,163.26 151.38,163.28 151.44,163.34 151.46,163.35 151.48,163.36
VCCSA_VCC on BOTTOM (solid shape): 148.9,162.06 148.94,162.05 148.95,162.01 148.95,161.58 148.96,161.57 148.97,161.55 149.37,161.15 149.39,161.14 149.4,161.13 149.95,161.13 149.97,161.13 149.98,161.12 150.21,160.89 150.22,160.88 150.22,160.86 150.22,160.69 150.18,160.65 149.69,160.65 149.64,160.6 149.64,160.4 149.69,160.34 150.18,160.34 150.22,160.3 150.22,160.17 150.21,160.13 150.17,160.12 149.66,160.12 149.66,160.12 149.2,160.12 149.18,160.11 149.17,160.1 148.89,159.83 148.87,159.82 148.85,159.81 147.28,159.81 147.08,160.01 147.08,160.74 147.78,161.44 147.78,162 147.79,162.02 147.83,162.06 147.85,162.06
VDD10 on TOP (solid shape): 45.9,69.87 45.9,67.33 45.65,67.08 45.01,67.08 44.76,67.33 44.76,68.47 44.38,68.85 44.38,70 44.51,70.12 45.65,70.12
VDD10 on TOP (solid shape): 35.17,76.3 35.21,76.3 35.44,76.07 35.44,75.64 35.36,75.56 33.41,75.56 32.14,74.29 32.14,73.73 32.02,73.61 31.07,73.61 31.07,73.6 29.34,73.6 29.19,73.76 29.19,74.8 30.94,76.55 34.91,76.55
VDD10 on TOP (solid shape): 43.49,76.85 43.49,76.27 43.41,76.2 42.94,76.2 42.43,75.68 42.43,74.3 42.08,73.95 41.5,73.95 41.5,73.96 40.53,73.96 40.5,73.98 40.48,74.01 40.48,74.11 40.5,74.15 40.53,74.16 41.51,74.16 42.01,74.67 42.01,76.53 42.45,76.97 43.36,76.97
VDD10 on TOP (solid shape): 39,70.06 39,69.06 39.07,68.99 39.07,68.94 39.08,68.94 39.11,68.91 39.11,68.49 39.13,68.47 39.13,68.28 39.48,67.93 39.48,67.55 39.38,67.45 38.75,67.45 38.67,67.54 38.67,68.32 38.8,68.45 38.8,69.07 38.8,69.07 38.8,70.04 38.82,70.07 38.85,70.09 38.98,70.09
VDD10 on BOTTOM (solid shape): outline of 230 points within 37.04,67.96 45.2,77.62
VDD10 on IN1 (solid shape): 37.58,77.25 37.58,76.89 36.25,75.56 35.13,75.56 34.89,75.81 34.89,76.2 35.19,76.5 35.49,76.5 36.4,77.41 37.42,77.41
VDDREG on TOP (solid shape): 39.75,70.09 39.79,70.07 39.8,70.03 39.8,69.07 39.82,69.05 39.82,68.89 41.15,67.57 41.26,67.57 41.27,67.56 41.54,67.56 41.56,67.53 41.56,66.9 41.85,66.62 42.38,66.62 42.62,66.37 42.62,65.54 42.63,65.54 42.63,65.3 42.53,65.21 41.08,65.21 41.08,65.2 40.61,65.2 40.59,65.19 39.85,65.19 39.77,65.28 39.77,66.06 40.31,66.61 40.31,66.68 40.33,66.69 40.33,67.26 40.33,67.26 40.33,67.33 39.86,67.79 39.86,68.09 39.58,68.37 39.58,69.05 39.6,69.07 39.6,70.03 39.62,70.07 39.65,70.09
VIN on TOP (solid shape): 61.37,76.86 62.49,76.86 62.62,76.73 62.62,75.41 62.36,75.15 60.53,75.15 59.57,76.11 59.57,76.76 59.85,77.03 61.19,77.03
VIN on TOP (solid shape): 144.23,161.61 144.23,159.2 143.92,158.9 139.33,158.9 139.07,158.64 139.07,157.91 138.99,157.83 138.16,157.83 138.03,157.96 138.03,159.63 138.77,160.37 141.38,160.37 142.91,161.89 143.95,161.89
VIN on TOP (solid shape): 54.36,68.65 57.13,68.65 57.38,68.4 57.38,63.9 57.18,63.7 56.15,63.7 54.4,61.95 52.8,61.95 52.65,62.1 52.65,63.74 52.52,63.88 51.59,63.88 51.42,64.05 51.42,67.84 51.57,67.99 53.22,67.99 53.42,68.19 53.42,68.8 53.52,68.9 54.11,68.9
VIN on TOP (solid shape): 54.26,80.06 54.26,78.12 55.17,77.21 55.17,74.06 54.92,73.81 53.14,73.81 52.89,74.06 50.6,74.06 50.35,74.31 50.35,76.85 50.02,77.19 48.42,77.19 48.29,77.31 48.29,78.46 48.52,78.68 49.87,78.68 50.22,79.04 50.22,79.88 50.39,80.04 52.6,80.04 52.9,80.35 53.97,80.35
VIN on TOP (solid shape): 118.27,162.4 118.27,160.4 118.22,160.34 117.81,160.34 117.76,160.4 117.76,160.6 117.51,160.85 117.51,160.86 117.38,160.99 117.38,161.11 117.34,161.15 117.33,161.16 117.23,161.34 117.05,161.44 117.04,161.45 117.02,161.46 116.91,161.46 115.88,161.46 115.83,161.51 115.83,162.17 116.52,162.86 117.81,162.86
VIN on TOP (solid shape): 212.53,82.27 212.55,82.27 212.69,82.13 212.69,71.62 212.13,71.06 206.86,71.06 206.46,71.47 206.46,80.72 205.7,81.48 200.59,81.48 200.58,81.46 200.12,81.46 198.74,80.08 185.45,80.08 183.09,77.72 183.09,73.5 182.12,72.54 178.16,72.54 176.84,73.86 176.84,79.37 182.28,84.81 195,84.81 195.04,84.84 196.08,84.84 197.82,86.58 208.21,86.58
