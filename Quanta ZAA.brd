# Allegro board Quanta ZAA.brd (continued)
## Nets (continued)
M_B_CB1: JDIM2.91 R10936.2
M_B_CB2: JDIM2.101 R10933.2
M_B_CB3: JDIM2.105 R10939.2
M_B_CB4: JDIM2.88 R10941.2
M_B_CB5: JDIM2.87 R10922.2
M_B_CB6: JDIM2.100 R10942.2
M_B_CB7: JDIM2.104 R10925.2
M_B_CKE0: JDIM2.109 U35.AN56
M_B_CKE1: JDIM2.110 U35.AP55
M_B_CLK0: JDIM2.137 U35.AP45
M_B_CLK0#: JDIM2.139 U35.AN45
M_B_CLK1: JDIM2.138 U35.AP46
M_B_CLK1#: JDIM2.140 U35.AN46
M_B_CS#0: JDIM2.149 U35.BB42
M_B_CS#1: JDIM2.157 U35.AY42
M_B_DQ0: JDIM2.4 U35.AF65
M_B_DQ1: JDIM2.8 U35.AF64
M_B_DQ2: JDIM2.20 U35.AK65
M_B_DQ3: JDIM2.21 U35.AK64
M_B_DQ4: JDIM2.7 U35.AF66
M_B_DQ5: JDIM2.3 U35.AF67
M_B_DQ6: JDIM2.17 U35.AK67
M_B_DQ7: JDIM2.16 U35.AK66
M_B_DQ8: JDIM2.25 U35.AF70
M_B_DQ9: JDIM2.24 U35.AF68
M_B_DQ10: JDIM2.37 U35.AH71
M_B_DQ11: JDIM2.38 U35.AH68
M_B_DQ12: JDIM2.29 U35.AF71
M_B_DQ13: JDIM2.28 U35.AF69
M_B_DQ14: JDIM2.42 U35.AH70
M_B_DQ15: JDIM2.41 U35.AH69
M_B_DQ16: JDIM2.45 U35.AT66
M_B_DQ17: JDIM2.49 U35.AU66
M_B_DQ18: JDIM2.58 U35.AP65
M_B_DQ19: JDIM2.62 U35.AN65
M_B_DQ20: JDIM2.46 U35.AN66
M_B_DQ21: JDIM2.50 U35.AP66
M_B_DQ22: JDIM2.63 U35.AT65
M_B_DQ23: JDIM2.59 U35.AU65
M_B_DQ24: JDIM2.67 U35.AT61
M_B_DQ25: JDIM2.71 U35.AU61
M_B_DQ26: JDIM2.83 U35.AP60
M_B_DQ27: JDIM2.80 U35.AN60
M_B_DQ28: JDIM2.70 U35.AN61
M_B_DQ29: JDIM2.66 U35.AP61
M_B_DQ30: JDIM2.79 U35.AT60
M_B_DQ31: JDIM2.84 U35.AU60
M_B_DQ32: JDIM2.174 U35.AU40
M_B_DQ33: JDIM2.170 U35.AT40
M_B_DQ34: JDIM2.182 U35.AT37
M_B_DQ35: JDIM2.186 U35.AU37
M_B_DQ36: JDIM2.173 U35.AR40
M_B_DQ37: JDIM2.169 U35.AP40
M_B_DQ38: JDIM2.187 U35.AP37
M_B_DQ39: JDIM2.183 U35.AR37
M_B_DQ40: JDIM2.194 U35.AT33
M_B_DQ41: JDIM2.190 U35.AU33
M_B_DQ42: JDIM2.207 U35.AU30
M_B_DQ43: JDIM2.203 U35.AT30
M_B_DQ44: JDIM2.191 U35.AR33
M_B_DQ45: JDIM2.195 U35.AP33
M_B_DQ46: JDIM2.204 U35.AR30
M_B_DQ47: JDIM2.208 U35.AP30
M_B_DQ48: JDIM2.211 U35.AU27
M_B_DQ49: JDIM2.215 U35.AT27
M_B_DQ50: JDIM2.225 U35.AT25
M_B_DQ51: JDIM2.224 U35.AU25
M_B_DQ52: JDIM2.212 U35.AP27
M_B_DQ53: JDIM2.216 U35.AN27
M_B_DQ54: JDIM2.228 U35.AN25
M_B_DQ55: JDIM2.229 U35.AP25
M_B_DQ56: JDIM2.233 U35.AT22
M_B_DQ57: JDIM2.232 U35.AU22
M_B_DQ58: JDIM2.245 U35.AU21
M_B_DQ59: JDIM2.249 U35.AT21
M_B_DQ60: JDIM2.236 U35.AN22
M_B_DQ61: JDIM2.237 U35.AP22
M_B_DQ62: JDIM2.250 U35.AP21
M_B_DQ63: JDIM2.246 U35.AN21
M_B_DQS0: JDIM2.13 U35.AH65
M_B_DQS1: JDIM2.34 U35.AG70
M_B_DQS2: JDIM2.55 U35.AR65
M_B_DQS3: JDIM2.76 U35.AR60
M_B_DQS4: JDIM2.179 U35.AR38
M_B_DQS5: JDIM2.200 U35.AR32
M_B_DQS6: JDIM2.221 U35.AR27
M_B_DQS7: JDIM2.242 U35.AR21
M_B_DQS8: JDIM2.97 R10926.2
M_B_DQS#0: JDIM2.11 U35.AH66
M_B_DQS#1: JDIM2.32 U35.AG69
M_B_DQS#2: JDIM2.53 U35.AR66
M_B_DQS#3: JDIM2.74 U35.AR61
M_B_DQS#4: JDIM2.177 U35.AT38
M_B_DQS#5: JDIM2.198 U35.AT32
M_B_DQS#6: JDIM2.219 U35.AR25
M_B_DQS#7: JDIM2.240 U35.AR22
M_B_DQS#8: JDIM2.95 R10929.2
M_B_EVENT#: JDIM2.134 R10921.1 R10928.2
M_B_ODT0_DIMM: JDIM2.155 U35.BA42
M_B_ODT1_DIMM: JDIM2.161 U35.AW42
M_B_PARITY: JDIM2.143 U35.AP43
M_B_RAS#: JDIM2.152 U35.AW44
M_B_WE#: JDIM2.151 U35.AY44
MAIND: PC103.2 PQ3.3 PQ26.4 PQ6058.3 PQ6065.2 PR148.2
MAINON: R389.1 R791.2 U45.30 U49.1 U1006.10
MAINON_ON_G: PQ3.2 PQ4.2 PQ5.2 PQ10.2 PQ11.3 PQ6066.2 PR150.1 PR151.2
MAINON_R: PQ11.2 PR37.1 PR147.1 PR257.2 PR6291.2 PR6294.2 R791.1 U49.4
MBCLK: PC9.1 PD2.1 PR7.2 PR178.1 R731.1 U45.110
MBDATA: PC8.1 PD1.1 PR6.2 PR177.1 R732.1 U45.111
MDI_0+: U15.1 U42.11
MDI_0-: U15.2 U42.12
MDI_1+: U15.4 U42.8
MDI_1-: U15.5 U42.9
MDI_2+: U15.6 U42.5
MDI_2-: U15.7 U42.6
MDI_3+: U15.9 U42.2
MDI_3-: U15.10 U42.3
ME_WR#: R737.1 U45.109
MIC2-VREFO: R407.1 R424.1 U23.29
MOD_EN_5V: C752.1 Q34.3 Q37.6 R686.1
MPHY_EXT_PWR: R195.2 U35.AM10
MULTISTRAP_REF_GND: R4344.2 R4345.2 U3002.J1
MX0: C4809.1 CN20.1 CN2019.1 RP1.2 U45.58
MX1: C4810.1 CN20.2 CN2019.2 RP1.4 U45.59
MX2: C4811.1 CN20.3 CN2019.3 RP1.3 U45.60
MX3: C4812.1 CN20.4 CN2019.4 RP1.1 U45.61
MX4: C4793.1 CN20.5 CN2019.5 RP1.9 U45.62
MX5: C4794.1 CN20.6 CN2019.6 RP1.7 U45.63
MX6: C4795.1 CN20.7 CN2019.7 RP1.8 U45.64
MX7: C4796.1 CN20.8 CN2019.8 RP1.6 U45.65
MY0: C4800.1 CN20.26 CN2019.26 U45.36
MY1: C4799.1 CN20.25 CN2019.25 U45.37
MY2: C4798.1 CN20.24 CN2019.24 U45.38
MY3: C4797.1 CN20.23 CN2019.23 U45.39
MY4: C4804.1 CN20.22 CN2019.22 U45.40
MY5: C4803.1 CN20.21 CN2019.21 U45.41
MY6: C4802.1 CN20.20 CN2019.20 U45.42
MY7: C4801.1 CN20.19 CN2019.19 U45.43
MY8: C4808.1 CN20.18 CN2019.18 U45.44
MY9: C4807.1 CN20.17 CN2019.17 U45.45
MY10: C4806.1 CN20.16 CN2019.16 U45.46
MY11: C4805.1 CN20.15 CN2019.15 U45.51
MY12: C4815.1 CN20.14 CN2019.14 U45.52
MY13: C4816.1 CN20.13 CN2019.13 U45.53
MY14: C4814.1 CN20.12 CN2019.12 U45.54
MY15: C4813.1 CN20.11 CN2019.11 U45.55
MY16: CN20.10 CN2019.10 U45.56
MY17: CN20.9 CN2019.9 U45.57
NBSWON#: C785.2 C805.1 R265.2 R730.1 R753.1 R776.2 R11107.2 SW2.1 SW2.2 U45.107
NGFF1_RST#_SSD: CN23.50 R960.1
NGFF3_PEDET: CN23.69 Q59.2 R961.2 R968.2
NGFF_SATA_DET: Q59.3 R11283.1 U35.G4
NGFF_SSD_CLK: CN23.55 R11113.1
NGFF_SSD_CLK#: CN23.53 R11112.1
NGFF_SSD_CLK#_C: R11112.2 U35.B42
NGFF_SSD_CLK_C: R11113.2 U35.A42
NV_PLLVDD: C4204.1 C4205.2 L4200.2 U3002.AD8
ODD_EN: Q37.5 R692.1 R703.1 R704.1
ODD_EN_Q: Q36.2 Q37.2 Q37.3 R695.2
ODD_POWER: R704.2 U45.71
ODD_PRSNT#: C802.1 R217.2 U35.AB2
ODD_PRSNT#_C: C330.1 CN9.8 R216.1 R217.1
PCBEEP: C476.1 U23.12
PCBEEP_EC: D10.2 U45.34
PCH_ACPRESENT: R651.2 R676.2 U35.AY15
PCH_AZ_CODEC_BITCLK: C493.2 C739.1 R644.1 U23.6
PCH_AZ_CODEC_RST#: Q29.1 R660.1 U23.11
PCH_AZ_CODEC_SDIN0: R359.2 U35.BA21
PCH_AZ_CODEC_SDOUT: R645.1 U23.5
PCH_AZ_CODEC_SYNC: R667.1 U23.10
PCH_BATLOW#: R628.2 TP74.1 U35.AU13
PCH_BLON: R67.1 U35.R12
PCH_BLON_C: Q3.5 R65.2 R66.2 R67.2
PCH_BLON_R: R66.1 U45.88
PCH_BRIGHT: CN5.27 R546.1 U35.R11
PCH_DP_HPD: R564.2 R10846.1 U35.L7
PCH_MBCLK0_R: Q32.6 R578.2 U35.R7
PCH_MBDAT0_R: Q32.3 R580.2 U35.R8
PCH_ODD_EN: R703.2 U35.N12
PCH_PWRBTN#: R677.2 U35.BA15
PCH_PWROK: R103.2 R647.2 R648.1 U45.78
PCH_RSMRST#: R642.1 R655.2 R661.2 U35.AY17
PCH_SLP_A#: R273.2 U35.AN16
PCH_SLP_LAN#: TP30.1 U35.AW15
PCH_SLP_S5#: R279.2 U35.AY16
PCH_SLP_SUS#: TP4369.1 U35.AN15
PCH_SLP_WLAN#: TP23.1 U35.BB17
PCH_SPI_CLK: C747.1 R684.2 U35.AV2
PCH_SPI_CLK_EC: C4726.1 R687.1 U45.105
PCH_SPI_CS0#: R602.2 U35.AU3 U41.1
PCH_SPI_IO2: R589.1 U35.AW2
PCH_SPI_IO3: R239.1 U35.AU4
PCH_SPI_SI: R691.2 U35.AV3
PCH_SPI_SI_EC: R654.1 R735.1 U45.102
PCH_SPI_SO: R650.1 U35.AW3
PCH_SPI_SO_EC: R588.1 R736.1 U45.103
PCH_SUSPWRACK: R11114.2 R11140.1 U45.15
PCH_TRST#: R534.2 U35.B59 U35.C61
PCH_TYPEC_UPFB#: R11251.1 R11252.1 U35.L6
PCH_VRALERT#: R211.2 TP19.1 U35.AM11
PCI_PLTRST#: U14.1 U14.2 U35.AN10
PCIE_CLKREQ_NGFF_SSD#: R11110.2 R11111.1
PCIE_CLKREQ_NGFF_SSD#_R: CN23.52 R11110.1
PCIE_CLKREQ_WLAN#: Q23.3 R224.1 R241.1 R253.1
PCIE_LAN_WAKE#: R244.1 R250.1 R713.2 U35.BB15
PCIE_LAN_WAKE#_R: Q39.1 R702.2 R709.1 U15.39
PCIE_RCOMPN: R562.2 U35.F5
PCIE_RCOMPP: R562.1 U35.E5
PCIE_REQ_LAN#_R: Q25.1 R276.1 R277.2 U15.29
PCIE_RX5+_LAN: C4601.2 U35.E23
PCIE_RX5+_LAN_C: C4601.1 U15.25
PCIE_RX5-_LAN: C4602.2 U35.E22
PCIE_RX5-_LAN_C: C4602.1 U15.26
PCIE_RX6+_WLAN: CN10.41 U35.E25
PCIE_RX6-_WLAN: CN10.43 U35.F25
PCIE_TX5+: C669.1 U35.A23
PCIE_TX5+_LAN: C669.2 U15.21
PCIE_TX5-: C668.1 U35.B23
PCIE_TX5-_LAN: C668.2 U15.22
PCIE_TX6+: C649.1 U35.C23
PCIE_TX6+_WLAN: C649.2 CN10.35
PCIE_TX6-: C648.1 U35.D23
PCIE_TX6-_WLAN: C648.2 CN10.37
PCLK_TPM: R626.1 U44.19
PD#: C494.1 D15.2 D16.2 R369.1 R372.2 U23.47
PEG_RX0: C4015.1 U35.G13
PEG_RX1: C4017.1 U35.F11
PEG_RX2: C4020.1 U35.G16
PEG_RX3: C4022.1 U35.F15
PEG_RX#0: C4016.1 U35.H13
PEG_RX#1: C4018.1 U35.G11
PEG_RX#2: C4021.1 U35.H16
PEG_RX#3: C4023.1 U35.G15
PEG_RXN0_C: C4016.2 U3002.AJ14
PEG_RXN1_C: C4018.2 U3002.AG14
PEG_RXN2_C: C4021.2 U3002.AJ15
PEG_RXN3_C: C4023.2 U3002.AK16
PEG_RXP0_C: C4015.2 U3002.AK14
PEG_RXP1_C: C4017.2 U3002.AH14
PEG_RXP2_C: C4020.2 U3002.AK15
PEG_RXP3_C: C4022.2 U3002.AL16
PEG_TX0: C652.1 U3002.AN12
PEG_TX1: C655.1 U3002.AN14
PEG_TX2: C662.1 U3002.AP14
PEG_TX3: C660.1 U3002.AN15
PEG_TX#0: C653.2 U3002.AM12
PEG_TX#1: C656.1 U3002.AM14
PEG_TX#2: C661.1 U3002.AP15
PEG_TX#3: C654.1 U3002.AM15
PEGX_RST#: Q4301.2 R4004.1 R4005.2 R4007.1 U3002.AJ12 U4002.4
PEX_CLKREQ#: Q4002.1 R4008.1 U3002.AK12
PEX_PLLVDD: C4036.1 C4037.2 C4040.1 R4010.2 U3002.AG26
PEX_TERMP: R4009.2 U3002.AP29
PEX_TSTCLK: R4006.2 U3002.AJ26
PEX_TSTCLK#: R4006.1 U3002.AK26
PIRQA#: R631.1 U35.BB11
PLLVDD: C4208.1 C4209.1 C4210.2 C4211.2 L4201.2 U3002.AD7 U3002.AE8
PLTRST#: C4030.2 R214.1 R671.1 R742.1 R749.1 R960.2 R11261.1 U14.4 U4001.2
PLTRST#_EC: C822.1 R749.2 U45.22
PM_THRMTRIP#: R10890.2 R10921.2
PMON: PC7.2 PR25.2 PR172.1 PR342.2
POA_AUTH_ERR: R11295.2 U45.48
POA_EN#: R11293.2 U45.83
POA_FP_PWREN#: R11297.1 U45.76
POA_POWERREQ: R11296.2 U45.20
POA_PWR: C3001.2 Q75.1 R866.1 R2854.1 R11288.1 R11289.1 R11290.1
POA_PWR_INT#: R11294.2 U45.19
PROC_PWRGD: R544.2 R554.1 U35.A68
PROCHOT_EC: Q30.2 R380.2 U45.17
PS_FB_CLAMP: R856.1 U3002.E1
PTP_PWR_EN#: R754.1 U45.125
PWM1_B: PR27.1 PR228.1
PWM2_B: PR29.1 PR233.1
PWM-VID: PR256.1 U3002.M5
PWM_A: PR43.2 PR237.1
PWM_C: PR47.2 PR239.1
PWRLED#: R426.1 R432.1 R436.1 U45.24
R_SPK+: R419.1 U23.45
R_SPK+_1: C551.1 CN18.1 R419.2
R_SPK-: R414.1 U23.44
R_SPK-_1: C548.1 CN18.2 R414.2
RAM_ID1: R610.2 R611.1 U35.AP2
RAM_ID2: R612.2 R613.1 U35.AP1
RAM_ID3: R614.2 R615.1 U35.AP3
REGN6V: PC122.1 PR1.1 PU5.24
REGOUT: C363.2 R246.1 U15.36
RF_EN: CN10.56 R774.2
RING2: R424.2 R425.1 U23.17
RING2_R: C554.1 CN2020.19 CN2020.20 CN2020.21 R425.2
ROM_SCLK: R4307.1 R4315.2 U3002.H4
ROM_SI: R4305.1 R4313.2 U3002.H5
ROM_SO: R4306.1 R4314.2 U3002.H7
RSET: R11264.2 U15.47
RSMRST#: R655.1 U45.112
RST_MON#: R4007.2 R11108.1 U4001.4
RTC_RST#: C380.1 J1.1 Q6060.3 R268.2 R299.2 U35.AM16
RTC_X1: C351.2 R255.1 U35.AM18 Y2.1
RTC_X2: C362.2 R255.2 U35.AM20 Y2.2
S5_ON: PQ9.2 PQ13.2 PR69.1 PR6285.1 PR6293.1 PR6299.1 R741.1 U45.100
SATA_DEVSLP1: R574.1 U35.J2
SATA_RXN0: C507.2 U35.F20
SATA_RXN0_C: C507.1 CN14.5
SATA_RXN1: C744.2 U35.G21
SATA_RXN1_C: C744.1 CN9.5
SATA_RXN3/PEG_RXN9_L0: R959.2 U35.E28
SATA_RXN3/PEG_RXN9_L0_N: CN23.31 R959.1
SATA_RXN3/PEG_RXN10_L1: R11062.2 U35.E30
SATA_RXN3/PEG_RXN10_L1_N: CN23.43 R11062.1
SATA_RXP0: C504.2 U35.E20
SATA_RXP0_C: C504.1 CN14.6
SATA_RXP1: C743.2 U35.F21
SATA_RXP1_C: C743.1 CN9.6
SATA_RXP3/PEG_RXP9_L0: R958.2 U35.E27
SATA_RXP3/PEG_RXP9_L0_N: CN23.29 R958.1
SATA_RXP3/PEG_RXP10_L1: R11061.2 U35.F30
SATA_RXP3/PEG_RXP10_L1_N: CN23.41 R11061.1
SATA_TXN0: C513.2 U35.B21
SATA_TXN0_C: C513.1 CN14.3
SATA_TXN1: C749.2 U35.D21
SATA_TXN1_C: C749.1 CN9.3
SATA_TXN3/PEG_TXN9_L0: C1176.1 U35.D24
SATA_TXN3/PEG_TXN9_L0_N: C1176.2 CN23.35
SATA_TXN3/PEG_TXN10_L1: C4664.1 U35.A25
SATA_TXN3/PEG_TXN10_L1_N: C4664.2 CN23.47
SATA_TXP0: C522.2 U35.A21
SATA_TXP0_C: C522.1 CN14.2
SATA_TXP1: C751.2 U35.C21
SATA_TXP1_C: C751.1 CN9.2
SATA_TXP3/PEG_TXP9_L0: C1177.1 U35.C24
SATA_TXP3/PEG_TXP9_L0_N: C1177.2 CN23.37
SATA_TXP3/PEG_TXP10_L1: C4665.1 U35.B25
SATA_TXP3/PEG_TXP10_L1_N: C4665.2 CN23.49
SATAGP0: R568.2 R570.2 U35.H2
SATAGP1: R569.1 U35.H3
SB_ACDC: R676.1 U45.84
SD_CLK_R: CN4.5 R11141.1
SEN_A: R1438.2 U5.J10 U7.J10
SEN_B: R1323.2 U3.J10 U4.J10
SENSEA: R378.2 R383.2 U23.13
SIO_A20GATE: TP77.1 U45.126
SIO_EXT_SCI#: R571.1 R781.1 U45.23
SIO_RCIN#: R652.1 U45.4
SLEEVE: R407.2 R408.1 U23.18
SLEEVE_R: C547.1 CN2020.16 CN2020.17 CN2020.18 R408.2
SM_RCOMP_0: R685.2 U35.AR18
SM_RCOMP_1: R678.2 U35.AT18
SM_RCOMP_2: R681.2 U35.AU18
SMB1ALERT#: R205.1 R218.2 U12.1 U35.AM7
SMB_ME1_CLK: R171.2 U35.W3
SMB_ME1_DAT: R175.2 U35.V3
SMBALERT#: R160.1 U35.R10
SML0ALERT#: R586.2 U35.W1
SP1: R11254.1 U15.14
SP1=SD_D1: C4611.1 CN4.8 R11254.2
SP2: R11253.1 U15.15
SP2=SD_D0=MS_D1: C4612.1 CN4.7 R11253.2
SP3: R11255.1 U15.16
SP3=SD_CLK=MS_D0: C4616.1 R11141.2 R11255.2
SP4: R11136.1 U15.17
SP4=SD_CMD=MS_D2: C4614.1 CN4.2 R11136.2
SP5: R11137.1 U15.18
SP5=SD_D3=MS_D3: C4613.1 CN4.1 R11137.2
SP6: R11138.1 U15.19
SP6=SD_D2=MS_CLK: C4615.1 CN4.9 R11138.2
SP7: R11139.1 U15.28
SP7=SD_WP=MS_BS: CN4.11 R11139.2
SP8: R11256.1 U15.42
SP8=SD_CD#: CN4.10 R11256.2
SPI_CLK_8M: R684.1 R687.2 U41.6
SPI_CS0#_UR_ME: R591.2 R602.1 U45.101
SPI_HOLD_IO3_ME: R239.2 R698.1 U41.7
SPI_SI_8M: R654.2 R691.1 U41.5
SPI_SO_8M: R588.2 R650.2 U41.2
SPI_WP_IO2_ME: R589.2 R649.2 U41.3
SPKR: D9.2 R624.1 R625.2 U35.AW5
SRTC_RST#: C382.1 Q6059.3 R300.2 U35.AN18
SSD_ID: CN9.7 R568.1
STRAP0: R4300.1 R4308.2 U3002.J2
STRAP1: R4301.1 R4309.2 U3002.J7
STRAP2: R4302.1 R4310.2 U3002.J6
STRAP3: R4303.1 R4311.2 U3002.J5
STRAP4: R4304.1 R4312.2 U3002.J3
SUSACK#_R: TP4368.1 U35.AP11
SUSB#: PQ6057.2 R282.2 U35.AP15 U45.119 U47.2 U49.2 U50.2
SUSC#: R274.2 U35.BA16 U45.18 U48.2
SUSCLK: R716.2 R11279.2 U43.2
SUSCLK_R: R11279.1 U35.BA17
SUSD: PC101.2 PQ8.3 PQ23.2 PR142.2
SUSLED#: R427.1 R433.1 U45.28
SUSON: R739.1 R790.2 U45.120 U48.1
SUSON_R: PQ6.2 PR263.2 PR304.2 R790.1 U48.4
SYS_HWPG: D4012.1 PR6283.2 U45.77
SYS_PEX_RST_MON#: R4321.1 R11108.2 U3002.L3 U4002.2
SYS_PWROK: R113.1 R556.1 R560.1 R643.1 U8.4
SYS_PWROK_R: R131.1 R555.1 R556.2 U35.B6
SYS_RESET#: R267.2 R561.2 U35.B5
SYS_SHDN#: PQ14.3 PR6278.2 PR6280.2 PU6010.6 Q5.3 U45.2
SYSTEM_AGND: PR6120.2 PR6121.2 PR6122.1 PR6124.2 PR6125.2
TEMP_MBAT#: PR8.2 PR9.1 PR12.1 U45.73
TERM9: C746.1 R251.1 R262.1 R269.1 R11265.1
TESTMODE: R4011.1 U3002.AK11
TH_FAN_POWER: C723.2 C728.2 CN8.1 U12.3
THRMTRIP#: Q5.1 R488.1 R530.1
TP_INT: CN5.1 Q1.1 R7.1 R8.2 R443.2
TP_INT_PCH: Q1.3 R8.1 U35.AB3
TP_PWR: C577.2 C578.2 CN5.30 CN5.31 R16.2 R19.2
TP_RST#: CN5.29 R444.1
TPCLK: R411.1 R415.2 U45.89
TPCLK_R: C787.2 CN17.7 R411.2
TPD_EN: CN17.1 R190.2
TPD_INT#: CN17.2 Q20.1 R164.1 R349.2
TPD_INT#_D: Q20.3 R164.2 R177.1 U35.W4
TPDATA: R412.1 R416.2 U45.90
TPDATA_R: C788.2 CN17.6 R412.2
TPM_BADD: R729.2 U44.6
TPM_CLKRUN#: R743.1 U44.13
TPM_LRESET#: R742.2 U44.17
TPM_PP: TP4358.1 U44.4
TS_EN: R442.1 R443.1 R751.1
TS_EN_C: C800.1 R751.2 U45.32
TS_EN_R: CN5.6 R442.2
TST: R617.1 R11209.1 U9.22
TYPEC_CHG: R11205.2 U28.7
TYPEC_CHG_HI: R11198.2 R11280.1 U28.8
TYPEC_SBU1: CN2021.A8 TP143.1 U4513.4
TYPEC_SBU2: CN2021.B8 TP144.1 U4513.7
UART2_CTS#: R290.1 TP4357.1 U35.AD4
UART2_RTS#: R283.1 TP4356.1 U35.AD3
UART2_RXD: R275.1 TP4354.1 U35.AD1
UART2_TXD: R280.1 TP4355.1 U35.AD2
USB2_ID: R587.1 U35.AG3
USB2_TYPC_7N_C: CN2021.A7 CN2021.B7 R818.2 U4513.9
USB2_TYPC_7P_C: CN2021.A6 CN2021.B6 R819.2 U4513.1
USB3_RXN0: C518.2 R392.2 U35.H8
USB3_RXN0_R: CN16.5 R392.1 U24.6
USB3_RXN1: C475.2 R355.2 U35.J6
USB3_RXN1_R: CN13.5 R355.1 U21.6
USB3_RXN2: C394.1 U35.J10
USB3_RXN3: C4777.1 U35.E10
USB3_RXP0: C517.2 R387.2 U35.G8
USB3_RXP0_R: CN16.6 R387.1 U24.5
USB3_RXP1: C469.2 R353.2 U35.H6
USB3_RXP1_R: CN13.6 R353.1 U21.5
USB3_RXP2: C4781.1 U35.H10
USB3_RXP3: C4776.1 U35.F10
USB3_TXN0: C499.1 U35.C13
USB3_TXN0_C: C499.2 R384.2
USB3_TXN0_R: C511.1 CN16.8 R384.1 U24.10
USB3_TXN1: C461.1 U35.B13
USB3_TXN1_C: C461.2 R341.2
USB3_TXN1_R: C460.1 CN13.8 R341.1 U21.1
USB3_TXN2: C4780.1 U35.B15
USB3_TXN3: C4779.1 U35.C15
USB3_TXP0: C498.1 U35.D13
USB3_TXP0_C: C498.2 R381.2
USB3_TXP0_R: C505.1 CN16.9 R381.1 U24.1
USB3_TXP1: C459.1 U35.A13
USB3_TXP1_C: C459.2 R340.2
USB3_TXP1_R: C458.1 CN13.9 R340.1 U21.10
USB3_TXP2: C369.1 U35.A15
USB3_TXP3: C4778.1 U35.D15
USB3_TYPC_RX2N_C: CN2021.B10 R11196.2 U4509.2
USB3_TYPC_RX2N_C_RE: C394.2 U9.1
USB3_TYPC_RX2N_RE: R11196.1 U9.27
USB3_TYPC_RX2P_C: CN2021.B11 R11199.2 U4509.8
USB3_TYPC_RX2P_C_RE: C4781.2 U9.2
USB3_TYPC_RX2P_RE: R11199.1 U9.26
USB3_TYPC_RX3N_C: CN2021.A10 R817.2 U4509.6
USB3_TYPC_RX3N_C_RE: C4777.2 U9.7
USB3_TYPC_RX3N_RE: R817.1 U9.21
USB3_TYPC_RX3P_C: CN2021.A11 R816.2 U4509.5
USB3_TYPC_RX3P_C_RE: C4776.2 U9.8
USB3_TYPC_RX3P_RE: R816.1 U9.20
USB3_TYPC_TX2N_C: CN2021.A3 R820.2 U4509.9
USB3_TYPC_TX2N_C_RE: C4780.2 U9.4
USB3_TYPC_TX2N_R: C4771.1 R820.1
USB3_TYPC_TX2N_RE: C4771.2 U9.24
USB3_TYPC_TX2P_C: CN2021.A2 R821.2 U4509.1
USB3_TYPC_TX2P_C_RE: C369.2 U9.5
USB3_TYPC_TX2P_R: C4770.1 R821.1
USB3_TYPC_TX2P_RE: C4770.2 U9.23
USB3_TYPC_TX3N_C: CN2021.B3 R11207.2 U4509.4
USB3_TYPC_TX3N_C_RE: C4779.2 U9.10
USB3_TYPC_TX3N_R: C4762.1 R11207.1
USB3_TYPC_TX3N_RE: C4762.2 U9.18
USB3_TYPC_TX3P_C: CN2021.B2 R11202.2 U4509.7
USB3_TYPC_TX3P_C_RE: C4778.2 U9.11
USB3_TYPC_TX3P_R: C4763.1 R11202.1
USB3_TYPC_TX3P_RE: C4763.2 U9.17
USB_BC_ON: U22.4 U45.97
USB_CHARGE_ON: R364.1 U22.5 U45.96
USB_CLT1: U22.6 U45.31
USB_OC0#: R541.1 U22.13 U35.A9
USB_OC1#: R540.1 U20.3 U35.C9
USB_OC2#: R543.1 U35.D9 U4511.3
USB_OC3#: R542.1 R11281.1 U35.B9
USBCOMP: R178.1 U35.AB6
USBON#: U20.4 U45.99 U4511.4
USBP0+: U22.3 U35.AB10
USBP0+_C: R386.2 U22.10
USBP0+_R: CN16.3 R386.1 U24.7
USBP0-: U22.2 U35.AB9
USBP0-_C: R385.2 U22.11
USBP0-_R: CN16.2 R385.1 U24.4
USBP1+: R348.2 U35.AD7
USBP1+_R: CN13.3 R348.1 U21.7
USBP1-: R342.2 U35.AD6
USBP1-_R: CN13.2 R342.1 U21.4
USBP2+: CN2020.7 U35.AJ3
USBP2-: CN2020.8 U35.AH3
USBP3+: CN2020.11 U35.AD10
USBP3-: CN2020.12 U35.AD9
USBP4+: CN10.3 U35.AJ2
USBP4-: CN10.5 U35.AJ1
USBP5+: R4.2 U35.AF7
USBP5-: R3.2 U35.AF6
USBP6+: R2.1 U35.AH2
USBP6+_R: CN5.14 R2.2
USBP6-: R1.1 U35.AH1
USBP6-_R: CN5.13 R1.2
USBP7+: R819.1 U35.AF9
USBP7-: R818.1 U35.AF8
USBP8+: R11299.2 R11301.2 U35.AG2
USBP8+_PI3: R11301.1 U1006.1
USBP8+_R: CN95.2 EC54.2 R11302.1 R11303.1
USBP8+_R_COM: R11299.1 R11302.2
USBP8+_R_PI3: R11303.2 U1006.7
USBP8-: R11291.2 R11300.2 U35.AG1
USBP8-_PI3: R11291.1 U1006.2
USBP8-_R: CN95.3 EC53.2 R11304.1 R11305.1
USBP8-_R_COM: R11300.1 R11304.2
USBP8-_R_PI3: R11305.2 U1006.6
USBPWR0: C487.1 C496.2 C497.2 C502.2 CN16.1 U22.12 U24.2
USBPWR1: C450.2 C451.2 C452.2 C462.2 CN13.1 U20.1 U21.2
USBPWRD2: C4711.2 C4712.2 C4713.2 C4715.2 CN2020.1 CN2020.2 CN2020.3 CN2020.4 U4511.1
V_BLIGHT: CN5.39 CN5.40 R14.2 R15.2
VA: PC124.2 PC128.2 PD3.1 PD8.1 PD8.2 PJ3.3 PJ3.4 PR168.1
VA1: PC13.2 PC133.1 PD8.3 PQ22.5 PR5.2
VA2: PC136.1 PQ22.1 PQ22.2 PQ22.3 PR166.1 PR210.1 PR213.1
VCORE_PHASE: PC144.2 PL4.1 PR60.1 PU8.5 PU8.13
VCORE_SENSE: PR33.2 R96.2 U35.E32
VCORE_VBST: PR231.2 PU8.3
VCORE_VCC: PC149.2 PR55.1 PU8.23 PU8.24
VCORESS_SENSE: PR38.2 R98.1 U35.E33
VDD33/18: C4597.2 C4598.2 U15.27
VGA_MBCLK: R582.2 U35.R9
VGA_MBDATA: R585.2 U35.W2
VGA_VCCSENSE: PR163.1 U3002.L4
VGA_VSSSENSE: PR162.1 U3002.L5
VGPU_EN: TP4398.1 U35.AN8
VL: PC6219.2 PR144.1 PR146.1 PU6010.13
VMA_CLK0: R1426.1 U5.J12 U3002.R30
VMA_CLK0#: R1426.2 U5.J11 U3002.R31
VMA_CLK1: R1500.1 U7.J12 U3002.AB31
VMA_CLK1#: R1500.2 U7.J11 U3002.AC31
VMA_DQ0: U5.A4 U3002.L28
VMA_DQ1: U5.A2 U3002.M29
VMA_DQ2: U5.B4 U3002.L29
VMA_DQ3: U5.B2 U3002.M28
VMA_DQ4: U5.E4 U3002.N31
VMA_DQ5: U5.E2 U3002.P29
VMA_DQ6: U5.F4 U3002.R29
VMA_DQ7: U5.F2 U3002.P28
VMA_DQ8: U5.A11 U3002.J28
VMA_DQ9: U5.A13 U3002.H29
VMA_DQ10: U5.B11 U3002.J29
VMA_DQ11: U5.B13 U3002.H28
VMA_DQ12: U5.E11 U3002.G29
VMA_DQ13: U5.E13 U3002.E31
VMA_DQ14: U5.F11 U3002.E32
VMA_DQ15: U5.F13 U3002.F30
VMA_DQ16: U5.U11 U3002.C34
VMA_DQ17: U5.U13 U3002.D32
VMA_DQ18: U5.T11 U3002.B33
VMA_DQ19: U5.T13 U3002.C33
VMA_DQ20: U5.N11 U3002.F33
VMA_DQ21: U5.N13 U3002.F32
VMA_DQ22: U5.M11 U3002.H33
VMA_DQ23: U5.M13 U3002.H32
VMA_DQ24: U5.U4 U3002.P34
VMA_DQ25: U5.U2 U3002.P32
VMA_DQ26: U5.T4 U3002.P31
VMA_DQ27: U5.T2 U3002.P33
VMA_DQ28: U5.N4 U3002.L31
VMA_DQ29: U5.N2 U3002.L34
VMA_DQ30: U5.M4 U3002.L32
VMA_DQ31: U5.M2 U3002.L33
VMA_DQ32: U7.U4 U3002.AG28
VMA_DQ33: U7.U2 U3002.AF29
VMA_DQ34: U7.T4 U3002.AG29
VMA_DQ35: U7.T2 U3002.AF28
VMA_DQ36: U7.N4 U3002.AD30
VMA_DQ37: U7.N2 U3002.AD29
VMA_DQ38: U7.M4 U3002.AC29
VMA_DQ39: U7.M2 U3002.AD28
VMA_DQ40: U7.U11 U3002.AJ29
VMA_DQ41: U7.U13 U3002.AK29
VMA_DQ42: U7.T11 U3002.AJ30
VMA_DQ43: U7.T13 U3002.AK28
VMA_DQ44: U7.N11 U3002.AM29
VMA_DQ45: U7.N13 U3002.AM31
VMA_DQ46: U7.M11 U3002.AN29
VMA_DQ47: U7.M13 U3002.AM30
VMA_DQ48: U7.A11 U3002.AN31
VMA_DQ49: U7.A13 U3002.AN32
VMA_DQ50: U7.B11 U3002.AP30
VMA_DQ51: U7.B13 U3002.AP32
VMA_DQ52: U7.E11 U3002.AM33
VMA_DQ53: U7.E13 U3002.AL31
VMA_DQ54: U7.F11 U3002.AK33
VMA_DQ55: U7.F13 U3002.AK32
VMA_DQ56: U7.A4 U3002.AD34
VMA_DQ57: U7.A2 U3002.AD32
VMA_DQ58: U7.B4 U3002.AC30
VMA_DQ59: U7.B2 U3002.AD33
VMA_DQ60: U7.E4 U3002.AF31
VMA_DQ61: U7.E2 U3002.AG34
VMA_DQ62: U7.F4 U3002.AG32
VMA_DQ63: U7.F2 U3002.AG33
VMA_WCK01: U5.D4 U3002.K31
VMA_WCK01#: U5.D5 U3002.L30
VMA_WCK23: U5.P4 U3002.H34
VMA_WCK23#: U5.P5 U3002.J34
VMA_WCK45: U7.P4 U3002.AG30
VMA_WCK45#: U7.P5 U3002.AG31
VMA_WCK67: U7.D4 U3002.AJ34
VMA_WCK67#: U7.D5 U3002.AK34
VMB_CLK0: R1336.1 U3.J12 U3002.D12
VMB_CLK0#: R1336.2 U3.J11 U3002.E12
VMB_CLK1: R1342.1 U4.J12 U3002.E20
VMB_CLK1#: R1342.2 U4.J11 U3002.F20
VMB_DQ0: U3.A4 U3002.G9
VMB_DQ1: U3.A2 U3002.E9
VMB_DQ2: U3.B4 U3002.G8
VMB_DQ3: U3.B2 U3002.F9
VMB_DQ4: U3.E4 U3002.F11
VMB_DQ5: U3.E2 U3002.G11
VMB_DQ6: U3.F4 U3002.F12
VMB_DQ7: U3.F2 U3002.G12
VMB_DQ8: U3.A11 U3002.G6
VMB_DQ9: U3.A13 U3002.F5
VMB_DQ10: U3.B11 U3002.E6
VMB_DQ11: U3.B13 U3002.F6
VMB_DQ12: U3.E11 U3002.F4
VMB_DQ13: U3.E13 U3002.G4
VMB_DQ14: U3.F11 U3002.E2
VMB_DQ15: U3.F13 U3002.F3
VMB_DQ16: U3.U11 U3002.C2
VMB_DQ17: U3.U13 U3002.D4
VMB_DQ18: U3.T11 U3002.D3
VMB_DQ19: U3.T13 U3002.C1
VMB_DQ20: U3.N11 U3002.B3
VMB_DQ21: U3.N13 U3002.C4
VMB_DQ22: U3.M11 U3002.B5
VMB_DQ23: U3.M13 U3002.C5
VMB_DQ24: U3.U4 U3002.A11
VMB_DQ25: U3.U2 U3002.C11
VMB_DQ26: U3.T4 U3002.D11
VMB_DQ27: U3.T2 U3002.B11
VMB_DQ28: U3.N4 U3002.D8
VMB_DQ29: U3.M2 U3002.A8
VMB_DQ30: U3.N2 U3002.C8
VMB_DQ31: U3.M4 U3002.B8
VMB_DQ32: U4.U4 U3002.F24
VMB_DQ33: U4.U2 U3002.G23
VMB_DQ34: U4.T4 U3002.E24
VMB_DQ35: U4.T2 U3002.G24
VMB_DQ36: U4.N4 U3002.D21
VMB_DQ37: U4.N2 U3002.E21
VMB_DQ38: U4.M4 U3002.G21
VMB_DQ39: U4.M2 U3002.F21
VMB_DQ40: U4.U11 U3002.G27
VMB_DQ41: U4.U13 U3002.D27
VMB_DQ42: U4.T11 U3002.G26
VMB_DQ43: U4.T13 U3002.E27
VMB_DQ44: U4.N11 U3002.E29
VMB_DQ45: U4.N13 U3002.F29
VMB_DQ46: U4.M11 U3002.E30
VMB_DQ47: U4.M13 U3002.D30
VMB_DQ48: U4.A11 U3002.A32
VMB_DQ49: U4.A13 U3002.C31
VMB_DQ50: U4.B11 U3002.C32
VMB_DQ51: U4.B13 U3002.B32
VMB_DQ52: U4.E11 U3002.D29
VMB_DQ53: U4.E13 U3002.A29
VMB_DQ54: U4.F13 U3002.C29
VMB_DQ55: U4.F11 U3002.B29
VMB_DQ56: U4.A4 U3002.B21
VMB_DQ57: U4.A2 U3002.C23
VMB_DQ58: U4.B4 U3002.A21
VMB_DQ59: U4.B2 U3002.C21
VMB_DQ60: U4.F2 U3002.B24
VMB_DQ61: U4.E2 U3002.C24
VMB_DQ62: U4.E4 U3002.B26
VMB_DQ63: U4.F4 U3002.C26
VMB_WCK01: U3.D4 U3002.F8
VMB_WCK01#: U3.D5 U3002.E8
VMB_WCK23: U3.P4 U3002.A5
VMB_WCK23#: U3.P5 U3002.A6
VMB_WCK45: U4.P4 U3002.D24
VMB_WCK45#: U4.P5 U3002.D25
VMB_WCK67: U4.D4 U3002.B27
VMB_WCK67#: U4.D5 U3002.C27
VR_SVID_ALERT#_VCORE: PU1.36 R134.2 R552.2
VREF_CA_DIMM0: C1255.1 C1259.1 JDIM1.164 R10878.2 R10883.2 R10887.2 R10895.1
VREF_CA_DIMM1: C1323.1 C1327.1 JDIM2.164 R10932.2 R10934.2 R10935.2 R10938.1
VREF_VMA1_MOS: Q129.3 R1410.1 R1513.1
VREF_VMA3_MOS: Q115.3 R1297.1 R1330.1
VREFC_VMA1: C1432.1 R1410.2 R1416.2 R1417.2 U5.J14
VREFC_VMA2: C1551.1 R1508.2 R1509.2 R1513.2 U7.J14
VREFC_VMC1: C1409.1 R1330.2 R1331.2 R1337.2 U3.J14
VREFC_VMC2: C1416.1 R1297.2 R1367.2 R1381.2 U4.J14
VRON: R463.1 R792.2 U45.69 U50.1
VRON_R: PR28.1 PR136.1 PR196.2 R792.1 U50.4
VSA_SENSE: PR50.2 R122.2 U35.H20
VSASS_SENSE: PR52.2 R109.1 U35.H21
VSTBY_FSPI: R11118.1 R11119.1 U45.106
VSYNC: R11192.1 R11270.2 U37.2
VSYNC_C: R11192.2 U13.18
WIFI_SUSCLK: CN10.50 R714.1 U43.4
WLAN_CLKREQ#: CN10.53 Q23.4 R245.1 R253.2
WLAN_RST#: C821.2 CN10.52 R671.2 R680.2
WLAN_WAKE_R#: CN10.55 Q23.1 R242.1 R243.2
WLANPWR#: R230.1 R231.2 R710.1 R712.2 U45.35
WRST#: C491.1 D12.2 Q56.6 R368.1 U45.14
XCLK_BIASREF: R512.1 U35.E42
XDP_BPM#0: TP89.1 U35.C55
XDP_BPM#1: TP90.1 U35.D55
XDP_BPM#2: TP64.1 U35.B54
XDP_BPM#3: TP62.1 U35.C56
XDP_PRDY#: TP91.1 U35.D56
XDP_PREQ#: TP92.1 U35.D61
XDP_TCK0: R513.1 R558.2 U35.A59 U35.B61
XDP_TCK1: R537.2 U35.B56
XDP_TDI: R515.2 R796.1 U35.D59
XDP_TDI_CPU: R796.2 U35.D60
XDP_TDO: R559.2 R795.1 U35.A56
XDP_TDO_CPU: R795.2 U35.A61
XDP_TMS: R514.2 R797.1 U35.C59
XDP_TMS_CPU: R797.2 U35.C60
XTAL24_IN: C665.2 R536.1 U35.E37 Y4.3
XTAL24_OUT: C658.2 R536.2 U35.E35 Y4.1
XTAL27_IN: C4207.2 U3002.H3 Y4200.1
XTAL27_OUT: C4206.2 U3002.H2 Y4200.3
XTAL_OUTBUFF: R4210.2 R4211.2 U3002.J4
XTAL_SSIN: R4212.2 U3002.H1
N62917: R158.2 U35.H66
N62945: R162.2 U35.H65
N62977: R635.2 U35.AT16
N62981: R646.2 U35.AU16
N74227: R174.2 U35.AB7
N108264: R623.2 U35.AW9
N108478: C806.1 U35.BA11
N109188: R626.2 R627.2 U35.AY9
N109300: R659.2 U35.AY13
N109332: R640.2 U35.BA13
N109356: R653.2 U35.BB13
N109380: R668.2 U35.AY12
N112417: R616.2 U35.AT1
N112429: TP63.1 U35.B7
N112433: R145.2 U35.E13
N119188: R153.1 U35.E8
N136283: CN2.2 R282.1
N136287: CN2.4 R279.1
N136291: CN2.6 R273.1
N136295: CN2.9 R268.1
N136299: CN2.11 R265.1
N136321: CN2.13 R267.1
N136329: CN2.5 R274.1
N321886: R390.2 R395.2 U25.5
N366230: Q36.3 R673.2
N16779422: C781.1 L19.2 Q42.1 R752.2
N16779565: Q18.2 Q19.3 R148.2
N16779579: C786.1 Q42.2 R754.2
N16781100: R402.2 R415.1 R416.1
N16946782: Q5.2 R74.2
N16946786: Q31.1 R74.1
N16998366: Q27.2 R343.1 R344.2
N16998426: Q27.3 Q28.2 R345.2
N17004316: D15.1 Q29.3
N17028021: C344.2 Q22.2 R230.2
N17046941: PJ1.3 PR6.1
N17047009: PR183.1 PU5.20
N17047028: PR184.1 PU5.19
N17047083: PJ1.5 PR8.1
N17047087: PC1.1 PL1.1 PQ1.1 PQ1.2 PQ1.3 PR169.1 PR176.2 PR186.1
N17047112: PC133.2 PC136.2 PQ22.4 PR165.1
N17047335: PC4.1 PR2.2
N17047399: PC119.2 PR173.1
N17047425: PJ1.4 PR7.1
N17047601: PC1.2 PQ1.4 PR185.1
N17067472: PC104.2 PR154.2 PR155.1 PU4.8
N17067476: PD4.1 PQ12.1 PR152.1
N17067510: PQ12.3 PR154.1
N17067514: PQ12.2 PQ13.3 PR152.2
N17067548: PC102.2 PQ14.2 PR155.2 PU4.1
N17067560: PQ9.3 PR262.1
N17067629: PQ4.3 PR137.2
N17067635: PQ10.3 PR153.2
N17192633: R337.2 U19.7
N17310717: D24.1 LED2.2 R430.2
N17310725: D27.1 LED1.1 R433.2
N17310735: D25.1 LED2.1 R431.2
N17310861: D26.1 LED1.2 R432.2
N17398787: PR167.2 PU5.5
N17410561: PC222.1 PC223.1 PC225.1 PC226.1 PL13.2 PR344.1 PR6306.1 PR6307.1
N17410571: PR280.2 PR288.1 R697.1
N17410893: PR290.2 PU14.13
N17424918: PR177.2 PU5.11
N17424920: PR178.2 PU5.12
N17424921: PR170.2 PU5.7
N17424925: PR172.2 PU5.9
N17424950: PR12.2 PR13.2 PU5.15
N17435661: PQ5.3 PR138.2
N17542339: C756.2 Q38.2 R710.2
N17642578: TP4367.1 U35.AT11
N17661815: PR171.2 PU5.8
N17792383: R172.1 R634.2 U35.AC63
N17792405: R176.1 R636.2 U35.AE63
N17792407: R633.2 U35.AL63
N17792421: R632.2 U35.AJ62
N17817978: LED1.3 R438.1 R440.1
N17818190: LED2.3 R437.1 R439.1
N18005998: CN14.18 R326.2
N18020348: TP17.1 U35.AM23
N18021386: TP14.1 U35.AM22
N18022283: TP12.1 U35.K32
N18022286: TP20.1 U35.AK32
N18137715: TP29.1 U35.AU11
N18834425: C764.1 Q56.2 Q56.3 R717.2
N18834459: R717.1 R756.1 R757.1
N18849499: CN5.11 R4.1 R6.2
N18849555: CN5.10 R3.1 R5.2
N18953365: R759.1 U35.AY3
N18953425: R760.1 U35.AY71
N18954271: R761.1 U35.C64
N18954886: R762.1 U35.AR56
N18954889: TP88.1 U35.AP56
N19011701: PC231.1 PR291.1
N19018012: C794.2 R775.2 U35.U11 U35.U12
N19520551: CN20.27 D34.1 R776.1
N19736816: TP84.1 U35.AM15
N20339214: R778.1 U35.AG4
N20915811: TP95.1 U35.AK13
N20965717: PC304.2 PR319.2
N21057139: PC61.2 PR37.2 PR54.1 PU2.2
N21057151: PC71.1 PR121.1 PR1247.1 PU2.6
N21057157: PC65.1 PC74.2 PR1248.2 PU2.3
N21057159: PR119.1 PR121.2 PU2.7
N21057165: PC70.2 PC81.2 PR68.1 PU2.4
N21057401: PC75.2 PR69.2 PR75.1 PU6.2
N21057413: PC80.1 PR156.1 PR1249.1 PU6.6
N21057419: PC76.1 PC78.2 PR1250.2 PU6.3
N21057421: PR133.1 PR156.2 PU6.7
N21057429: PC77.2 PC79.2 PR81.1 PU6.4
N21060883: PQ17.3 PR164.2
N21061023: PQ15.3 PQ16.2 PQ17.2 PR157.1 PR159.2
N21061031: PC109.2 PQ15.2 PR158.1 PR160.2
N21390980: CN23.10 TP108.1
N21390982: CN23.56 TP109.1
N21390990: CN23.58 TP150.1
N21466717: C1329.2 R10930.1
N21854677: PC110.2 PR84.2 PR163.2 PR277.1
N21854679: PR85.2 PR162.2 PR279.1
N21854704: PC187.1 PQ18.2
N21854718: PC227.2 PR260.2 PR275.1
N21854764: PR112.2 PR114.2
N21854773: PC200.1 PR105.1 PR106.2 PR113.2 PR115.1
N21854780: PC253.1 PR96.1
N21854821: PC188.1 PR89.2
N21854867: PC199.2 PR118.1
N21854979: PC183.1 PR91.2
N21854999: PC182.1 PR95.1
N21855085: PQ18.3 PR105.2
N21874303: PQ6.3 PQ7.2 PQ8.2 PR140.1 PR141.2
N21874329: PQ7.3 PR139.2
N22203161: C1252.2 R10873.2
N22210005: JDIM1.162 TP154.1
N22210006: JDIM1.165 TP153.1
N22221753: C1265.1 C1267.1 JDIM1.255 R11133.1 R11170.1
N22317134: CN2019.27 D4002.1 R11107.1
N22444593: Q40.3 R11282.2 SW4.3 SW4.4
N22485913: TP4360.1 U44.30
N22485947: TP4361.1 U44.29
N22521878: C4200.1 Q4200.2 Q4201.3 R4201.1
N22521888: C4201.1 Q4201.2 R4203.1
N22523419: Q4001.3 R4000.2 R4002.1
N22523424: C4013.2 C4019.1 Q4000.2 R4002.2
N22570409: C798.2 R774.1 U45.66
N22570473: C801.1 EC52.2 R460.1 U45.118
N22570527: C796.1 R190.1 U45.98
N22570909: C797.1 R349.1 U45.128
N22571742: C490.2 R373.1
N22571917: C778.1 U45.12
N22668004: PQ6066.3 PR6298.2
N22678439: R11140.2 U35.AR13
N22746710: C4727.1 C4728.1 JDIM2.255 R11134.1 R11142.1
N23131721: C793.2 U35.L1
N23160970: Q4300.6 R4328.1 R4329.2
N23160985: Q4300.3 R4335.1 R4336.2
N23162333: TP4309.1 U3002.N8
N23162335: TP4308.1 U3002.P7
N23162337: TP4306.1 U3002.P5
N23162339: TP4304.1 U3002.L6
N23162341: TP4302.1 U3002.M3
N23457928: Q39.3 R709.2 R713.1 R715.1
N23457985: C364.2 U42.1 U42.4 U42.7 U42.10
N23458009: C368.2 Q24.2 R259.2
N23458593: R11259.1 U15.32
N23458605: C4821.2 R11260.2 R11261.2 U15.30
N23458824: C4603.1 TP4333.1 U15.41
N23458866: C4604.1 TP4334.1 U15.37
N23458888: TP4335.1 U15.40
N23458910: TP44.1 U15.43
N23458912: TP4336.1 U15.38
N23510743: TP4390.1 U35.N11
N23517766: R11187.1 U13.9
N23517875: R11286.1 U13.12
N23517877: TP4376.1 U13.13
N23523086: TP4395.1 U35.A50
N23523088: TP4394.1 U35.B50
N23523090: TP4392.1 U35.D51
N23523092: TP4393.1 U35.C51
N23587811: PC112.1 PR6294.1 PU10.5
N23587813: PC107.1 PR6293.2 PU10.3
N23587852: PR6283.1 PR6284.2 PR6297.1 PU6010.7
N23587899: PC6213.2 PR6286.2
N23587941: PC6222.1 PR6289.2
N23588169: PC214.1 PR6299.2 PU20.3
N23588226: PC180.1 PR6300.2 PU20.4
N23588230: PC210.1 PU20.12
N23588246: PC6221.1 PR6288.2
N23588298: PC6215.1 PR6287.1
N23588466: PQ6057.3 PQ6058.2 PR6290.1
N23588559: PC88.1 PR6282.2 PU11.4
N23588563: PC175.1 PU11.12
N23588565: PC98.1 PU11.10
N23588601: PC87.1 PR6291.1 PU11.5
N23588609: PC84.1 PR6285.2 PU11.3
N23588692: PC111.1 PR6292.2 PU10.4
N23588706: PC177.1 PU10.12
N23588708: PC176.1 PU10.10
N24001694: CN6.2 CN6.4 R119.2
N24137237: C529.2 U23.39
N24137249: C528.2 U23.37
N24137264: C530.1 U23.34
N24137266: C519.1 U23.19
N24137310: TP34.1 U23.48
N24137536: C481.1 U23.7
N24137654: D9.1 D10.1 R352.2
N24137694: C528.1 U23.35
N24137751: R388.2 U23.20
N24462443: R571.2 U35.N9
N24842468: D31.1 R316.1
N24842470: D30.1 R317.1
N24842747: R11273.1 U18.4
N25027006: R11210.1 U9.30
N25057492: R11269.1 U40.4
N25057545: R11272.1 U37.4
N25088929: PC11.1 PC12.1 PC16.2 PR187.1 PR191.2 PR194.2
N25088945: PC25.2 PC26.2 PC27.1 PR31.1 PR33.1 PR201.2
N25088989: PR224.1 PR235.2 PR236.2
N25089005: PC41.1 PR44.2
N25089057: PR225.1 PR226.2 PR227.2
N25089075: PC139.1 PR216.2
N25089155: PR218.1 PR242.1
N25089173: PC40.1 PR48.1
N25089218: PR193.1 PR241.2
N25089263: PC19.2 PR21.2
N25125081: PC129.1 PR195.2
N25125123: PC15.1 PR23.2
N25125126: PC16.1 PR24.2
N25125152: PC26.1 PR34.2
N25125190: PR205.1 PR243.1
N25125219: PC34.1 PR41.1
N25125233: PC135.1 PR199.2
N25125243: PC28.1 PR36.2
N25125246: PC42.2 PC44.1 PC46.2 PR50.1 PR51.1 PR217.2
N25125286: PC42.1 PR45.2
N25127185: PL4.3 PR215.2
N25127186: PL4.4 PR214.2
N25127202: PC58.1 PR60.2
N25127220: PL2.3 PR19.2 PR20.2
N25127225: PL3.3 PR189.2 PR190.2
N25127236: PL2.4 PR17.2 PR18.1
N25127258: PL3.4 PR182.2 PR188.1
N25127284: PC142.1 PR223.1
N25127289: PC143.1 PR230.1
N25127305: PR237.2 PU8.1
N25127307: PR238.2 PU8.2
N25127323: PC144.1 PR231.1
N25127350: PR229.2 PU13.2
N25127352: PR228.2 PU13.1
N25127366: PR233.2 PU7.1
N25127378: PR234.2 PU7.2
N25128804: PR239.2 PU9.1
N25128814: PL5.3 PR222.2
N25128815: PL5.4 PR221.2
N25128837: PC57.1 PR59.2
N25128839: PC145.1 PR232.1
N25128864: PR240.2 PU9.2
N25168545: CN23.12 CN23.14 CN23.16 CN23.18 TP4397.1
N26437429: PC244.1 PR285.1 PU16.4
N26437442: PR273.1 PR278.1
N26437455: PC240.2 PR271.1 PU16.1
N26437457: PR271.2 PR304.1 PR307.2
N26437471: PR278.2 PR302.2 PU16.6
N26437496: PR306.2 PU16.5
N26460910: PC270.1 PR98.2
N26460931: PC267.1 PR99.2
N26462467: PC218.1 PR269.2 PU21.4
N26462475: PC202.1 PR251.1
N26462659: PR281.1 PU21.3
N26462709: PC197.1 PR90.2
N26464581: PC290.1 PR120.2
N26464602: PC289.1 PR123.2
N27001711: R11188.1 U13.10
N27001714: R11285.1 R11287.1 U13.11
N27008720: TP4377.1 U35.AH7
N27008723: TP4378.1 U35.AH8
N27585563: Q75.2 Q76.3 R2854.2 R11298.2
N27585646: C3007.2 C3008.2 R2868.2 R2870.2
N27585648: R2868.1 U1006.9
N27585717: R2872.1 U1006.8
N27586193: CN95.5 R11293.1
N27586196: CN95.6 R11294.1
N27586199: CN95.7 R11295.1
N27586202: CN95.8 R11296.1
N27699592: C4822.2 Q76.2 R11297.2 R11298.1
N81560469: R1333.2 U4.J13
N81561297: R1510.2 U7.J13
N81564024: R1335.2 U3.J13
N81564072: R1415.2 U5.J13
N215331000: JDIM2.165 TP157.1
N215331770: JDIM2.162 TP158.1
N275857383: TP4396.1 U1006.4
N275857384: TP4399.1 U1006.5
N281253841: PC55.1 PR57.2
N281258110: PC56.1 PR58.2

Pads without a net: CN2 15 16 17 18 19 20; CN5 37 38; CN6 3; CN7 4; CN10 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 65 67 76 77; CN12 13 14; CN14 8 10 20 21 22; CN23 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN2020 5; NOREF 1; NOREF#2 1; NOREF#6 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; PAD8 1; PU2 5; PU4 7; PU6 5; PU7 4 19 20; PU8 4 19 20; PU9 4 19 20; PU13 4 19 20; PU15 7; PU20 5 6 7 8 9 10; PU22 7; PU6010 19; U3 A5 A10 U5 U10; U4 A5 A10 U5 U10; U5 A5 A10 U5 U10; U6 1; U7 A5 A10 U5 U10; U9 12; U13 27 28 31; U18 3 23 24; U19 2 3; U22 9; U23 14 15 16 23 24; U33 1; U35 A3 A4 A6 A7 A11 A26 A27 A29 A31 A33 A36 A38 A52 A65 A69 AB4 AB11 AB12 AB13 AC1 AC2 AC3 AD11 AD12 AF11 AF12 AF13 AH9 AH10 AH11 AH12 AK6 AK7 AK9 AK10 AK12 AK62 AL25 AL27 AL61 AN13 AN55 AP13 AP53 AT5 AT15 AU1 AU2 AU5 AU56 AW1 AW7 AW17 AW20 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY4 AY5 AY7 AY8 AY20 AY21 AY56 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B67 B69 B70 BA3 BA4 BA7 BA8 BA9 BA68 BA70 BB2 BB3 BB4 BB5 BB7 BB9 BB68 BB69 C2 C4 C7 C8 C11 C12 C19 C20 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C41 C54 C67 C68 C70 C71 D1 D3 D4 D5 D8 D12 D19 D20 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D41 D54 D65 D67 D68 D71 E1 E2 E3 E16 E61 E63 E66 E68 F6 F16 F18 F46 F50 F52 F60 F61 F63 F65 F66 F70 F71 G1 G2 G3 G18 G46 G50 G65 G68 G69 G70 G71 H1 H11 H69 H70 J4 J5 J68 J71 K45 K46 M1 M2 M3 M4 N1 N2 N3 P1 P2 P3 P4 U1 U2 U3 U4 V1 V2 W7 W8 W10 W11 W12; U43 1; U44 2 5 7 10 11 12 25 26 31; U3002 A9 A26 A27 A30 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA8 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AG10 AG17 AG20 AG23 AH3 AH4 AH6 AH8 AH9 AH17 AH20 AH23 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ17 AJ18 AJ20 AJ21 AJ23 AJ24 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK17 AK18 AK19 AK20 AK21 AK22 AK23 AK24 AK25 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AL19 AL22 AL25 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM17 AM18 AM20 AM21 AM23 AM24 AM26 AM27 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AN17 AN18 AN20 AN21 AN23 AN24 AN26 AN27 AP3 AP5 AP6 AP8 AP9 AP17 AP18 AP20 AP21 AP23 AP24 AP26 AP27 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 H6 H26 H30 H31 J30 J31 J32 J33 K3 K4 M6 M30 M34 N4 P2 P3 P4 R1 R8 T8 V32 Y1 Y2 Y3; U4513 2 8

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5070 vias
v2: diameter 0.483, hole 0.254, TOP to BOTTOM, 1130 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 1184 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
2.469V: length 4.2
  TOP w0.254: PU4.3 v1(52.69,107.66) PR144.2 52.18,106.5 52.46,106.5 52.9,106.05 PR145.1
3.3V_AUX: length 1.5
  TOP w0.127: TP4000.1 184.71,125.8 v1(184.71,124.86)
  BOTTOM w0.127: U3002.P8 185.13,124.45 v1(184.71,124.86)
3V_LDO: length 11.9
  TOP w0.203: PU6010.3 v1(54.82,38.73)
  IN1 w0.508: v1(54.82,38.73) 57.33,38.73 v1(57.87,38.2)
  IN2 w0.381: v1(57.05,42.16) 57.05,40.96 v1(54.82,38.73)
  BOTTOM w0.381: PR6280.1 56.63,42.16 v1(57.05,42.16)
  BOTTOM w0.508: PR6296.1 v1(57.87,38.2)
  BOTTOM w0.762: v1(54.82,38.73) 54.82,38.83 55.53,39.54 PC6098.1
3V_LR: length 14.3
  TOP w0.178: U9.9 v1(33.05,120.6) ; U9.25 v1(28.08,118.2)
  TOP w0.508: R11213.1 R254.1 ; R258.1 R11211.1 v1(32.57,113) ; v1(32.35,125) R206.1 R11212.1 R11214.1 R203.1
  BOTTOM w0.508: v1(33.05,120.6) 33.03,120.62 C4774.1 ; v1(29.27,114.19) v1(30.26,114.19) 31.98,114.19 32.57,113.61 v1(32.57,113) ; C4773.1 28.45,117.83 v1(28.08,118.2) ; R617.2 v1(26.53,121.98)
  vias: v1(29.27,113.53)
3V_MAIN_PWGD: length 225.2
  IN1 w0.14: v1(207.37,63.52) 205.81,61.96 205.81,58.65 203.87,56.72 196.87,56.72 193.37,60.22 192.78,60.22 192.1,60.91 189.85,60.91 189.12,61.64 186.06,61.64 180.63,67.08 179.98,67.08 176.41,70.65 176.41,74.42 176.1,74.72 176.1,81.25 180.63,85.77 180.63,90.47 179.49,91.61 179.49,100.09 177.7,101.87 177.7,104.03 178.52,104.85 178.52,108 176.97,109.54 176.97,110.07 v1(177.02,110.12)
  IN2 w0.14: v1(204.04,171.44) 204.04,171.44 204.02,171.41 204.02,169.46 204.58,168.9 204.58,168.9 204.64,168.84 204.64,166.2 205.6,165.24 205.6,163.81 206.12,163.29 206.12,162.24 208.45,159.91 214.48,159.91 215.45,158.94 219.82,158.94 223.3,155.47 223.3,155.44 223.35,155.39 223.35,109.97 217.37,103.98 217.37,103.69 214.86,101.19 214.74,101.19 212.96,99.41 212.96,84.91 216.59,81.27 216.59,71.14 216.13,70.68 214.71,70.68 214.43,70.4 214.43,66.76 v1(214.17,66.49)
  BOTTOM w0.127: v1(214.17,66.49) 211.05,66.49 210.62,66.06 210.22,66.06 v1(209.3,65.15) 207.68,63.52 v1(207.37,63.52) 206.97,63.11 PR345.1 ; PR321.2 204.24,171.64 v1(204.04,171.44) ; v1(177.02,110.12) R4200.1 R4202.2 178.75,109.34 Q4200.3
+1.2VSUS: length 192.4
  TOP w0.381: R194.1 115.94,107.83 116.52,107.26 116.52,107.18
  TOP w0.508: v1(145.4,53.36) 144.84,53.36
  IN1 w0.508: v2(126.72,104.5) 126.74,104.49 126.74,101.61 v1(128.27,100.07)
  IN1 w1.016: 44.27,58.68 44.83,58.12 44.83,58.08 47.12,55.79 48.71,55.79 50.64,57.72 69.4,57.72 71.75,60.07 v3(74.96,60.07)
  BOTTOM w0.132: U35.BB23 127.97,101.25 128.01,101.2 128.01,100.35 128.27,100.09 v1(128.27,100.07) ; v1(118.03,99.63) 118.03,99.63 U35.BB41
  BOTTOM w0.178: U35.BB47 114.37,100.43 114.4,100.41 v1(114.4,100.26) ; U35.BB32 123,101.48 123,99.61 123.18,99.42 v1(123.18,99.22) ; v1(111.88,100.41) 111.91,100.44 U35.BB51
  BOTTOM w0.191: v1(112.47,57.43) 112.25,57.43 111.92,57.11 111.92,56.48 111.97,56.43 JDIM2.118 ; v1(113.72,47.55) 113.75,47.57 113.98,47.57 114.72,48.32 JDIM1.129 ; v1(125.39,58.17) 125.17,58.17 124.79,57.79 124.79,56.9 124.47,56.58 JDIM2.160 ; JDIM1.123 113.22,49.79 113.54,49.47 113.72,49.47 113.72,49.48 v1(113.72,49.45) ; JDIM2.124 113.47,56.46 113.42,56.51 113.42,57.08 113.77,57.43 v1(113.97,57.43) ; v1(118.17,65.38) 117.72,64.94 JDIM2.141
  BOTTOM w0.203: U35.AU42 v2(116.7,103.9)
  BOTTOM w0.254: JDIM2.241 144.72,65.39 145.06,65.73 v1(145.34,65.73) ; v1(114.69,41.9) 114.97,42.19 JDIM1.130 ; JDIM1.141 v1(117.72,52.85) ; v1(115.9,54.11) 116.16,54.11 116.47,54.42 JDIM2.136 ; JDIM2.33 v1(90.72,64.92) ; v1(123.6,52.85) 123.75,52.85 124.22,52.38 JDIM1.159 ; v1(123.64,65.82) 124.05,65.82 125.22,64.65 JDIM2.163 ; v1(132.75,65.54) 133.86,65.54 134.22,65.17 JDIM2.199 ; JDIM1.163 125.22,52.42 124.03,53.62 v1(123.6,53.62) 122.97,54.24 JDIM2.154 ; v1(111.12,65.11) 111.5,65.11 111.72,64.88 JDIM2.117 ; JDIM2.75 101.22,64.88 v1(100.41,65.69) ; v1(122.28,64.94) 122.31,64.92 122.41,64.92 122.72,64.6 JDIM2.153 ; v1(91.26,52.8) 91.04,52.8 90.72,52.49 JDIM1.33 ; JDIM1.135 116.22,52.53 v1(115.91,52.85) ; v1(145.4,53.36) 145.09,53.36 144.72,52.99 JDIM1.241 ; v1(111.41,52.76) 111.72,52.44 JDIM1.117 ; JDIM2.178 128.97,54.42 129.29,54.1 v1(129.98,54.1) ; JDIM1.178 128.97,42.17 129.34,41.8 v1(129.64,41.8) ; v1(109.83,52.73) 110.22,52.34 JDIM1.111 ; v1(123.64,65.05) 123.79,65.05 124.22,64.62 JDIM2.159 ; JDIM1.96 106.47,42.1 v1(106.25,41.88) ; JDIM1.75 101.22,52.39 v1(100.64,52.98) ; JDIM2.112 110.47,57.1 110.81,57.43 v1(111.08,57.43) ; JDIM2.130 114.97,54.26 114.72,54 v1(114.28,54) ; JDIM1.153 122.72,52.73 122.48,52.97 v1(122.03,52.97) 121.58,52.97 121.22,52.61 JDIM1.147 ; JDIM1.54 95.97,41.76 v1(95.79,41.57) ; v1(122.23,53.99) 121.9,53.99 121.47,54.42 JDIM2.148 ; v1(125.39,45.33) 125.27,45.33 124.72,44.78 124.72,44.56 124.47,44.32 JDIM1.160 ; v1(116.26,41.9) 116.47,42.12 JDIM1.136 ; v1(106.36,53.98) 106.36,54 106.47,54.12 JDIM2.96 ; JDIM2.54 95.97,54.37 95.68,54.08 v1(95.46,54.08) ; v1(139.75,56.95) 139.75,56.94 139.47,56.66 JDIM2.220 ; v1(109.38,65.61) 109.68,65.61 109.96,65.34 109.96,64.93 110.22,64.66 JDIM2.111 ; JDIM1.142 v1(117.97,41.92) ; JDIM1.199 134.22,52.72 133.58,53.36 v1(132.92,53.36) ; v1(115.45,65.59) 115.98,65.59 116.31,65.26 116.31,64.75 116.22,64.67 JDIM2.135 ; v1(114.03,64.91) 114.52,64.91 114.72,64.71 JDIM2.129 ; v1(114.03,65.58) 113.54,65.58 113.22,65.27 JDIM2.123 ; v1(113.82,41.91) 113.8,41.91 113.47,42.24 JDIM1.124 ; v1(85.17,53.98) 85.47,54.29 JDIM2.12 ; C1260.1 139.47,40.95 JDIM1.220 ; v1(117.83,56.8) 117.97,56.65 JDIM2.142 ; v1(121.47,41.8) JDIM1.148 ; JDIM1.112 110.47,42 110.6,41.88 v1(111.28,41.88) ; JDIM1.12 85.47,44.29 v1(85.17,44.6) ; JDIM1.118 v1(111.97,41.83) ; v1(122.31,65.65) 121.96,65.65 121.22,64.92 JDIM2.147 ; v1(122.97,44.49) JDIM1.154
  BOTTOM w0.305: U35.AU23 v2(126.72,104.5) ; v2(120.39,103.88) 120.77,104.2 U35.AU35 ; U35.AU28 v2(123.98,104.53)
  BOTTOM w0.381: v1(93.66,103.02) 93.63,103.04 Q35.2 ; v1(128.27,100.07) 128.27,99.54 129.47,98.34 129.47,97.82 C325.1
  BOTTOM w0.508: v1(132.75,66.19) 132.9,66.34 C1335.1 ; EC44.1 v1(129.72,39.9) ; EC48.1 v1(106.25,40.02) ; EC41.1 110.94,67.26 v1(111.12,67.08) ; C1261.1 v1(100.13,41.04) ; C1336.1 118.17,66.31 v1(118.19,66.34) ; EC38.1 120.97,68.22 v1(122.33,68.22) ; v1(116.26,41.9) 115.51,41.15 C1273.1 ; EC50.1 v1(99.4,41.12) ; C1271.1 v1(99.42,39.97) ; v1(106.25,41.04) 105.6,41.04 C1254.1 ; v1(111.28,41.88) 111.05,41.64 C1256.1 ; C1337.1 v1(90.72,66.69) EC43.1 ; C1314.1 v1(126.93,65.52) ; v1(104.32,66.3) 104.18,66.44 EC42.1 ; v1(100.41,65.69) 101.15,66.43 C1332.1 ; EC36.1 129.72,66.33 v1(129.72,66.32) ; C1318.1 110.94,65.94 v1(111.12,65.75) ; EC46.1 v1(116.16,39.9) ; v1(133.79,40.91) 133.91,40.8 EC45.1 ; v1(118.17,67.81) 117.86,67.81 117.51,67.46 EC39.1 ; v1(121.47,41.8) 121.46,41.79 C1253.1 ; EC49.1 v1(100.13,40.02) ; C1244.1 v1(129.6,40.91) ; C1325.1 v1(122.31,67.08) ; EC47.1 v1(110.42,39.9) ; C1260.1 v1(138.57,40.92) ; EC37.1 v1(123.64,67.19)
  vias: v1(67.57,59.52) v1(68.52,63.25) v1(131.35,37.94) v3(44.18,59.56) v3(68.59,60.22) v3(68.88,66.19) v3(75.77,64.92) v3(75.8,64) v3(75.8,62.99) v3(76.64,64.92) v3(76.64,64) v3(76.59,63.04) v3(76.59,62.1)
+1.5V: length 287.6
  TOP w1.016: 130.99,33.37 126.45,33.37 122.39,37.43 94.11,37.43
  IN1 w1.016: v3(203.51,187.47) 203.79,187.47 v3(204.17,187.09) 204.98,186.28 207.27,186.28 212.55,180.99 212.55,173.96 227.79,158.73 227.79,113.83 227.5,113.55 227.5,113.53 226.15,112.18 226.15,107.22 224.31,105.37 223.49,105.37 222.51,104.39 222.51,103.09 220.35,100.93 219.18,100.93 217.56,99.31 214.94,99.31 214.33,98.7 214.33,89.96 215.42,88.87 215.42,76.27 216.26,75.43 216.26,70.33 216.08,70.15 216.08,66.62 214.71,65.25 ; 213.42,63.57 213.42,60.9 211.98,59.47 211.98,50.81 207.57,46.4 ; 134.75,33.75 135.8,34.8 141.52,34.8 143.01,36.29 149.59,36.29 155.83,42.53 156.2,42.53 156.84,43.17 156.84,43.54 156.84,43.73 159.73,46.62 159.73,52.45 159.53,52.64 159.53,64.24 158.72,65.06 158.72,69.88 157.97,70.63 157.97,73.1 157.31,73.76
  IN2 w1.016: 58.91,56.36 59.38,56.83 67.48,56.83 69.96,54.35 75.22,54.35 77.81,51.76 82.84,51.76 83.55,51.05
  vias: v1(132.92,33.37) v1(133,22.5) v1(133.71,33.34) v1(133.71,22.5) v1(134.45,22.5) v1(155.89,74.16) v1(155.89,73.5) v1(198,29.43) v1(198.02,28.77) v1(203.87,46.93) v1(204.53,46.96) v1(206.79,47.21) v1(207.42,47.54) v1(211.33,37.28) v1(211.87,36.55) v1(212.58,36.55) v1(212.85,65.88) v1(212.85,65.22) v3(34.27,48.08) v3(34.27,47.06) v3(89.67,41.73) v3(90.43,41.45)
+1.05V_GFX:
  vias: v1(169.73,140.81) v1(169.73,122.45) v1(170.54,122.45) v1(170.54,121.58) v1(171.33,139.97) v1(171.3,121.58) v1(172.17,139.94) v1(172.22,121.56) v1(172.95,139.94) v1(173.08,121.25) v1(173.79,139.11) v1(173.82,136.62) v1(173.83,135.74) v1(173.82,134.08) v1(173.82,133.29) v1(173.82,132.43) v1(174.81,138.04) v1(175.47,129.56) v1(206.69,156) v1(213.23,164.42) v3(210.04,165.58) v3(210.01,158.67) v3(210.75,164.76) v3(210.7,158.34) v3(210.83,165.58) v3(211.54,164.76) v3(211.46,158.67) v3(212.15,158.34)
+1.8V_PRIM: length 22
  TOP w0.381: C686.1 97.63,122.31 v1(97.9,122.57) 98.16,122.31 C687.1
  IN1 w0.508: v1(90.99,122.96) 97.17,122.96 97.42,122.71 97.77,122.71 v1(97.9,122.57) 100.18,122.57 100.79,123.18 103.23,123.18 v1(105.63,120.78)
  BOTTOM w0.254: U35.G61 105.68,119.69 105.18,119.19 U35.H63
  BOTTOM w0.305: v1(105.63,120.78) 105.63,119.94 105.89,119.69
  BOTTOM w0.508: R565.1 v1(90.65,123.55) 90.65,123.29 v1(90.99,122.96)
+1.8V_S5: length 346.4
  TOP w0.381: v1(162.11,108.68) 162.03,108.76 v1(162.03,109.44) 162.03,112.85 160.81,114.07 154.13,114.07 153.9,113.84 151.83,113.84 150.67,115 R775.1 150.57,115.21 R180.2
  TOP w0.508: v1(135.87,32.86) 135.26,32.25 126.31,32.25 122.1,36.47 93.8,36.47 86.82,43.45 82.71,43.45 v1(80.55,45.61)
  IN1 w0.381: v1(159.52,98.22) 159.62,98.22 161.42,100.02 161.42,100.65 161.91,101.14 162.24,101.14 162.82,101.72 162.82,103.52 161.02,105.33 161.02,107.59 v1(162.11,108.68)
  IN1 w0.508: v1(160.18,74.49) 159.54,74.49 158.87,73.82 158.87,71 159.62,70.25 159.62,65.6 160.43,64.79 160.43,53.08 160.69,52.83 160.69,46.29 157.79,43.39 157.79,42.43 156.94,41.58 156.15,41.58 148.73,34.16 142.89,34.16 142.42,33.7 136.71,33.7 v1(135.87,32.86)
  IN2 w0.508: v1(47.22,30.2) 47.96,30.2 49.08,29.08 52.63,29.08 54.36,30.8 54.36,34.65 55.06,35.36 58.79,35.36 60.65,37.21 63.94,37.21 65.03,38.3 74.45,38.3 80.55,44.39 v1(80.55,45.61)
  BOTTOM w0.508: v1(47.22,30.2) 46.69,29.66 37.23,29.66 36.05,30.84 36.05,35.94 35.29,36.7 35.29,41.4 32.56,44.13 32.56,54.62 46.36,68.42 46.36,70.08 48.77,72.49 48.77,76.22 44.28,80.72 44.28,93.92 50.08,99.71 58.7,99.71 68.98,110 71.08,110 74.81,113.73 75.8,113.73 81.9,119.83 81.9,121.74 82.99,122.83 82.99,126.26 83.67,126.94 85.32,126.94 85.59,127.21 86.49,127.21 87.06,127.78 89.29,127.78 90.65,126.42 R565.2
  vias: v1(151.62,105.51) v1(152.25,105.68) v1(152.96,98.72) v1(153.14,103.42) v1(153.55,99.03) v1(158.78,77.39) v1(160.18,75.18)
+1.35V_GFX: length 123.6
  BOTTOM w0.14: v2(178.78,160.99) U7.J1
  BOTTOM w0.152: v1(183.51,142.09) 183.5,142.09 183.5,142.91 U3002.T30 ; v1(191.45,133.27) 191.87,133.69 U3002.E19 ; U3002.E16 191.92,131.19 191.91,131.19 v1(191.89,131.19)
  BOTTOM w0.178: U3002.B16 195.26,131.05 196.55,131.05 v2(196.58,131.08)
  BOTTOM w0.203: U3002.T33 183.62,145.49 183.62,146.64 v1(183.69,146.7) ; U3002.B19 195.19,133.69 195.38,133.88 196.54,133.88 v2(196.72,133.7) ; U3002.AB33 178.35,145.47 178.35,146.69 v2(178.49,146.84) ; v2(196.74,128.7) 196.58,128.54 195.28,128.54 U3002.B13 ; v1(181.11,146.81) 181.11,145.47 U3002.W33 ; U5.L1 188.99,162.97 189.7,162.97 U5.L2
  BOTTOM w0.254: U5.D12 197.75,157.41 v2(198.15,157.01) ; U5.G11 196.95,159.81 v2(197.35,159.41) ; U3.L14 214.59,118 v2(214.98,118.4) U3.L13
  BOTTOM w0.305: U7.L2 178.38,159.79 178.38,159.79 v2(178.78,159.39) ; U4.B12 218.6,147.05 v2(218.2,146.65) ; U5.L1 188.86,162.93 188.42,162.93 v2(188.35,162.86) ; v2(172.37,165) 172.01,164.63 171.98,164.6 U7.E10 ; v2(195.6,164.62) U5.N10 ; U5.P11 196.95,165.4 v2(197.33,165.02) 197.72,165.42 U5.P12 ; U3002.AA30 179.29,142.94 v1(178.92,142.57) ; v2(218.2,141.05) U4.C5 ; v2(177.98,161.79) U7.H3 ; v2(210.18,119.2) 210.58,119.6 U3.F12 ; U4.E10 216.2,144.94 216.21,144.93 v2(216.21,144.9) ; v2(170.78,167.39) 170.38,166.99 U7.B12 ; U4.F1 215.4,137.74 v2(215.14,137.48) ; U5.D11 196.95,157.41 v2(197.35,157.01) ; U5.R10 196.15,166.24 v2(195.77,166.62) ; U7.M3 177.58,158.99 v2(177.98,158.59) ; U3.C10 v2(208.58,120.8) U3.D11 ; U4.T3 207.39,139.85 v2(207,140.25) ; v2(189.35,159.41) U5.F1 ; v2(210.2,149.05) U4.M14 ; U3.G14 211.38,118 v2(210.98,117.6) U3.F14 ; v2(216.34,121.81) 216.18,121.66 U3.N10 ; U4.R5 208.2,141.45 v2(207.8,141.05) ; v2(207,149.05) U4.T14 ; v2(214.18,128) 214.58,127.6 U3.L2 ; v2(218.2,138.65) U4.B1 ; v2(207.78,126.4) U3.B3 ; v2(190.15,164.22) U5.M3 ; v2(207.78,125.6) U3.C5 ; v2(219,149.05) U4.B14 ; U3.N5 216.18,125.2 v2(215.78,125.6) ; v2(209.38,117.6) U3.D14 ; U5.B12 197.75,155.82 v2(198.15,156.21) ; U4.G14 214.6,148.65 v2(214.2,148.25) ; U5.G13 v2(198.15,160.21) 197.75,160.61 U5.H12 ; U5.P1 188.92,165.39 v2(188.39,165.39) ; v2(199.92,165.47) 199.4,165.47 U5.P14 ; U5.T14 199.45,167.12 199.88,167.12 v2(199.93,167.17) ; U7.G1 v1(178.78,162.59) 178.39,162.99 U7.G2 ; v2(218.99,118.4) 218.59,118 U3.T14 ; v2(190.15,160.21) U5.G2 ; v2(199.78,159.43) 199.77,159.43 U5.F14 ; v2(190.18,157.02) 190.18,157.04 U5.D3 ; v2(188.58,157.81) 188.58,157.78 U5.D1 v2(189.35,157.81) ; U5.L13 198.55,163.03 v2(198.15,163.42) ; v2(207,147.45) U4.T12 ; U4.G1 214.6,138.24 v2(214.2,137.85) ; v2(190.95,161.81) 190.55,162.21 U5.K3 ; v2(198.97,163.42) 199.35,163.04 U5.L14 ; U4.L1 211.4,138.25 v2(211.8,138.65) ; U4.D1 217,137.84 v2(217.23,137.61) ; U3.B12 207.38,119.6 v2(206.98,120) ; v2(216.58,119.2) 216.98,119.6 U3.P12 ; U5.M12 197.74,163.82 v2(197.34,163.42) 196.95,163.03 U5.L11 ; v2(178,160.19) 177.98,160.19 U7.K3 ; v2(215,140.25) U4.F3 ; U5.R5 v2(192.87,166.22) ; U3.G2 211.38,127.6 v2(210.98,128) ; v2(206.98,118.4) 207.38,118 U3.B14 ; v2(177.18,156.19) 177.58,155.79 U7.T3 ; v2(192.54,164.23) 192.51,164.23 192.15,164.6 U5.N5 ; U4.D11 v2(217.4,145.85) U4.C10 ; U3.D3 208.98,126.8 v2(208.58,127.2) ; U3.R10 217.78,121.2 v2(217.38,120.8) 216.99,120.4 U3.P11 ; v2(209.4,145.85) U4.N10 ; U4.F14 215.4,149.17 v2(215.19,149.37) ; U4.D14 217,148.65 v2(216.6,149.05) ; U3.T12 218.59,119.6 v2(218.99,120) ; U3.L1 214.58,128.4 v2(214.18,128.8) ; U7.B3 177.58,166.99 v2(177.18,167.38) ; v2(216.08,142.51) 216.2,142.4 U4.E5 ; v2(176.38,159.39) U7.L4 ; v2(188.41,167.09) 188.9,167.09 188.95,167.04 U5.T1 ; v2(208.6,147.45) U4.P12 ; U5.F3 190.55,159.02 v2(190.15,159.41) ; U4.G2 214.6,139.04 v2(214.2,138.65) ; v2(208.58,119.2) U3.D12 ; v2(216.6,147.45) U4.D12 ; v2(215.55,129.13) 215.38,128.96 U3.M1 ; v2(211,140.25) 211.4,140.65 U4.L4 ; U7.B1 179.38,166.99 179.51,167.12 v2(179.74,167.12) ; U5.G4 191.35,159.82 v2(190.95,160.21) ; v2(215,146.65) U4.G11 ; v2(176.38,156.19) 175.98,156.59 U7.R5 ; U5.D14 199.35,157.45 v2(199.73,157.83) ; U5.B14 199.35,155.83 v2(199.73,156.21) ; U3.K12 213.79,119.6 v2(214.18,120) ; U3.D1 208.98,128.43 v2(208.57,128.85) ; v2(210.2,139.45) 210.6,139.85 U4.M3 ; U7.D11 171.18,165.39 v2(170.78,165.79) 170.38,165.39 U7.D12 ; U4.G13 214.6,147.85 v2(214.2,147.45) U4.H12 ; U7.M1 179.55,159.36 v2(179.55,159.39) ; U7.F3 v2(177.18,163.39) U7.G4 ; v2(196.55,158.61) 196.15,158.22 U5.E10 ; U3.L4 v2(214.98,126.4) U3.M3 ; v2(208.6,146.65) U4.P11 ; v2(177.98,157.79) 177.58,157.39 U7.P3 ; v2(218.99,126.4) 218.59,126.8 U3.T3 ; v2(177.18,165.79) U7.D3 ; v2(190.95,165.82) U5.P3 ; v2(191.75,156.21) U5.C5 ; U5.K12 197.75,162.23 v2(198.13,162.61) ; v2(175.51,158.66) U7.N5 ; U4.L13 v2(211.8,147.45) U4.K12 ; v2(207,138.65) 207.39,138.25 U4.T1 ; v2(181.39,142.49) 180.98,142.9 U3002.W30 ; v2(188.34,163.69) 188.44,163.8 188.93,163.8 U5.M1 ; U3.R5 217.79,125.2 v2(218.18,125.6) ; U4.H3 213.8,139.85 v2(214.2,140.25) 214.6,140.65 U4.G4 ; U4.P3 209,139.85 v2(208.6,139.45) ; v2(179.78,165.43) 179.22,165.43 U7.D1 ; v2(191.75,163.41) U5.L4 ; U4.P1 208.9,138.25 v2(208.29,137.64) ; U3.H12 212.18,119.6 211.39,118.8 U3.G13 211.38,118.8 v2(210.98,118.4) ; v2(213.4,137.85) U4.J1 ; v2(216.6,140.25) U4.D3 ; v2(216.58,128.8) 216.98,128.4 U3.P1 ; v2(210.2,147.45) U4.M12 ; U7.L1 179.55,160.16 v2(179.55,160.2) ; v2(190.95,161.01) U5.H3 ; U5.M14 199.35,163.8 v2(199.73,163.42) ; U3.B1 v2(206.98,128) ; v2(216.58,127.2) 216.98,126.8 U3.P3 ; U3.G1 211.38,128.4 v2(210.98,128.8) U3.F1 ; v2(197.35,159.41) U5.F12 ; U7.C5 175.95,166.19 v2(175.57,166.57) ; v2(210.2,141.05) U4.N5 ; v2(188.56,160.22) 188.94,159.84 188.95,159.84 U5.G1 ; v2(210.18,127.2) 210.58,126.8 U3.F3 ; v2(215.78,119.2) U3.M12 ; v2(207.8,145.85) U4.R10 ; v2(190.15,155.41) U5.B3 ; v2(211.8,146.65) U4.L11 ; U3.H3 212.18,126.8 v2(211.78,127.2) ; v2(196.55,157.01) 196.15,156.62 U5.C10 ; v2(211,149.05) U4.L14 211.4,148.65 v2(211,148.25) ; v2(208.6,149.05) U4.P14 ; U4.M1 210.6,138.25 v2(211,138.65) 211.4,139.05 U4.L2 ; v2(197.35,166.62) U5.T12 ; U3.G11 211.38,120.4 v2(210.98,120) ; v2(218.99,128.8) U3.T1 ; U3002.E13 v1(192.31,129.11) ; v2(211.78,126.4) U3.G4 ; v2(215.8,146.65) U4.F12 ; v2(190.95,167.42) U5.T3 ; v2(171.58,165.79) U7.C10 171.99,166.19 v2(172.37,166.57) ; v2(176.37,164.2) 175.98,164.59 U7.E5 ; U3.P14 216.98,117.56 v2(217.28,117.27) ; v2(188.55,156.21) 188.94,155.82 U5.B1 v2(189.35,156.21) ; v2(210.18,120.8) U3.E10 ; v2(199.73,160.22) 199.35,159.84 U5.G14 199.35,159.81 v2(198.95,159.41) ; U4.K3 v2(212.6,139.45) ; v2(218.2,140.25) U4.B3
  BOTTOM w0.356: U7.T1 179.55,156.16 v2(179.55,156.19) ; U7.F1 179.75,163.79 v2(179.83,163.71) ; v2(179.55,157.79) 179.55,157.76 U7.P1
  BOTTOM w0.381: v2(213.38,127.2) 213.78,126.8 U3.K3 ; v2(210.18,125.6) U3.E5 ; v2(214.18,120) 214.58,120.4 U3.L11 ; U3.M14 215.38,118 v2(214.98,117.6) ; U5.E5 192.11,158.22 v2(191.76,158.56)
  vias: v1(165.46,156.1) v1(168.23,165.29) v1(170.02,163.39) v1(178.1,139.98) v1(178.95,140.02) v1(179.73,140.83) v1(179.71,140.02) v1(180.55,140.04) v1(181.39,140.07) v1(182.22,140.83) v1(183.01,140.83) v1(183.88,140.84) v1(183.88,140.05) v1(184.71,140.83) v1(187.22,140.83) v1(188.87,136.19) v1(189.36,134.13) v1(189.67,129.5) v1(189.69,128.14) v1(189.69,127.34) v1(189.68,124.89) v1(190.63,137.43) v1(190.65,136.62) v1(190.63,134.97) v1(190.62,129.94) v1(190.63,127.44) v1(190.6,125.77) v1(197.8,110.76) v1(204.73,164.36) v1(214.1,154.86) v1(215.83,111.4) v1(216.31,162.61) v1(218.88,123.21) v1(218.88,122.45) v1(219.64,123.21) v1(219.64,122.45) v1(222.44,165.98) v1(222.71,158.01) v1(223.18,178.39) v2(168.22,167.02) v2(168.24,163.55) v2(168.24,162.68) v2(168.38,159.36) v2(168.38,156.97) v2(168.39,155.37) v2(169.16,163.37) v2(169.23,159.39) v2(170.01,162.58) v2(170.02,159.39) v2(170.8,163.37) v2(170.78,160.19) v2(170.78,156.99) v2(170.78,155.39) v2(171.58,159.39) v2(171.58,156.99) v2(172.37,158.6) v2(172.37,156.97) v2(215.78,126.4) v3(217.28,156.18) v3(217.66,165.88) v3(217.66,165.09) v3(217.68,164.31) v3(217.96,155.62) v3(218.42,165.09) v3(218.47,164.33) v3(218.55,156.18) v3(218.62,155.04) v3(219.11,155.65) v3(219.21,154.35) v3(219.28,164.33) v3(219.69,154.99) v3(219.84,153.77) v3(220.22,154.43) v3(220.33,153.16) v3(220.61,162.98) v3(220.62,162.22) v3(220.6,161.46)
